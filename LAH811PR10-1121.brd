# Allegro board LAH811PR10-1121.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on GND1: outline of 275 points within 0.2,0.2 292.7,84.45 ; 1 cut-out
GND on IN1: 97.25,50.39 100.89,50.39 102.37,48.91 102.37,32.36 104.04,30.69 105.28,30.69 105.89,30.08 105.89,28.53 105.09,27.73 95.09,27.73 92.68,30.14 92.68,34.4 94.97,36.68 94.97,48.1
GND on IN1: 25.25,35.47 25.25,38.87 30.08,38.87 30.76,38.19 30.76,35.88 30.35,35.47
GND on IN1: 39.68,50.66 38.32,52.02 38.32,60.36 30.91,67.77 30.91,70.61 31.06,70.75 37.95,70.75 38.51,70.51 38.75,69.95 38.75,63.48 43.43,58.79 43.84,57.89 43.55,56.95 41.58,53.94 40.11,50.66
GND on IN1: 249.7,8.08 251.7,8.08 251.72,8.1 257.01,8.1 257.24,8.32 257.24,9.19 257.29,9.24 257.38,9.24 257.84,9.7 257.84,9.71 258.39,10.26 261.85,10.26 262.13,10.54 262.13,11.81 261.31,12.63 261.31,13.19 262.34,14.21 262.34,16.11 260.94,17.5 259.24,17.5 258.94,17.81 258.94,22.02 259.87,22.95 261.75,22.95 264.68,25.88 264.72,25.88 265.54,26.7 269.7,26.7 270.87,27.86 275.44,27.86 275.69,27.61 275.69,1.05 275.45,0.49 274.89,0.25 252.52,0.25 250.42,2.36 250.42,5.29 250.05,5.66 249.62,5.66 249.16,6.11 249.16,7.54 ; 2 cut-outs
GND on IN1: 94.54,8.78 91.88,11.43 81.32,11.43 79.84,12.91 79.84,14.58 91.57,26.31 91.57,26.56 101.51,26.56 102.87,25.2 102.87,11.99 99.66,8.78 ; 2 cut-outs
GND on IN1: 10.02,40.17 8.94,41.25 3.19,41.25 3.19,42.05 2.84,42.9 1.99,43.25 1,43.25 0.44,43.49 0.2,44.05 0.2,48.4 10.39,48.4 11.34,47.45 11.34,44.89 13.26,42.98 13.26,40.23 13.2,40.17
GND on IN1: 213.32,18.78 212.58,19.52 209.3,19.52 205.11,23.72 205.11,25.94 206.37,27.21 206.37,34.89 207.05,35.57 208.02,35.57 214.09,26.09 223.85,20.48 223.85,18.85 223.46,18.45 219.31,18.45 218.68,17.82 215.92,17.82 214.96,18.78
GND on IN1: 18.01,0.25 17.45,0.49 17.21,1.05 17.21,27.79 18.35,27.79 19.83,26.31 19.83,18.04 21.38,16.49 24.03,16.49 28.29,12.23 28.29,6.12 26.99,4.83 25.83,4.83 23.85,2.85 23.75,2.85 21.2,0.3 19.37,0.3 19.37,0.25
GND on IN1: 187.15,73.96 188,74.31 188.35,75.16 188.35,75.75 188.59,76.31 189.15,76.55 196.55,76.55 196.55,75.72 197.55,74.72 198.55,75.72 198.55,76.55 203.95,76.55 205.93,75.73 206.75,73.75 206.75,44.56 206.28,44.09 203.07,44.09 192.39,54.77 190.54,54.77 181.52,63.78 181.52,70.36 181.88,70.72 189.96,70.72 190.64,71.4 190.64,72.17 190.5,72.3 182.89,72.3 183.7,73.11 183.7,73.67 183.98,73.96 ; 1 cut-out
GND on GND2: outline of 275 points within 0.2,0.2 292.7,84.45 ; 3 cut-outs
GND on VCC: outline of 561 points within 0.2,0.2 292.7,84.45
GND on IN2: outline of 227 points within 14.33,23.65 44.78,73.05
GND on IN2: 86.2,24.83 107.13,24.83 110.09,21.86 110.09,13.65 105.77,9.33 78.85,9.33 77.37,10.81 77.37,16
GND on IN2: 259.64,39.83 261.02,41.21 264.61,41.21 265.15,40.67 265.15,38.05 264.92,37.81 259.65,37.81 259.64,37.81
GND on IN2: 18.01,0.25 17.45,0.49 17.21,1.05 17.21,21.74 26.62,21.74 28.66,19.7 28.66,0.69 28.23,0.25
GND on IN2: 253.57,0.25 253.57,0.69 256.22,3.34 259,3.34 259,6.12 270.48,17.6 270.48,19.27 273.82,22.61 275.69,22.61 275.69,1.05 275.45,0.49 274.89,0.25
GND on IN2: 101.97,55.26 105.49,55.26 106.02,54.74 106.02,54.37 101.7,50.05 96.48,50.05 96.02,50.51 96.02,51.38 97.93,53.29 100,53.29
GND on IN2: 183.65,73.66 183.74,73.87 183.95,73.96 187.15,73.96 188,74.31 188.35,75.16 188.35,75.75 188.59,76.31 189.15,76.55 196.55,76.55 196.55,75.72 197.55,74.72 198.55,75.72 198.55,76.55 203.95,76.55 205.93,75.73 206.75,73.75 206.75,43.25 211.95,28.43 225.27,20.12 223.63,18.47 209.55,18.47 202.02,26 202.02,45.23 201.68,45.57 197.23,45.57 197.23,41.9 196.21,40.88 194.02,40.88 187.45,47.45 187.45,52.06 179.42,60.08 177.45,60.08 174.61,62.92 174.61,68.96 175.45,68.96 176.3,69.31 176.65,70.16 176.65,72.56 176.74,72.77 176.95,72.85 182.95,72.85 183.45,73.06 183.65,73.56 ; 4 cut-outs
GND on GND3: outline of 275 points within 0.2,0.2 292.7,84.45 ; 4 cut-outs
GND on IN3: 176.65,72.56 176.74,72.77 176.95,72.85 182.95,72.85 183.45,73.06 183.65,73.56 183.65,73.66 183.74,73.87 183.95,73.96 187.15,73.96 188,74.31 188.35,75.16 188.35,75.75 188.59,76.31 189.15,76.55 196.55,76.55 196.55,75.72 197.55,74.72 198.55,75.72 198.55,76.55 203.95,76.55 205.93,75.73 206.75,73.75 206.75,43.25 206.79,41.88 206.9,40.51 205.01,40.51 202.78,42.74 201.21,42.74 194.61,49.34 193.25,49.34 181.65,60.95 176.95,60.95 174.73,63.17 174.73,68.96 175.45,68.96 176.3,69.31 176.65,70.16 ; 4 cut-outs
GND on IN3: 205.49,26.39 206.59,27.48 206.59,34.46 207.82,35.69 207.98,35.69 221.32,21.37 240.88,21.96 240.88,19.39 238.54,17.05 216.12,17.05 214.92,15.84 207.2,15.84 205.31,13.96 203.93,13.96 203.93,20.16 203.94,20.17 203.94,20.89 205.49,22.44
GND on IN3: 34.68,31.4 33.14,32.95 33.14,33.29 34.34,34.49 34.34,40.91 37.55,44.12 38.76,44.12 39.27,38.27 41.21,32.73 40.95,32.73 40.92,32.76 39,32.76 37.64,31.4
GND on IN3: 17.21,7.42 17.21,29.7 16.86,30.55 16.01,30.9 10.51,30.9 9.95,31.14 9.71,31.7 9.71,35.38 10.82,35.38 12.86,33.35 15.88,33.35 18.6,30.63 18.6,29.46 21.62,26.43 24.77,26.43 25.33,25.88 28.18,23.02 25.19,23.02 24.31,22.14 24.31,21.46 25.48,20.29 25.48,16.83 28.48,13.84 28.48,11 24.89,7.42
GND on IN3: 39.71,49.83 38.54,51 38.54,59.59 33.91,64.22 28.97,64.22 24.96,68.23 22.73,68.23 21.87,69.09 21.87,70.75 37.95,70.75 38.51,70.51 38.75,69.95 38.75,63.48 43.43,58.79 43.84,57.89 43.55,56.95 41.37,53.56 39.84,49.83
GND on IN3: 25.25,35.47 25.25,38.84 25.28,38.87 30.76,38.87 30.76,38.87 30.76,35.47
GND on IN3: outline of 114 points within 85.27,6.68 105.18,17.09 ; 1 cut-out
GND on GND4: outline of 275 points within 0.2,0.2 292.7,84.45 ; 1 cut-out
VIN_AUX on TOP (solid shape): 205.32,72.46 205.32,68.9 205.07,68.65 200.62,68.65 199.86,69.41 197.48,69.41 196.84,68.78 196.05,68.78 194.78,67.51 194.53,67.51 193.71,68.32 193.71,68.45 194.96,69.69 194.96,70.22 197.58,72.84 204.94,72.84
VIN_AUX on BOTTOM (solid shape): 205.32,72.46 205.32,68.88 205.16,68.71 200.56,68.71 199.86,69.41 197.48,69.41 196.84,68.78 196.05,68.78 194.78,67.51 194.53,67.51 193.71,68.32 193.71,68.45 194.96,69.69 194.96,70.22 195.12,70.39 195.13,70.39 196.65,71.91 196.65,71.92 197.58,72.84 204.94,72.84
(no net) on TOP: 173.24,17.78 175,17.78 175.2,17.58 176.83,17.58 176.92,17.66 176.92,17.89 176.59,18.22 175.54,18.22 174.88,18.88 173.19,18.88 173.14,18.83 173.14,17.88
(no net) on TOP: 172.55,18.87 173,18.87 173.03,18.84 173.03,17.61 173.6,17.05 174.86,17.05 175.21,17.4 176.87,17.4 177,17.27 177,16.67 176.85,16.52 175.91,16.52 175.75,16.36 172.13,16.36 172.09,16.39 172.09,17.68 172.14,17.73 172.14,17.92 172.48,18.25 172.48,18.8
(no net) on TOP: 170.6,17.37 170.52,17.44 169.84,17.44 169.48,17.09 169.48,15.58 171.13,13.93 173.36,13.93 174.11,14.67 174.11,15.11 174.03,15.18 173.17,15.18 173.08,15.27 173.08,15.84 173,15.92 172.23,15.92 172,16.15 172,16.2 171.77,16.43 170.83,16.43 170.6,16.65
(no net) on TOP: 266.4,37.62 265.31,37.62 265.15,37.46 262.6,37.46 262.6,35.74 262.44,35.59 262.44,34.48 262.47,34.44 262.69,34.44 262.74,34.49 262.74,35.57 262.88,35.71 265.32,35.71 265.32,35.71 266.22,35.71 266.28,35.77 266.28,35.94 266.23,36 265.27,36 265.14,36.13 265.14,37.12 265.35,37.33 266.39,37.33 266.42,37.36 266.42,37.6
(no net) on TOP: 266.44,37.72 265.23,37.72 265.15,37.81 259.64,37.81 259.52,37.69 258.47,37.69 258.39,37.77 258.39,37.94 258.46,38.02 259.53,38.02 259.64,38.12 259.64,39.16 259.51,39.29 258.08,39.29 258,39.36 258,40.4 258.05,40.45 259.56,40.45 259.64,40.54 259.64,41.06 259.43,41.26 258.5,41.26 258.42,41.25 258.36,41.2 257.86,41.2 257.52,41.55 257.52,42.13 258.45,42.13 258.84,42.51 259.5,42.51 259.57,42.47 259.6,42.39 259.59,42.35 259.59,41.57 259.59,41.39 259.77,41.21 265.05,41.21 265.2,41.36 265.2,42.35 265.18,42.43 265.14,42.5 265.14,42.65 265.51,43.02 265.75,43.02 265.84,42.95 265.82,42.84 265.47,42.5 265.47,41.36 265.15,41.04 265.15,38.13 265.25,38.03 266.6,38.03 266.84,37.79 266.84,37.53 266.82,37.51 266.64,37.51 266.52,37.62 266.52,37.64
(no net) on BOTTOM: 11.36,43.52 11.36,44.74 11.13,44.98 11.13,46.54 11.27,46.68 12.28,46.68 12.41,46.55 12.41,45.53 12.28,45.41 11.9,45.41 11.65,45.15 11.64,45.15 11.64,43.51 11.61,43.48 11.39,43.48
(no net) on BOTTOM: 24,35.3 25.24,35.3 25.42,35.12 27.8,35.12 27.8,33.47 27.8,33.38 27.96,33.22 27.96,32.16 27.93,32.13 27.71,32.13 27.66,32.18 27.66,33.27 27.57,33.37 25.22,33.37 25.19,33.34 23.92,33.34 23.89,33.37 23.89,33.64 23.94,33.68 25.17,33.68 25.26,33.77 25.26,34.91 25.18,34.99 24.03,34.99 23.98,35.05 23.98,35.28
(no net) on BOTTOM: 14.02,38.04 14.7,38.04 15.13,37.61 19.6,37.61 19.72,37.74 19.72,38.83 19.6,38.96 18.81,38.96 18.4,38.55 17.64,38.55 17.49,38.7 16.88,38.7 16.68,38.91 13.7,38.91 13.6,38.8 13.6,38.78 13.15,38.78 13.15,38.78 12.79,38.42 12.79,38.42 12.79,38.16 12.53,38.16 12.16,37.79 12.16,37.77 11.77,37.77 11.6,37.6 11.6,37.09 12.88,37.09 13.42,37.62 13.78,37.62 13.88,37.73 13.88,37.91
(no net) on BOTTOM: 179.8,44.52 179.8,45.49 179.19,46.1 179.19,47.01 179.41,47.24 179.41,47.69 179.92,48.2 179.92,49.22 179.8,49.34 178.78,49.34 178.64,49.2 178.64,48.34 178.23,47.93 178.23,45.68 178.88,45.03 178.88,44.54 178.79,44.45 178.03,44.45 178.03,44.45 177.09,44.45 177.03,44.39 177.03,43.83 176.88,43.68 176.59,43.68 176.49,43.58 176.49,43.15 176.37,43.03 175.86,43.03 175.7,43.18 175.27,43.18 175.23,43.14 175.23,42.15 175.3,42.08 177.34,42.08 177.6,42.33 177.6,43.12 178.03,43.55 178.83,43.55
(no net) on BOTTOM: 150.36,60.98 150.36,62.55 150.23,62.68 148.07,62.68 147.79,62.96 146.06,62.96 145.94,62.83 145.94,62.29 146.02,62.2 147.65,62.2 147.99,61.87 149.62,61.87 149.82,61.66 149.82,60.98 149.87,60.93 150.31,60.93
(no net) on BOTTOM: 25.16,35.4 25.3,35.4 25.36,35.47 30.7,35.47 30.77,35.39 31.88,35.39 31.92,35.43 31.92,35.58 31.85,35.65 30.95,35.65 30.76,35.84 30.76,36.82 30.92,36.97 32.32,36.97 32.37,37.03 32.37,37.98 32.29,38.06 30.88,38.06 30.76,38.17 30.76,38.75 31.07,39.06 31.59,39.06 31.71,39.18 31.71,39.57 31.59,39.69 30.94,39.69 30.83,39.59 30.83,39.07 30.63,38.87 25.39,38.87 25.2,39.06 25.2,40.11 25.22,40.19 25.26,40.26 25.26,40.41 24.89,40.78 24.65,40.78 24.56,40.71 24.58,40.6 24.93,40.26 24.93,39.27 24.93,39.24 24.93,39.03 25.25,38.7 25.25,35.87 25.08,35.69 23.57,35.69 23.32,35.45 23.32,35.17 23.13,34.98 23.13,34.59 23.16,34.54 23.22,34.55 23.23,34.56 23.27,34.56 23.36,34.61 23.36,34.71 23.44,35.01 23.74,34.96 23.87,34.96 23.92,34.99 23.91,35.05 23.88,35.08 23.88,35.36 23.92,35.4
(no net) on BOTTOM: 261.74,50.35 261.76,50.36 261.76,50.83 261.87,50.94 264.44,50.94 264.91,51.4 265.28,51.4 265.31,51.37 265.56,51.37 265.64,51.46 265.64,51.98 265.6,52.02 264.61,52.02 264.43,52.19 264.05,52.19 263.59,51.73 262.13,51.73 262.12,51.72 261.57,51.72 261.05,51.21 261.05,50.36 261.07,50.35
(no net) on BOTTOM: 147.61,62.08 147.95,61.73 149.53,61.73 149.69,61.57 149.69,60.85 150.78,59.76 150.78,58.08 150.66,57.96 148.54,57.96 148.39,58.11 148.39,60.16 147.96,60.59 146.57,60.59 146.02,60.04 145.13,60.04 144.88,60.29 144.88,62.21 144.96,62.29 145.71,62.29 145.92,62.08
(no net) on IN3: 267.85,53.94 268.35,53.94 268.49,54.08 268.68,54.08 268.8,53.97 268.8,51.29 268.57,51.06 268.57,48.84 268.19,48.46 265.95,48.46 264.81,47.31 264.56,47.31 264.29,47.04 262.83,47.04 262.7,47.18 262.7,47.96 262.71,47.97 262.71,49.58 263.87,50.74 265.32,50.74 265.4,50.66 266.83,50.66 267.23,51.06 267.23,53.07 266.72,53.58 266.72,53.84 267,54.12 267.67,54.12
(no net) on IN3: 265.12,39.71 265.12,38.05 264.93,37.86 259.91,37.86 259.66,38.12 259.66,40.15 260.67,41.17 263.66,41.17
(no net) on IN3: 145.22,55.93 146.82,55.93 147.04,56.15 147.04,56.52 147.67,57.15 147.67,57.57 148.69,58.59 150.32,58.59 150.54,58.37 150.54,58.11 149.82,57.39 149.82,56.94 147.56,54.68 145.17,54.68 145.08,54.77 145.08,55.79
+BATT on BOTTOM (solid shape): 46.32,24.07 46.32,23.94 45.81,23.44 45.81,23.06 49.62,19.25 50.65,19.25 51.7,20.3 51.77,20.3 52.5,19.58 52.64,19.58 53.15,19.07 53.97,19.07 54,19.1 54.89,19.1 54.95,19.04 54.95,17.65 55.19,17.4 56.73,17.4 56.96,17.18 56.96,16.18 57.53,15.62 57.53,13.31 56.61,12.39 55.34,12.39 52.54,9.59 48.48,9.59 42.06,16.01 42.06,20.85 42.1,20.85 42.41,21.15 42.41,21.58 41.49,22.5 41.49,23.18 44.03,25.72 44.67,25.72
+BATT on IN1 (solid shape): 46.32,24.07 46.32,23.82 45.81,23.31 45.81,23.18 49.49,19.5 52.03,19.5 52.41,19.12 52.41,17.21 52.16,16.96 48.73,16.96 41.87,23.82 41.87,24.2 43.91,26.23 44.16,26.23
+BATT on IN2 (solid shape): 46.32,24.07 46.32,23.82 45.81,23.31 45.81,23.18 49.49,19.5 52.03,19.5 52.41,19.12 52.41,17.29 52.09,16.97 45.04,16.97 40.98,21.02 40.98,23.31 43.91,26.23 44.16,26.23
+BATT on IN3 (solid shape): 46.32,24.07 46.32,23.82 45.81,23.31 45.81,23.18 49.49,19.5 52.03,19.5 52.41,19.12 52.41,17.59 52.29,17.47 48.22,17.47 41.87,23.82 41.87,24.2 43.91,26.23 44.16,26.23
+CAM_PWR on TOP: 155.59,64.2 155.41,64.38 155.41,66.87 155.54,67 157.32,67 158.31,67.99 168.26,67.99 169.64,66.62 169.64,65.17 169.47,65 168.53,65 167,66.54 158.76,66.54 157.7,65.47 157.7,64.46 157.44,64.2
+CAM_PWR on BOTTOM: 186.73,49.52 186.73,49.33 186.17,48.77 185.57,48.77 184.78,49.56 184.79,49.56 181.45,52.9 181.45,53.54 181.13,53.85 179.86,53.85 179.54,54.17 179.54,54.93 178.65,55.82 178.65,56.71 177.89,57.47 176.24,57.47 172.99,60.72 170.55,60.72 168.34,62.93 168.34,63.95 168.28,64.01 168.28,66.02 168.39,66.13 169.36,66.13 169.71,65.78 169.71,65.32 171.59,63.44 172.92,63.44 176.86,59.5 177.76,59.5 179.67,57.6 179.67,56.58
+CAM_PWR on BOTTOM: 157.82,63.95 157.95,64.08 157.95,64.71 157.44,65.22 156.43,65.22 156.3,65.09 156.3,64.89 156.17,64.76 155.64,64.76 155.51,64.64 155.51,64.38 155.64,64.25 155.89,64.25 155.94,64.31 156.33,64.31 156.68,63.95
+CAM_PWR_R on BOTTOM: 188.08,48.96 188.18,48.96 188.94,48.2 188.94,47.92 188.28,47.26 186.86,47.26 186.4,47.72 186.4,47.72 186.23,47.89 186.23,48.31 186.93,49.02 187.12,49.02 187.53,48.61 187.71,48.61 187.74,48.63 187.75,48.63
+CHG_SRC_20V on BOTTOM (solid shape): 80.99,19.25 80.99,15.18 81.5,14.67 81.5,13.66 81.37,13.53 78.58,13.53 78.32,13.28 77.81,13.28 77.81,14.04 77.56,14.29 77.31,14.29 77.05,14.04 77.05,13.28 76.54,13.28 76.16,12.9 76.16,12.89 71.87,12.89 71.66,13.09 71.66,13.48 71.79,13.61 72.05,13.61 72.07,13.63 72.07,14.44 72.3,14.67 75.88,14.67 76.16,14.96 76.16,15.82 78.7,15.82 78.7,14.67 78.83,14.55 80.1,14.55 80.35,14.8 80.35,15.69 80.1,15.94 78.83,15.94 78.7,15.82 76.16,15.82 76.16,17.6 76.57,18.01 77.22,18.01 77.6,18.39 77.6,19.28 77.82,19.5 78.96,19.5 78.96,19.5 80.74,19.5
+CHG_VIN_20V on TOP (solid shape): 264.3,35.48 264.3,34.63 265.04,33.89 265.04,31.2 264.91,31.07 264.25,31.07 264.15,31.17 264.15,32.15 263.67,32.63 263.67,33.29 263.54,33.42 263.41,33.42 263.28,33.55 263.28,33.93 263.67,34.31 263.67,35.43 263.74,35.5 264.28,35.5
+CHG_VIN_20V on BOTTOM (solid shape): 26.74,33.17 26.74,31.96 27.12,31.58 27.12,31.1 27,30.98 26.77,30.98 26.74,30.95 26.74,28.92 26.54,28.72 25.34,28.72 25.16,28.9 25.16,29.91 25.28,30.03 25.28,31.46 26.1,32.28 26.1,33.17 26.16,33.23 26.67,33.23
+CHG_VIN_20V on IN3 (solid shape): 27.12,31.58 27.12,30.52 26.68,30.09 25.39,30.09 25.38,30.09 25.22,30.25 25.22,30.9 25.48,31.15 25.48,31.77 25.79,32.09 26.61,32.09
+CHG_VIN_20V on TOP: 25.36,32.2 28.03,32.2 28.41,31.82 28.41,30.29 28.28,30.17 26.25,30.17 25.24,31.18 25.24,32.07
+CHG_VIN_20V on TOP: 39.88,2.61 39.75,2.73 39.75,3.45 39.93,3.63 41.03,3.63 41.14,3.52 41.14,2.63 41.11,2.61
+CHG_VIN_20V on BOTTOM: 74.51,8.2 78.96,8.2 79.21,7.94 94.78,7.94 95.19,7.54 95.9,7.54 96.76,6.67 98.18,6.67 98.76,6.1 103.91,6.1 108.55,10.74 161.89,10.74 163.03,9.59 163.03,3.62 162.9,3.5 159.73,3.5 159.48,3.75 159.48,4.64 156.82,7.29 132.44,7.29 132.42,7.31 109.56,7.31 105.5,3.24 96.89,3.24 95.69,4.44 93.49,4.44 92.4,5.53 75.66,5.53 75.65,5.53 74.52,5.53 74.39,5.66 74.39,8.07
+CHG_VIN_20V on VCC: 28.92,1.22 28.92,10.21 26.63,12.49 26.63,27.86 25.11,29.38 25.11,31.46 25.98,32.33 29.58,32.33 31.21,30.7 31.21,17.24 39.86,8.58 79.74,8.58 80.35,7.96 80.35,5.17 53.4,5.17 53.4,5.17 52.26,4.77 51.51,3.84 50.75,4.77 49.62,5.17 49.61,5.17 48.77,5.17 48.76,5.17 43.28,5.17 43.27,5.17 41.85,4.53 41.22,3.11 41.21,3.11 41.21,1.22
+CHG_VIN_20V on IN2: 160.11,1.21 159.48,1.85 159.48,4.13 159.98,4.64 169.89,4.64 170.78,3.75 196.43,3.75 198.21,5.53 198.82,5.53 199.11,5.82 227.54,5.82 227.98,6.26 241.8,6.26 242.71,7.18 244.79,7.18 246.75,9.14 247.38,9.14 249.05,10.8 249.05,12.43 251.55,14.93 251.55,16.22 254.47,19.14 254.47,21.66 262.73,29.91 262.73,33.77 263.34,34.38 264.48,34.38 265.24,33.62 265.24,27.11 260.59,22.46 260.59,17.49 256.4,13.3 256.4,8.47 249.86,1.93 243.17,1.93 241.92,3.17 236.81,3.17 236.8,3.18 213.89,3.18 213.07,2.35 213.07,1.81 212.42,1.16 210.28,1.16 209.72,1.72 209.72,2.48 209.02,3.18 200.18,3.18 199.79,2.79 199.67,2.68 199.56,2.56 198.21,1.21
+INV_PWR_SRC on TOP: 141.06,65.85 139.03,65.85 138.65,65.47 136.49,65.47 135.85,66.11 135.85,66.62 135.98,66.74 138.27,66.74 138.52,67 138.52,67.76 138.65,67.89 140.81,67.89 141.19,67.51 141.19,65.98
+INV_PWR_SRC on TOP: 112.51,57.62 108.8,61.33 108.8,66.67 109.51,67.38 110.22,67.38 110.48,67.63 111.82,67.63 111.82,64.33 113.5,62.65 118.02,62.65 118.12,62.76 119.57,62.76 119.75,62.58 119.75,59.73 117.65,57.62
+INV_PWR_SRC on BOTTOM: 109.77,64.91 109.21,65.47 108.29,65.47 108.17,65.6 108.17,66.87 108.29,67 109.56,67 109.56,66.99 110.06,66.99 110.28,66.78 110.28,65 110.19,64.91
+INV_PWR_SRC on BOTTOM: 95.85,72.84 97.25,72.84 97.37,72.71 97.37,71.7 97.12,71.44 95.91,71.44 95.69,71.67 95.69,72.67
+INV_PWR_SRC on BOTTOM: 134.96,64.58 134.96,64.08 135.09,63.95 138.14,63.95 138.52,64.33 138.52,67.68 138.24,67.96 123.61,67.96 123.31,67.66 123.31,65.75 121.38,63.82 119.6,63.82 117.84,62.06 117.84,61.62 118.34,61.11 119.23,61.11 119.52,61.4 120.29,61.4 121.57,62.68 121.88,62.68 122.75,63.54 122.77,63.54 124.55,65.32 124.55,66.72 124.96,67.12 137.12,67.12 137.25,67 137.25,64.84 137.12,64.71 135.09,64.71
+INV_PWR_SRC on IN1: 95.7,72.97 103.09,72.97 103.67,72.38 104,72.38 104.26,72.12 104.56,72.12 107.26,69.42 107.69,69.42 107.72,69.45 109.28,69.45 109.55,69.18 110.05,69.18 110.17,69.05 110.17,65.68 109.67,65.17 108.93,65.17 106.62,67.48 106.02,67.48 105.19,68.3 105.19,68.34 102.91,68.34 102.43,68.82 102.43,69.16 100.12,69.16 100.04,69.08 98.34,69.08 95.24,72.18 95.24,72.51
+INV_PWR_SRC on IN3: 97.07,72.74 95.64,72.74 95.49,72.59 95.49,72.26 95.62,72.13 97.09,72.13 97.17,72.2 97.17,72.64
+INV_PWR_SRC_R on BOTTOM: 95.47,69.03 95.14,69.36 93.89,69.36 93.47,68.93 93.47,67.48 93.14,67.15 92.14,67.15 92.01,67.27 92.01,69.05 91.7,69.36 89.63,69.36 89.37,69.61 89.37,71.09 89.55,71.26 96.69,71.26 97.19,70.76 97.19,69.92 96.69,69.92 96.67,69.91 96.42,69.91 96.2,69.69 96.2,69.44 96.18,69.44 96.18,69.08 96.13,69.03
+LCDVDD on BOTTOM (solid shape): 114.57,71.82 115.06,71.82 115.3,71.59 115.3,71.21 115.07,70.98 114.73,70.98 114.62,70.87 114.62,70.26 114.7,70.17 115,70.17 115.08,70.1 115.08,69.51 114.97,69.41 114.03,69.41 113.93,69.51 113.93,69.93 113.73,70.13 113.57,70.13 113.57,70.78 113.57,71.71 113.69,71.83 114.57,71.83
+LCDVDD on TOP: 133.17,64.11 133.17,64.79 133.41,65.04 133.41,65.96 133.31,66.06 132.55,66.06 132.47,66.13 132.47,66.67 132.55,66.74 134.84,66.74 134.91,66.67 134.91,65.79 134.73,65.6 134.73,64.73 134.54,64.54 134.54,64.38 134.27,64.11
+LCDVDD on BOTTOM: 133.87,66.46 133.95,66.54 134.43,66.54 134.48,66.49 134.48,66.03 134.75,65.76 134.75,65.46 134.67,65.37 133.98,65.37 133.87,65.48
+LCDVDD on IN2: 133.36,65.32 133.19,65.5 133.19,65.73 133.04,65.88 115.35,65.88 111.8,69.43 104.9,69.43 104.59,69.74 104.59,71.49 104.78,71.68 106.13,71.68 106.43,71.39 114.07,71.39 114.07,70.62 114.33,70.36 114.33,69.23 115.56,68 116.08,68 117.03,67.05 133.05,67.05 133.09,67 134.58,67 134.96,66.62 134.96,65.5 134.79,65.32
+LCDVDD_R on BOTTOM (solid shape): 105.65,72.8 105.65,72.14 105.63,72.12 104.51,72.12 104.43,72.04 103.61,72.04 103.38,72.27 103.38,72.55 103.82,72.99 105.45,72.99
+P_VCC_R on TOP (solid shape): 166.67,62.79 166.67,62.21 166.87,62.01 167.29,62.01 167.41,61.88 167.41,61.51 167.34,61.44 166.21,61.44 165.35,62.3 165.35,62.93 165.4,62.97 166.49,62.97
+SD_VDD1 on TOP: 17.74,56.2 19.52,56.2 19.78,55.95 19.78,46.17 18.63,45.03 15.58,45.03 14.19,43.63 11.39,43.63 11.27,43.76 11.27,45.41 11.39,45.53 12.28,45.53 14.06,47.31 16.35,47.31 17.49,48.46 17.49,55.95
+SD_VDD1 on BOTTOM: 17.87,56.08 18.51,56.08 18.63,55.95 18.63,54.42 18.51,54.3 18,54.3 17.74,54.55 17.74,55.95
+SD_VDD1 on IN1: 18.25,54.3 18.76,54.3 18.89,54.42 18.89,55.95 18.76,56.08 18.25,56.08 18.12,55.95 18.12,54.42
+SD_VDD1 on IN3: 11.9,45.41 11.14,45.41 11.01,45.28 11.01,44.26 11.14,44.14 11.9,44.14 12.03,44.26 12.03,45.28
+SD_VDD2 on IN3: 12.16,45.28 12.16,44.26 12.28,44.14 12.79,44.14 13.3,44.65 13.3,45.66 13.17,45.79 12.66,45.79
+TBT_L_SVR_IND on BOTTOM (solid shape): 23.54,53.38 26.13,53.38 26.17,53.35 26.17,52.89 26.08,52.66 26.14,52.43 26.14,52.39 26.1,52.35 21.48,52.35 21.26,52.57 21.26,53.4 21.38,53.51 23.41,53.51
+TBT_R_SVR_IND on BOTTOM (solid shape): 266,50.21 266,49.66 265.61,49.27 265.61,49.25 265.42,49.06 265.42,46.85 265.39,46.8 264.43,46.8 263.86,47.37 263.86,49.38 263.97,49.49 263.97,49.72 264,49.76 264.86,49.76 265.35,50.25 265.96,50.25
+TBT_VBUS_L on BOTTOM (solid shape): 12.16,66.74 12.16,64.33 12.03,64.2 10.25,64.2 9.87,64.58 9.87,66.74 10.12,67 11.9,67
+TBT_VBUS_L on BOTTOM (solid shape): 28.1,26.94 28.1,26.44 28.35,26.19 28.35,26.18 28.74,25.78 28.74,22.4 28.97,22.17 28.97,21.94 28.87,21.84 28.74,21.84 28.03,22.55 26.58,22.55 26.42,22.71 26.42,27.08 26.61,27.27 27.77,27.27
+TBT_VBUS_L on IN2 (solid shape): outline of 2135 points within 8.04,21.91 28.79,78.83
+TBT_VBUS_L on BOTTOM: 7.62,75.08 7.55,75.15 7.55,75.37 7.71,75.53 8.5,75.53 8.53,75.55 9.01,75.55 9.24,75.78 10.03,75.78 10.23,75.59 10.23,75.33 10.16,75.27 9.29,75.27 9.1,75.08
+TBT_VBUS_L on BOTTOM: 7.61,77.66 7.55,77.72 7.55,77.95 7.7,78.1 8.49,78.1 8.75,78.36 10.02,78.36 10.22,78.16 10.22,77.91 10.15,77.84 8.74,77.84 8.55,77.66
+TBT_VBUS_L on IN1: 8.55,78.4 8.04,77.89 8.04,75.27 8.27,75.05 9.96,75.05 10.09,75.18 10.09,75.67 9.93,75.83 9.32,75.83 9.05,75.56 8.81,75.56 8.59,75.78 8.59,77.76 8.68,77.85 8.95,77.85 8.99,77.81 9.97,77.81 10.14,77.97 10.14,78.29 10.03,78.4
+TBT_VBUS_L on GND2, GND3: 8.25,75.05 8.09,75.21 8.09,77.94 8.51,78.35 9.99,78.35 10.1,78.24 10.1,75.26 9.89,75.05
+TBT_VBUS_L on VCC: 16.32,40.71 15.97,41.07 15.97,47.15 16.56,47.71 16.81,48.49 16.82,48.49 16.82,63.01 16.81,63.01 16.6,63.71 16.11,64.26 15.97,64.41 15.97,64.94 15.31,65.6 9.34,65.6 8.85,66.09 8.85,69.05 10.63,70.83 10.63,72.31 8.44,74.5 8.36,74.59 8.25,74.64 8.09,74.8 8.09,77.94 8.86,78.71 9.18,78.71 9.23,78.66 12.28,78.66 13.59,75.93 13.93,74.96 14.04,73.94 14.04,71.34 14.04,71.34 14.53,70.27 15.6,69.79 15.6,69.78 37.78,69.78 37.78,63.08 37.86,63 42.75,58.11 42.88,57.83 42.79,57.54 39.88,52.68 38.23,47.27 37.95,45.79 37.8,44.29 37.8,44.29 37.78,42.81 37.85,41.34 22.46,41.34 21.83,40.71
+TBT_VBUS_L_PD on BOTTOM (solid shape): 25.91,33.17 25.91,32.28 25.16,31.53 25.16,31.53 25.16,31.09 25.09,31.03 24.52,31.03 24.4,31.15 24.4,33.05 24.58,33.23 25.85,33.23
+TBT_VBUS_L_PD on IN3 (solid shape): 24.97,33.79 24.97,33.25 29.02,33.25 30.47,31.79 31.01,31.26 31.02,31.24 31.02,30.36 30.82,30.17 29.75,30.17 28.47,31.44 27.54,31.44 27.28,31.71 27.28,32.03 27.23,32.08 27.23,32.09 27.17,32.19 27.07,32.25 27.06,32.25 26.96,32.35 26.88,32.35 26.81,32.42 25.66,32.42 25.09,31.84 25.09,31.37 24.94,31.22 24.45,31.22 24.08,31.6 23.95,31.6 23.69,31.86 23.69,32.9 23.86,33.08 23.99,33.08 24.35,33.44 24.35,33.82 24.49,33.96 24.8,33.96
+TBT_VBUS_L_PD on BOTTOM: 29.16,22.29 29.03,22.42 29.03,26.91 29.05,26.93 29.05,27.46 29.46,27.87 29.46,28.68 29.9,29.12 29.9,30.33 29.59,30.64 29.59,31.01 29.28,31.33 29.28,33.17 29.34,33.23 29.85,33.23 29.91,33.17 29.91,32.22 30.51,31.62 31.35,31.62 32.01,30.96 32.01,26.83 31.85,26.68 31.3,26.68 31.15,26.53 31.15,22.4 31.05,22.29
+TBT_VBUS_L_PD on IN1: 30.39,31.87 29.02,33.25 24.97,33.25 24.78,33.44 24.78,33.78 24.66,33.9 24.24,33.9 24.12,33.78 24.12,33.44 24.12,33.44 23.7,33.02 23.7,31.95 25.39,30.25 29.41,30.25 30.39,31.23
+TBT_VBUS_R on BOTTOM (solid shape): 282.03,66.87 283.73,66.87 283.91,67.05 285.23,67.05 285.28,67 285.28,66.79 285.23,66.74 284.44,66.74 284.16,66.46 282.74,66.46 282.41,66.13 281.67,66.13 281.38,66.43 281.38,66.96 281.47,67.05 281.85,67.05
+TBT_VBUS_R on BOTTOM (solid shape): 284.24,64.56 285.15,64.56 285.26,64.46 285.26,64.33 285.18,64.25 284.34,64.25 284.21,64.13 283.83,64.13 283.71,64 282.51,64 282.17,63.66 282.02,63.66 281.9,63.54 281.62,63.54 281.53,63.63 281.53,64.09 282.03,64.58 282.41,64.58 282.67,64.33 283.6,64.33 283.88,64.61 284.19,64.61
+TBT_VBUS_R on TOP: 282.44,67 283.81,67 283.94,67.12 284.19,67.12 284.32,67 284.32,66.62 284.19,66.49 282.54,66.49 282.16,66.11 281.52,66.11 281.4,66.24 281.4,67 281.52,67.12 282.31,67.12
+TBT_VBUS_R on TOP: 284.19,64.61 284.32,64.48 284.32,64.25 284.16,64.1 283.66,64.1 283.43,63.87 282.87,63.87 282.44,63.44 281.7,63.44 281.55,63.59 281.55,63.92 281.62,64 281.62,64.15 281.64,64.17 281.64,64.29 281.95,64.61
+TBT_VBUS_R on TOP: 263.97,21.23 262.27,21.23 260.58,22.91 260.58,23.5 261.71,24.62 261.71,28.14 262.06,28.49 263,28.49 263.02,28.47 263.46,28.47 265.23,26.7 269.6,26.7 269.73,26.57 269.73,24.87 269.46,24.59 269.46,22.55 269.34,22.43 268.71,22.43 268.69,22.45 265.79,22.45 265.64,22.6 265.34,22.6
+TBT_VBUS_R on BOTTOM: 281.17,60.39 282.16,60.39 283.05,59.5 283.05,58.36 282.79,58.11 281.27,58.11 281.12,58.26 281.12,60.34
+TBT_VBUS_R on IN1: 284.7,67.15 284.82,67.02 284.82,64.2 284.65,64.03 283.5,64.03 282.97,63.49 281.6,63.49 281.4,63.7 281.4,66.92 281.62,67.15
+TBT_VBUS_R on GND2, GND3: 281.67,63.64 281.28,64.03 281.28,66.84 281.52,67.07 284.79,67.07 284.82,67.04 284.82,64.41 284.54,64.13 282.77,64.13 282.29,63.64
+TBT_VBUS_R on VCC: 262.45,18.99 261.84,19.6 261.84,22.06 262.32,22.55 265.47,22.55 270.35,27.42 270.35,60.98 275.07,60.98 276.32,62.22 276.32,64.99 276.82,65.5 276.82,66.64 277.08,66.89 277.08,68.63 276.44,69.27 276.63,69.46 281.57,69.46 282.59,68.44 282.59,67.37 282.89,67.07 284.78,67.07 284.81,67.04 284.81,64.41 284.52,64.13 282.81,64.13 281.83,63.14 281.83,60.69 283.99,58.53 283.99,50.71 283.88,50.6 283.64,50.6 283.64,50.59 282.57,50.11 282.09,49.04 282.08,49.04 282.08,42.65 282.09,42.64 282.28,41.97 282.73,41.43 282.73,31.95 276.78,31.95 276.78,31.95 275.36,31.32 274.72,29.89 274.72,29.89 274.72,18.99
+TBT_VBUS_R on IN2: 284.75,67.15 284.86,67.04 284.86,64.44 284.86,64.44 284.86,64.37 284.52,64.03 282.7,64.03 282.3,63.63 282.28,63.63 282.17,63.52 281.62,63.52 281.34,63.8 281.34,66.81 281.68,67.15
+TBT_VBUS_R_PD on TOP (solid shape): 266.01,35.4 266.01,33.5 265.88,33.37 265.31,33.37 265.24,33.43 265.24,33.88 265.24,33.88 264.49,34.63 264.49,35.49 264.53,35.53 265.88,35.53
+TBT_VBUS_R_PD on TOP (solid shape): 261.13,35.45 261.13,33.67 260.86,33.41 260.81,33.36 260.81,32.95 260.5,32.64 260.5,31.63 260.88,31.25 260.88,29.33 261.37,28.85 261.37,24.66 259.16,24.66 259.16,24.66 259.16,25.19 259.15,25.19 259.15,25.32 259.16,25.32 259.16,25.82 259.15,25.82 259.15,25.95 259.16,25.95 259.16,26.46 259.15,26.46 259.15,26.59 259.16,26.59 259.16,27.09 259.15,27.09 259.15,29.19 259.23,29.19 259.23,29.9 259.15,29.9 259.15,30.8 259.17,30.8 259.17,31.55 259.48,31.86 259.51,31.86 259.51,31.89 259.54,31.92 259.54,33.3 259.55,33.31 259.55,33.83 259.68,33.96 259.89,33.96 260.49,34.56 260.49,35.45 260.54,35.5 261.08,35.5
+TBT_VBUS_R_PD on IN1: 265.88,33.6 265.27,33.6 264.25,34.61 262.98,34.61 261.2,32.83 259.68,32.83 259.55,32.96 259.55,34.49 260.57,35.5 265.01,35.5 265.57,36.06 266,36.06 266.33,35.73 266.33,34.05
+TBT_VBUS_R_PD on IN2: 266.37,34.57 265.88,34.08 264.78,34.08 264.37,34.5 263.34,34.5 261.68,32.83 260.57,32.83 260.44,32.96 260.44,35.25 260.69,35.5 265.14,35.5 265.65,36.01 266.05,36.01 266.37,35.69
+TBT_VBUS_R_PD on IN3: 260.57,32.83 260.44,32.96 260.44,35.25 260.69,35.5 265.14,35.5 265.42,35.22 265.42,34.23 265.24,34.05 264.89,34.05 264.62,34.32 263.78,34.32 262.29,32.83
+UA2_VBAT on TOP (solid shape): 27.9,28.34 27.9,24.91 27.52,24.53 27.52,23.72 27.45,23.64 26.76,23.64 26.63,23.51 25.02,23.51 24.7,23.51 24.6,23.61 24.6,23.72 24.65,23.76 24.7,23.79 24.74,23.82 26.24,23.82 26.3,23.82 26.6,24.12 26.6,24.54 26.86,24.8 26.86,25.81 26.6,26.06 26.6,28.43 26.76,28.59 27.65,28.59
+UA3_VBAT on TOP (solid shape): 274.19,37.68 275.16,37.68 275.17,37.66 275.17,37.03 274.79,36.64 271.31,36.64 271.21,36.54 270.98,36.32 271.14,36.05 271.31,35.88 271.31,33.98 271.27,33.94 271.27,32.01 271.2,31.94 271.08,31.94 271,32.02 271,33.78 270.6,34.18 270.6,35.76 270.35,36.01 270.35,37.56 270.57,37.79 274.07,37.79
ACAV_IN on TOP: 29.54,1.35 30.48,1.35 30.54,1.41 30.54,2.96 30.39,3.12 29.67,3.12 29.5,2.95 29.5,1.39
B+ on BOTTOM (solid shape): 205.32,68.27 205.32,65.6 205.07,65.35 201.99,65.35 201.39,65.96 201.39,68.27 201.51,68.39 205.2,68.39
B+ on BOTTOM (solid shape): 201.51,51.76 201.51,49.28 201.39,49.15 200.12,49.15 199.99,49.28 199.99,51.76 200.24,52.01 201.26,52.01
B+ on BOTTOM (solid shape): 97.25,7.82 99.79,7.82 99.84,7.76 99.84,6.39 99.73,6.29 98.87,6.29 98.34,6.82 96.84,6.82 96.04,7.63 95.28,7.63 94.83,8.07 94.83,8.58 94.96,8.7 96.36,8.7
B+ on BOTTOM (solid shape): 188.51,72.69 188.51,72.54 185.97,69.99 183.35,69.99 183.05,70.3 183.05,70.76 183.3,71.01 183.86,71.01 185.83,72.98 187.88,72.98 187.99,73.09 188.1,73.09
B+ on IN1 (solid shape): 85.39,30.85 85.39,30.84 85.45,30.76 85.53,30.71 85.53,30.7 85.69,30.55 85.69,29.28 78.2,21.79 76.29,21.79 75.75,22.33 75.72,22.41 75.77,22.48 80.39,26.32 83.95,31.16 83.97,31.18 85.05,31.18
B+ on IN2 (solid shape): 85.39,30.85 85.39,30.84 85.45,30.76 85.53,30.71 85.53,30.7 85.69,30.55 85.69,29.28 78.2,21.79 76.29,21.79 75.75,22.33 75.72,22.41 75.77,22.48 80.39,26.32 83.95,31.16 83.97,31.18 85.05,31.18
B+ on IN2 (solid shape): 92.42,25.55 92.42,25.34 92.17,25.09 91.28,25.09 90.9,24.71 90.9,23.18 90.39,22.67 90.39,20.13 90.13,19.88 89.12,19.88 88.74,19.5 88.74,18.87 88.7,18.83 88.7,17.23 88.53,17.06 86.35,17.06 86.25,17.16 86.25,19.63 85.99,19.88 82.39,19.88 82.13,20.13 82.13,20.24 85.79,20.24 85.79,20.19 85.8,20.14 85.82,20.09 85.85,20.04 85.88,20 85.92,19.96 85.96,19.93 86.01,19.91 86.06,19.89 86.11,19.88 86.16,19.88 86.22,19.89 86.27,19.91 86.31,19.93 86.36,19.96 86.4,20 86.43,20.04 86.45,20.09 86.47,20.14 86.48,20.19 86.48,20.24 86.48,20.29 86.46,20.35 86.44,20.39 86.41,20.44 86.38,20.48 86.34,20.51 86.29,20.54 86.24,20.56 86.19,20.57 86.14,20.58 86.08,20.57 86.03,20.56 85.98,20.54 85.94,20.51 85.9,20.48 85.86,20.44 85.83,20.39 85.81,20.35 85.8,20.29 85.79,20.24 82.13,20.24 82.13,20.31 89.32,27.5 90.46,27.5
B+ on IN3 (solid shape): 85.39,30.85 85.39,30.84 85.45,30.76 85.53,30.71 85.53,30.7 85.69,30.55 85.69,29.28 78.2,21.79 76.29,21.79 75.75,22.33 75.72,22.41 75.77,22.48 80.39,26.32 83.95,31.16 83.97,31.18 85.05,31.18
B+ on TOP: 86.2,17.21 86.2,23.18 91.53,28.52 95.34,28.52 95.47,28.39 95.47,26.99 94.83,26.36 94.83,24.71 94.71,24.58 93.05,24.58 92.55,24.07 91.53,24.07 90.26,22.8 90.26,21.4 90.39,21.28 90.39,20.13 88.61,18.36 88.61,17.21 88.36,16.96 86.45,16.96
B+ on TOP: 39.96,1.38 39.83,1.5 39.83,2.14 39.96,2.27 41.1,2.27 41.14,2.23 41.14,1.41 41.1,1.38
B+ on TOP: 35.02,26.23 35.02,23.56 34.76,23.31 34,23.31 33.49,23.82 33.49,25.98 32.22,27.25 28.79,27.25 28.54,27.5 28.54,28.39 28.67,28.52 32.73,28.52
B+ on TOP: 274.16,38.42 275.17,38.42 275.3,38.55 275.3,39.91 275.09,40.12 274.46,40.12 274.03,39.69 274.03,38.55
B+ on BOTTOM: 91.76,74.06 91.76,71.75 92.01,71.49 94.53,71.49 94.66,71.63 94.66,72.63 94.52,72.77 94.11,72.77 92.55,74.34 92.04,74.34
B+ on BOTTOM: 244.16,8.22 247.49,8.22 247.84,7.87 247.84,7.1 247.36,6.62 244.16,6.62 243.83,6.95 243.83,7.89
B+ on BOTTOM: 217.08,14.65 217.77,14.65 217.87,14.55 217.87,13.43 217.54,13.1 217.01,13.1 216.83,13.28 216.83,14.39
B+ on BOTTOM: 32.09,24.83 32.09,23.31 32.22,23.18 35.4,23.18 35.52,23.31 35.52,24.71 35.14,25.09 32.35,25.09
B+ on BOTTOM: 88.1,15.18 87.97,15.31 87.97,16.07 87.85,16.2 86.58,16.2 86.25,16.53 86.25,19.96 86.39,20.1 86.39,20.3 86.15,20.53 77.75,20.53 77.41,20.19 76.75,20.19 76.54,20.4 76.54,21.48 75.83,21.48 75.68,21.63 75.68,22.24 76.14,22.7 76.4,22.7 76.65,22.95 80.87,26.69 84.14,31.28 84.24,31.39 84.65,31.39 85.31,30.73 85.31,29.02 92.67,29.02 92.93,28.77 92.93,27.45 93.74,26.64 93.74,24.83 93.69,24.78 92.42,24.78 92.11,25.09 91.28,25.09 90.9,24.71 90.9,23.18 90.39,22.67 90.39,20.13 90.13,19.88 89.12,19.88 88.74,19.5 88.74,15.31 88.61,15.18
B+ on BOTTOM: 210.33,13.73 214.11,13.73 214.36,13.48 214.36,12.84 213.65,12.13 210.53,12.13 210.1,12.57 210.1,13.51
B+ on IN1: 39.71,2.35 40.35,2.35 40.48,2.23 40.48,1.59 40.35,1.47 39.46,1.47 39.33,1.59 39.33,1.97
B+ on VCC: outline of 126 points within 31.71,1.17 262.45,75.58 ; 3 cut-outs
B+ on IN2: 205.7,57.98 205.58,57.85 202.78,57.85 201.26,56.33 201.26,54.17 202.91,52.52 205.32,52.52 205.7,52.14 205.7,30.68 205.32,30.29 202.66,30.29 202.02,30.93 202.02,46.68 198.59,50.11 198.59,59.53 186.27,71.85 186.27,72.48 186.28,72.5 186.28,72.78 186.5,72.99 191.28,72.99 192.65,71.62 192.65,69.84 196.51,65.98 198.59,65.98 201,68.39 205.2,68.39 205.7,67.89
B+ on IN2: 260.85,10.9 261.58,11.63 261.58,12.13 261.08,12.64 260.57,12.64 259.84,11.92 259.84,11.09 260.04,10.9
B+ on IN2: 274.92,38.55 274.16,37.79 273.9,37.79 273.65,38.04 273.65,38.93 274.41,39.69 274.79,39.69 274.92,39.57
B+ on IN3: 245.64,8.11 245.86,7.9 245.86,7.44 244.85,6.43 243.03,6.43 242.92,6.54 242.92,7.61 243.37,7.61 243.87,8.11
B+ on IN3: 207.38,13.43 207.38,12.92 207.63,12.67 212.31,12.67 212.92,13.28 217.51,13.28 217.51,13.48 217.67,13.63 217.67,14.27 217.44,14.5 208.45,14.5
B+_1.1V_MEM on BOTTOM (solid shape): 99.4,13.15 99.4,11.5 100.93,9.97 100.93,8.25 101.56,7.61 101.56,6.42 101.49,6.34 100.37,6.34 100.14,6.57 100.14,7.69 99.89,7.94 99,7.94 98.9,8.04 98.9,13.15 99.02,13.28 99.28,13.28
B+_3V on BOTTOM: 210.43,13.89 210.28,14.04 210.28,15.33 210.66,15.71 211.72,15.71 212.03,16.02 213.2,16.02 213.5,15.71 214.75,15.71 214.97,15.94 214.97,16.71 215.91,17.65 215.91,19.04 215.96,19.09 216.17,19.09 216.29,18.97 216.29,17.06 216.73,16.63 216.73,14.24 216.37,13.89
B+_CAM on TOP: 165.95,65.47 167.58,65.47 168.11,64.94 168.11,63.57 167.98,63.44 166.84,63.44 166.71,63.57 166.71,64.46 166.59,64.58 166.08,64.58 165.83,64.84 165.83,65.35
B+_CAM on BOTTOM: 165.44,64.58 165.44,64.13 165.6,63.97 165.6,63.95 167.22,63.95 167.35,64.08 167.35,64.46 167.1,64.71 167.1,65.22 166.97,65.35 165.95,65.35 165.83,65.22 165.83,64.97
B+_CAM_R on TOP (solid shape): 180.43,69.54 180.43,67.56 179.88,67 179.1,67 177.27,66.79 175.8,65.67 175.61,65.39 175.44,65.09 174.92,65.09 174.48,64.65 174.38,64.59 174.32,64.49 171.97,62.15 166.99,62.15 166.88,62.26 166.88,62.97 167.04,63.14 168.8,63.14 173.55,67.89 176.24,67.89 178.26,69.91 180.06,69.91
B+_CAM_R on BOTTOM (solid shape): 181.93,69.97 182.49,69.97 182.56,69.89 182.56,68.93 181.75,68.12 178.25,68.12 177.92,68.45 177.92,70.25 178.09,70.43 181.47,70.43
BST1_AUX on BOTTOM (solid shape): 192.75,67.76 192.75,67.7 192.2,67.15 191.3,67.15 190.67,66.51 190.5,66.51 190.13,66.88 190.13,67.1 190.98,67.95 192.56,67.95
BST1_VCCIN on BOTTOM (solid shape): 97.78,47.52 97.78,46.52 97.6,46.35 97.6,45.2 97.4,45 96.71,45 96.7,45.01 96.46,45.01 96.4,45.08 96.4,45.98 96.77,46.35 96.77,47.49 96.82,47.54 97.75,47.54
BST2_AUX on BOTTOM (solid shape): 194.15,66.36 194.15,64.71 193.31,63.87 193.14,63.87 192.7,64.31 192.7,64.46 193.26,65.02 193.26,65.85 193.89,66.49 194.02,66.49
BST2_VCCIN on BOTTOM (solid shape): 97.52,37.84 97.52,35.73 97.14,35.34 96.46,35.34 96.4,35.4 96.4,36.24 96.66,36.49 96.69,36.49 96.84,36.64 96.84,37.84 96.86,37.86 97.5,37.86
BST_0.6V on BOTTOM (solid shape): 203.01,45.32 203.01,44.42 202.91,44.32 202.71,44.32 201.99,43.6 200.5,43.6 200.27,43.83 200.27,44.59 200.39,44.72 202.35,44.72 202.59,44.96 202.59,45.29 202.66,45.36 202.96,45.36
BST_1.1V_MEM on BOTTOM (solid shape): 100.04,16.32 100.04,15.44 99.4,14.8 99.4,13.91 99.28,13.78 99.02,13.78 98.9,13.91 98.9,16.32 99.02,16.45 99.91,16.45
BST_1.1V_MEM_R on BOTTOM (solid shape): 101.44,17.34 101.44,15.44 101.31,15.31 100.42,15.31 100.29,15.44 100.29,17.34 100.42,17.47 101.31,17.47
BST_1.8V on BOTTOM (solid shape): 199.37,61.38 199.37,61.27 197.73,59.63 197.22,59.63 196.58,60.27 196.58,60.32 197.19,60.93 198.59,60.93 199.14,61.47 199.27,61.47
BST_3V on BOTTOM: 216.37,21.22 216.37,19.58 216.27,19.47 216.02,19.47 215.93,19.56 215.93,20.3 215.36,20.87 215.36,21.66 216.12,22.42 216.65,22.42 217.03,22.04 217.03,21.88
BST_3V_R on BOTTOM (solid shape): 216.04,22.91 216.04,22.74 214.88,21.59 214.78,21.59 214.38,21.98 214.38,22.7 215.18,23.5 215.45,23.5
BST_5V on BOTTOM: 25.62,15.18 26,15.18 26.13,15.05 26.13,14.93 26,14.8 23.59,14.8 23.33,15.05 23.33,16.07 23.46,16.2 24.6,16.2
BST_5VB on BOTTOM: 274.5,23.34 273.26,23.34 271.55,21.63 271.55,20.48 271.67,20.36 271.78,20.36 271.89,20.48 271.89,20.91 273.66,22.67 274.59,22.67 274.61,22.69 274.61,23.23
CHG_ADP on BOTTOM: 38.11,4.98 38.05,4.92 37.34,4.92 37.02,5.24 36.89,5.24 36.83,5.3 36.83,5.58 36.82,5.58 36.82,5.67 36.86,5.7 38.07,5.7 38.11,5.66
CHG_BGATE on BOTTOM (solid shape): 63.65,14.17 63.65,11.58 63.37,11.3 62.86,11.3 62.86,11.3 62.38,11.3 62.09,11.59 62.09,11.89 62.7,12.5 62.7,13.78 62.64,13.85 62.64,14.17 62.7,14.23 63.59,14.23
CHG_BST1 on BOTTOM (solid shape): 38.31,8.81 38.31,7.93 37.86,7.49 36.34,7.49 35.91,7.92 35.9,7.92 35.22,7.92 35.17,7.97 35.17,8.11 35.22,8.16 35.98,8.16 36.31,7.84 37.28,7.84 37.39,7.96 37.39,8.88 37.42,8.91 38.2,8.91
CHG_BST2 on BOTTOM (solid shape): 34.08,11.78 34.08,11.75 33.53,11.21 33.53,10.11 33.53,9.49 33.47,9.43 33.33,9.43 33.25,9.5 33.25,11.25 32.96,11.54 32.96,11.57 33.59,12.21 33.64,12.21
CHG_COMP on BOTTOM (solid shape): 30.88,8.41 30.88,7.97 31.04,7.81 31.97,7.81 32.08,7.7 32.08,7.53 32.05,7.5 30.95,7.5 30.69,7.24 30.04,7.24 29.91,7.37 29.91,8.54 30.05,8.69 30.61,8.69
CHG_LG1 on BOTTOM (solid shape): 38.06,10.38 38.06,10.06 37.77,9.77 36.97,9.77 36.34,9.14 35.2,9.14 35.16,9.18 35.16,9.34 35.21,9.39 35.76,9.39 35.82,9.46 36.07,9.51 36.12,9.75 36.46,10.1 36.46,10.28 37.03,10.85 37.58,10.85
CHG_LG1 on IN3 (solid shape): 38.57,11.37 37.81,10.61 37.81,10.36 38.06,10.1 38.06,9.59 37.94,9.47 37.05,9.47 36.79,9.72 36.79,11.12 37.81,12.13 38.57,12.13
CHG_LG1 on IN3: 84.29,15.05 85.31,15.05 85.43,14.93 85.43,14.42 84.67,13.66 83.91,13.66 83.66,13.91 83.66,14.42
CHG_LG2 on TOP (solid shape): 36.89,10.73 36.63,10.46 35.04,10.46 34.93,10.57 34.93,11.12 34.99,11.21 35.01,11.32 35.17,11.47 36.89,11.47
CHG_LG2 on BOTTOM (solid shape): 35.68,11.17 35.68,10.58 35.57,10.48 35.06,10.48 34.73,10.16 34.73,9.49 34.66,9.42 34.52,9.42 34.46,9.49 34.46,10.2 35.04,10.78 35.04,11.37 35.14,11.47 35.37,11.47
CHG_LG2 on TOP: 93.82,15.82 93.94,15.69 93.94,14.67 93.05,13.78 92.29,13.78 92.17,13.91 92.17,15.69 92.29,15.82
CHG_LG2 on BOTTOM: 92.17,15.69 92.17,14.93 92.55,14.55 93.82,14.55 93.94,14.67 93.94,15.69 93.82,15.82 92.29,15.82
CHG_LX1 on TOP (solid shape): 82.41,9.85 82.41,9.32 82.14,9.12 82.12,8.78 79.64,8.78 79.59,8.83 79.59,9.57 79.99,9.97 82.28,9.97
CHG_LX1 on TOP (solid shape): 43.02,9.64 43.02,8.76 42.96,8.7 40.12,8.7 39.9,8.48 39,8.48 38.86,8.61 38.86,9.19 39.11,9.43 39.59,9.43 39.93,9.52 40.2,9.77 42.89,9.77
CHG_LX1 on BOTTOM (solid shape): 84.29,19.25 84.29,14.42 84.55,14.17 85.94,14.17 86.45,13.66 86.45,9.47 86.07,9.09 82.99,9.09 82.61,9.47 80.48,9.47 80.1,9.85 80.1,11.9 80.2,12.01 81.75,12.01 81.88,12.13 81.88,14.8 81.5,15.18 81.5,19.25 81.62,19.37 84.16,19.37
CHG_LX1 on BOTTOM (solid shape): 39.17,9.41 40.51,9.41 40.79,9.13 40.79,8.84 40.08,8.13 39.82,8.13 39.62,8.21 39.42,8.13 38.76,8.13 38.55,8.35 38.55,8.82 38.54,8.83 38.54,9.08 38.43,9.18 37.31,9.18 36.86,8.73 35.21,8.73 35.15,8.79 35.15,8.93 35.22,9 36.52,9 37.14,9.63 38.95,9.63
CHG_LX2 on BOTTOM (solid shape): 91.91,19.37 91.91,10.86 92.29,10.48 93.82,10.48 93.94,10.36 93.94,9.21 93.82,9.09 87.34,9.09 86.96,9.47 86.96,13.66 87.47,14.17 88.23,14.17 89.12,15.05 89.12,19.37 89.24,19.5 91.78,19.5
CHG_LX2 on BOTTOM (solid shape): 34.94,12.64 34.94,10.87 34.33,10.26 34.33,9.47 34.29,9.43 34.12,9.43 34.06,9.49 34.06,10.38 34.27,10.58 34.27,10.89 34.46,11.08 34.46,11.78 33.69,12.54 33.69,12.64 34.28,13.23 34.35,13.23
CHG_LX2 on IN2 (solid shape): 91.66,18.48 91.66,16.07 89.5,13.91 89.12,13.91 89.12,15.05 89.24,15.18 89.24,16.83 89.28,16.86 89.28,18.52 89.5,18.74 91.4,18.74
CHG_LX2 on IN2: 36.46,10.03 37.45,11.02 37.45,12.31 37.05,12.72 35.19,12.72 34.56,12.08 34.56,11.6 34.38,11.42 34.38,11.12 34.3,11.04 34.3,10.63 34.91,10.03
CHG_UG1 on TOP (solid shape): 37.63,8.28 40.17,8.28 40.29,8.16 40.29,7.25 40.17,7.13 37.13,7.13 36.16,8.11 36.16,8.43 36.41,8.69 37.23,8.69
CHG_UG1 on BOTTOM (solid shape): 80.1,15.56 80.1,14.93 79.97,14.8 79.08,14.8 78.96,14.93 78.96,15.56 79.08,15.69 79.97,15.69
CHG_UG1 on BOTTOM (solid shape): 37.25,8.47 37.25,8.1 37.12,7.97 36.34,7.97 35.98,8.32 35.21,8.32 35.16,8.37 35.16,8.5 35.25,8.59 37.13,8.59
CHG_UG1 on IN3: 85.82,11.37 85.82,9.21 86.14,8.89 87.38,8.89 87.59,9.1 87.59,10.74 86.83,11.5 85.94,11.5
CHG_UG1 on IN3: 79.59,15.69 79.59,14.93 79.85,14.67 81.12,14.67 81.75,15.31 81.75,16.07 81.37,16.45 80.35,16.45
CHG_UG2 on BOTTOM (solid shape): 87.72,15.69 87.72,14.8 87.59,14.67 86.96,14.67 86.51,15.12 86.51,15.63 86.7,15.82 87.59,15.82
CHG_UG2 on BOTTOM (solid shape): 34.33,11.4 34.33,11.19 34.14,11 34.14,10.65 33.92,10.43 33.92,9.46 33.88,9.42 33.74,9.42 33.66,9.49 33.66,11.19 34,11.52 34.2,11.52
CHG_UG2 on IN2 (solid shape): 34.33,13.45 34.33,11.12 34.15,10.94 34.15,10.43 34.08,10.36 33.26,10.36 32.96,10.66 32.96,13.68 33.14,13.86 33.92,13.86
CHG_UG2 on IN2: 86.96,16.07 87.72,16.07 87.97,15.82 87.97,14.93 87.21,14.17 86.32,14.17 86.2,14.29 86.2,15.31
CHG_VDDP on IN1 (solid shape): 35.83,10 35.83,8.81 35.78,8.76 35.37,8.76 34.53,9.59 34.53,10.2 34.63,10.3 35.52,10.3
CHG_VDDP on IN3 (solid shape): 34.88,10.41 35.24,10.23 35.61,10.41 36.03,10.41 36.36,10.08 36.36,9.49 36.26,9.39 35.32,9.39 34.96,9.75 34.56,9.75 34.41,9.9 34.41,10.28 34.53,10.41
CHG_VDDP on TOP: 36.22,8.8 36,8.58 35.38,8.58 35.08,8.88 35.08,9.28 35.02,9.34 35.02,10.17 35.18,10.33 36.13,10.33 36.62,9.85 36.62,8.88 36.53,8.8
CHG_VDDP on BOTTOM: 35.07,10.33 35.68,10.33 36.03,9.97 36.03,9.59 35.98,9.54 35.17,9.54 35.07,9.44 34.89,9.44 34.86,9.47 34.86,10.13
CHG_VIN_20V on BOTTOM (solid shape): 77.05,11.5 77.31,11.24 77.56,11.24 77.81,11.5 77.81,12.26 78.32,12.26 78.45,12.13 78.45,11.5 78.58,11.37 79.21,11.37 79.34,11.24 79.34,10.74 79.08,10.48 79.08,9.59 78.96,9.47 76.54,9.47 76.42,9.59 76.42,12.13 76.54,12.26 77.05,12.26
CPU_B+ on TOP (solid shape): 93.05,35.9 93.05,35.5 93.56,34.99 93.56,34.36 93.44,34.23 90.64,34.23 90.51,34.36 90.51,36.01 90.77,36.26 92.69,36.26
CPU_B+ on TOP (solid shape): 93.82,45.17 93.82,44.26 93.69,44.14 90.64,44.14 90.51,44.26 90.51,45.15 91.63,46.27 92.72,46.27
CPU_B+ on BOTTOM (solid shape): 102.83,51.31 102.83,49.15 102.45,48.77 93.75,48.77 93.18,48.2 93.18,45.99 93.14,45.91 93.04,45.9 92.7,45.64 93.08,45.44 93.09,45.45 93.18,45.45 93.18,45.09 93.5,44.77 97.63,44.77 97.88,45.03 98.39,45.03 98.52,44.9 98.52,44.52 98.39,44.39 97.63,44.39 97.56,44.46 95.4,44.46 95.02,44.07 93.4,44.07 93.03,43.71 91.92,43.71 91.72,43.5 91.72,42.68 92.04,42.36 92.77,42.36 93.38,41.75 93.38,39.46 92.99,39.07 92.99,35.37 93.24,35.12 97.45,35.12 97.83,35.5 98.57,35.5 98.64,35.44 98.64,34.88 98.56,34.8 95.09,34.8 94.77,34.49 93.5,34.49 93.05,34.04 91.91,34.04 91.78,33.91 91.78,32.58 93.1,31.26 93.1,29.74 92.9,29.53 85.69,29.53 85.56,29.66 85.56,31.18 85.74,31.36 87.59,31.36 87.72,31.49 87.72,34.61 87.47,34.87 86.32,34.87 86.2,34.99 86.2,36.2 86.39,36.89 86.56,37.57 86.56,37.58 86.77,37.79 90.51,37.79 90.7,37.98 90.7,41.34 90.45,41.6 87.47,41.6 87.28,41.79 87.28,44.46 87.34,44.52 89.12,44.52 89.5,44.9 89.5,50.41 90.59,51.5 102.64,51.5
CPU_B+ on IN2: 93.63,31.82 99.66,31.82 100.42,32.58 100.42,49.73 100.29,49.85 94.71,49.85 91.85,47 91.85,33.6
CPU_B+ on IN3: 93.94,34.37 95.21,34.37 95.34,34.5 95.34,35.13 95.21,35.26 93.94,35.26 93.82,35.13 93.82,34.5
CPU_B+ on IN3: 93.97,44.05 95.43,44.05 95.66,44.28 95.66,44.83 95.54,44.94 93.97,44.94 93.84,44.81 93.84,44.18
CPVEE on TOP (solid shape): 263.6,65.45 263.6,65.34 262.94,64.68 262.94,64.09 262.86,64.01 262.75,64.01 262.7,64.06 262.7,64.19 262.7,64.98 263.24,65.51 263.53,65.51
ENVDD on BOTTOM: 101.73,70.93 101.94,70.73 101.94,69.98 101.22,69.27 99.05,69.27 98.75,69.57 98.75,71.41 98.82,71.48 99.72,71.48 100.26,70.93
HPOL_CONN on BOTTOM: 267.43,62.93 266.73,62.24 266.73,61.47 266.71,61.46 266.1,61.46 266.03,61.54 266.03,62.43 265.58,62.87 265.58,63.25 266.73,64.39 266.73,64.99 266.93,65.19 269.14,65.19 269.28,65.05 269.28,63.16 269.05,62.93
HPOR_CONN on BOTTOM: 271.08,63.04 270.98,62.93 270.98,61.54 270.92,61.47 269.64,61.47 269.52,61.6 269.52,65.05 269.66,65.19 271.77,65.19 271.82,65.14 271.82,63.14 271.72,63.04
HPOUT-L on TOP (solid shape): 262.65,66.54 262.65,66.42 262.65,66.41 262.65,65.75 262.5,65.61 262.47,65.58 262.44,65.54 262.13,65.23 262.13,64.08 262.06,64.01 261.95,64.01 261.88,64.08 261.88,65.37 262.28,65.77 262.27,65.78 262.27,66.08 262.12,66.24 262.12,66.51 262.19,66.59 262.6,66.59
HPOUT-R on TOP (solid shape): 263.23,66.54 263.23,65.75 262.51,65.03 262.51,64.21 262.51,64.2 262.51,64.07 262.46,64.01 262.36,64.01 262.26,64.11 262.26,65.2 262.77,65.71 262.77,66.53 262.83,66.59 263.18,66.59
LX1_AUX on BOTTOM: 193.57,68.2 193.83,67.95 193.83,67.82 189.83,63.82 188.56,63.82 186.04,66.34 186.04,68.22 185.26,69 185.26,69.16 186.12,70.02 186.25,70.02 187.28,68.99 187.63,68.99 188.28,69.64 188.39,69.64 188.74,69.3 188.74,69.18 188.33,68.78 188.33,68.37 190.36,66.34 190.72,66.34 191.38,67 192.24,67 193.45,68.2
LX1_VCCIN on BOTTOM (solid shape): 103.47,45.92 103.47,41.09 102.96,40.58 101.75,40.58 101.12,39.95 101.12,37.91 101.06,37.85 99.98,37.85 98.26,39.57 98.26,41.22 97.12,42.36 95.63,42.36 95.53,42.46 95.53,44.19 95.6,44.26 95.81,44.26 95.81,44.26 98.9,44.26 99.12,44.48 99.12,46.33 98.75,46.7 98.2,46.7 98.2,47.44 98.26,47.5 101.88,47.5
LX2_AUX on BOTTOM (solid shape): 194.4,67.38 194.4,67.25 193.07,65.92 193.07,65.05 192.58,64.57 192.58,64.24 194.76,62.07 195.11,62.07 195.56,62.51 195.71,62.51 196.03,62.2 196.03,62.15 195.13,61.25 194.69,61.25 193.07,59.63 192.5,59.63 189.96,62.17 189.96,63.57 194.02,67.63 194.15,67.63
LX2_VCCIN on BOTTOM (solid shape): 99.91,37.28 103.09,37.28 103.47,36.9 103.47,31.06 103.21,30.8 101.82,30.8 101.18,30.17 101.18,28.52 101.06,28.39 99.53,28.39 98.26,29.66 98.26,31.69 97.25,32.71 95.61,32.71 95.53,32.79 95.53,34.56 95.58,34.61 98.71,34.61 98.9,34.8 98.9,36.84 98.77,36.96 98.26,36.96 98.2,37.03 98.2,37.79 98.32,37.91 99.28,37.91
LX_0.6V on BOTTOM (solid shape): 203.54,46.08 203.54,44.9 203.67,44.77 203.99,44.77 204.94,43.82 205.32,43.82 205.45,43.69 205.45,42.87 205.32,42.74 202.53,42.74 202.25,42.46 201.36,42.46 201.26,42.56 201.26,43.22 201.39,43.35 202.12,43.35 202.78,44.01 202.99,44.01 203.16,44.19 203.16,46.02 203.28,46.14 203.49,46.14
LX_1.1V_MEM on BOTTOM (solid shape): 101.06,18.61 101.06,17.85 100.93,17.72 100.17,17.72 100.04,17.59 100.04,16.83 99.91,16.71 98.9,16.71 98.64,16.45 98.64,12.64 98.59,12.59 98.44,12.59 98.39,12.64 98.39,13.4 97.75,14.04 97.75,14.24 96.69,15.31 95.98,15.31 95.34,15.94 95.34,18.61 95.47,18.74 100.93,18.74
LX_1.8V on BOTTOM (solid shape): 200.28,61.59 200.28,61.5 199.35,60.57 199.35,60.29 200.42,59.23 200.42,57.71 196.24,53.54 191.03,53.54 190.97,53.6 190.97,54.49 191.99,55.5 193.07,55.5 193.96,56.39 193.96,57.66 196.31,60.01 196.51,60.01 197.08,59.44 197.84,59.44 200.09,61.69 200.18,61.69
LX_3V on BOTTOM: 207.61,18.99 209.64,21.02 209.64,22.17 211.93,24.45 212.56,24.45 214.09,22.93 214.09,21.79 215.48,20.39 215.63,20.39 215.74,20.29 215.74,18.79 215.61,18.66 215.48,18.66 215.41,18.74 215.41,19.5 215.15,19.75 209.77,19.75 208.37,18.36 208.24,18.36
LX_5V on BOTTOM: 21.05,14.93 21.17,14.8 22.82,14.8 23.08,14.55 27.27,14.55 27.4,14.42 27.4,14.29 27.27,14.17 25.87,14.17 23.08,11.37 19.78,11.37 19.65,11.5 19.65,15.94 19.78,16.07 20.92,16.07 21.05,15.94
LX_5VB on TOP: 270.47,23.11 273.04,23.11 274,22.14 274,20.97 273.78,20.74 270.49,20.74 270.29,20.95 270.29,22.93
LX_5VB on BOTTOM: 274.26,27.17 271.05,27.17 269.84,25.95 269.84,22.78 270.96,21.66 270.96,19.25 271.06,19.14 271.26,19.14 271.36,19.25 271.36,21.71 273.48,23.82 273.48,25.55 273.75,25.82 274.44,25.82 274.59,25.98 274.59,26.84
MIC2-VREFO-R on TOP (solid shape): 261.83,67.22 261.83,66.54 261.6,66.31 261.6,65.7 261.32,65.42 261.32,64.06 261.26,64.01 261.15,64.01 261.09,64.07 261.09,65.58 261.27,65.76 261.27,66.85 261.18,66.94 260.8,66.94 260.74,67 260.74,67.38 260.8,67.44 261.61,67.44
NB_LID# on TOP: 212.99,1.17 212.01,1.17 211.91,1.27 211.91,2.05 212.07,2.22 213.11,2.22 213.15,2.19 213.15,1.72 213.07,1.64 213.07,1.25
Net_2 on TOP (solid shape): 106.5,41.26 98.5,41.26 98.5,53.26 106.5,53.26
Net_132 on TOP (solid shape): 26.37,9.2 18.37,9.2 18.37,17.2 26.37,17.2
PANEL_PWRGD on BOTTOM (solid shape): 113.09,71.89 113.09,71.52 112.8,71.23 112.8,70.67 112.89,70.59 113.37,70.59 113.39,70.57 113.39,70.2 113.31,70.12 113.08,70.12 113,70.05 112.98,70.05 112.98,69.33 112.99,69.33 112.99,69.17 112.97,69.15 112.97,68.5 112.87,68.39 111.98,68.39 111.85,68.52 111.85,69.51 112,69.51 112,70.52 111.85,70.52 111.85,71.85 112.03,72.03 112.95,72.03
PCH_3.3V_TS_EN_R on BOTTOM: 102.97,68.65 103.44,68.65 103.64,68.46 105.52,68.46 105.76,68.22 105.76,67.74 105.63,67.61 104.88,67.61 104.63,67.35 104.19,67.35 104.09,67.46 104.09,67.75 103.99,67.85 103.55,67.85 103.29,68.11 102.97,68.11 102.9,68.18 102.9,68.58
PD_L_DRAIN1 on TOP (solid shape): 27.8,33.36 25.26,33.36 25.26,35.12 27.8,35.12
PD_L_DRAIN1 on BOTTOM (solid shape): 24.28,35.29 24.31,35.29 24.9,35.29 24.93,35.29 24.98,35.3 25.24,35.3 25.42,35.12 27.8,35.12 27.8,33.47 27.8,33.38 27.96,33.22 27.96,32.16 27.93,32.13 27.71,32.13 27.66,32.18 27.66,33.21 27.66,33.27 27.57,33.37 25.22,33.37 25.19,33.34 23.92,33.34 23.89,33.37 23.89,33.64 23.94,33.68 25.17,33.68 25.26,33.77 25.26,34.91 25.18,34.99 24.03,34.99 23.98,35.05 23.98,35.28 24,35.3 24.24,35.3
PD_L_DRAIN1 on IN2 (solid shape): 27.8,33.37 25.26,33.37 25.26,35.12 27.8,35.12
PD_L_DRAIN1 on IN3 (solid shape): 27.8,33.37 25.26,33.37 25.26,35.12 27.8,35.12
PD_L_DRAIN1 on IN1: 25.26,33.37 25.26,35.12 27.8,35.12 27.8,33.37
PD_L_DRAIN2 on TOP (solid shape): 30.75,33.37 28.16,33.37 28.16,35.1 28.18,35.12 30.75,35.12

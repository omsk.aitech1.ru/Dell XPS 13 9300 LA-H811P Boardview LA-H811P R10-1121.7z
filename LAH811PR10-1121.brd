# Allegro board LAH811PR10-1121.brd (continued)
## Nets (continued)
PD_L_GPIO18: RPD204.1 UPD1.50
PD_L_GPIO19: RPD204.2 UPD1.53
PD_L_PROCHOT#: RPD183.1 RPD185.2 UPD1.40
PD_L_R_PROCHOT#: PR104.1 PR105.1 RPD185.1 RPD186.1
PD_L_SINK_ARB_MASTER_OUT: RPD174.2 UPD1.54
PD_L_SINK_ARB_SLAVE_IN: RPD172.2 RPD189.1 UPD1.55
PD_L_SLAVE_IN: RPD171.1 RPD172.1
PD_L_USB_MUX1_EN: RM1.1 RPD187.1
PD_L_USB_MUX1_EN_R: RPD187.2 RPD190.1 UPD1.16
PD_R_DDM_MUX1_EN: RM18.1 RPD157.1
PD_R_DDM_MUX1_EN_R: RPD157.2 RPD192.1 UPD2.42
PD_R_DRAIN1: UPD2.8 UPD2.15 UPD2.19 UPD2.58
PD_R_DRAIN2: UPD2.7 UPD2.52 UPD2.56 UPD2.57
PD_R_GPIO2: RPD144.2 UPD2.18
PD_R_GPIO4: RPD147.1 UPD2.31
PD_R_GPIO16: RPD147.2 UPD2.48
PD_R_GPIO17: RPD144.1 UPD2.49
PD_R_GPIO18: RPD205.1 UPD2.50
PD_R_GPIO19: RPD205.2 UPD2.53
PD_R_PROCHOT#: RPD184.1 RPD186.2 UPD2.40
PD_R_SINK_ARB_MASTER_OUT: RPD171.2 UPD2.54
PD_R_SINK_ARB_SLAVE_IN: RPD173.2 RPD177.1 UPD2.55
PD_R_SLAVE_IN: RPD173.1 RPD174.1
PD_R_USB_MUX1_EN: RM17.1 RPD188.1
PD_R_USB_MUX1_EN_R: RPD188.2 RPD193.1 UPD2.16
PD_TCP0_LS_EN: RPD126.1 RT83.1
PD_TCP0_LS_EN_R: RPD126.2 UPD1.30
PD_TCP2_LS_EN: RPD134.1 RT94.1
PD_TCP2_LS_EN_R: RPD134.2 UPD2.30
PE: PR1111.2 PR1115.1 PU1100.20
PECI_EC: RE153.2 UC1.CD5
PECI_EC_R: RE153.1 UE1.K13
PM_RSMRST_PWRGD_MIPI60: JMIPI60.42 RC247.2 RC647.2
POWER_SW_IN#: CE104.1 QE25.3 RE184.2 RE187.2 UE1.D5
PRIM_PWRGD: RE245.1 RE461.1 UE1.L7
PROCHOT#_R1: RE158.1 UE1.H13
PROM_BIOS_R: JSPI1.6 R466.1
PS2_CLK1B_TP: C4235.1 D482.3 JTP1.8 R6217.2 RE467.1
PS2_DAT1B_TP: C4234.1 D482.2 JTP1.7 R6218.2 RE468.1
PTP_DIS#: JTP1.6 UE1.F4
PWM1: PU1100.24 PU1201.9
PWM2: PU1100.23 PU1200.9
PWM_FAN1: JFAN1.2 R36.1 UE1.L10
PWM_FAN2: JFAN2.2 R39.1 UE1.L11
PWRBTN#: CE68.2 JAPS1.11 PD600.1 QF1.1 R208.2 RE187.1 SW1.1 SW1.3
PWRBTN#_FPR: JFP1.7 QF1.3 R208.1
REF_1.1V_MEM: PC714.1 PU700.7
REM_DIODE1_N: CE57.2 CE58.2 CE76.1 QE4.3 QE14.1 QE14.2 UE1.A8
REM_DIODE1_P: CE57.1 CE58.1 CE76.2 QE4.1 QE4.2 QE14.3 UE1.A7
REM_DIODE2_N: CE55.2 CE69.2 CE93.1 QE8.1 QE8.2 QE17.3 UE1.A10
REM_DIODE2_P: CE55.1 CE69.1 CE93.2 QE8.3 QE17.1 QE17.2 UE1.A9
REM_DIODE3_N: CE39.1 CE60.2 CE67.2 QE3.1 QE3.2 QE10.3 UE1.B9
REM_DIODE3_P: CE39.2 CE60.1 CE67.1 QE3.3 QE10.1 QE10.2 UE1.B8
REM_DIODE4_N: CE86.1 UE1.A11
REM_DIODE4_P: CE86.2 UE1.B10
RESET_IN#: RE247.2 UE1.C1
RING2: L15.1 RA2.2 UA1.30
RING2_CONN: CA59.1 DA3.1 JHP1.6 L15.2
RREF: RR1.2 UCR1.9
RSVD_1: TP99.1(TP-1) UC1.J3
RSVD_AA35: TP71.1(TP-1) UC1.AA35
RSVD_L34: TP67.1(TP-1) UC1.L34
RSVD_M34: TP68.1(TP-1) UC1.M34
RSVD_W35: TP72.1(TP-1) UC1.W35
RSVD_Y34: TP73.1(TP-1) UC1.Y34
RT_FORCE_PWR: RPD130.1 RPD138.1 RT6.1 RT109.1 UC1.DT34 URT1.B10 URT2.B10
RT_L_FORCE_PWR: RPD130.2 UPD1.43
RT_R_FORCE_PWR: RPD138.2 UPD2.43
RTCRST_ON: Q3.2 RTCR4.1 UE1.F11
RTCRST_ON_POWER: R5779.2 UE1.N10
RTCRST_ON_R: C1132.1 D116.2 Q348.2 R5769.1
RUN_ON#: QE18.2 QE18.3 RE87.1
RUN_ON_EC: RE15.1 RE475.2 UC4.2 UE1.E8
RUN_ON_P: PJTAG9.2 QE18.5 R6169.1 R6170.1 R6181.1 R6199.1 RC731.1 RE14.2 RE15.2 RE460.2 RZ2.1 UC4.4 UZ6.1
RUN_ON_P_1P8VS: R6170.2 UC24.3
RUN_ON_P_3VS: R6169.2 UC30.3
RUN_ON_P_5VBS: R6199.2 U60.3
RUN_ON_P_5VS: R6181.2 UC28.3
RUN_ON_P_R: R81.2 RZ2.2 US1.3 UZ6.4
RUN_ON_R: RC730.2 RC731.2 UC10.2
RUNPWROK: RE448.1 UE1.G3
S_BIO: JUFC1.15 RH750.1
SBIOS_TX: RE206.1 UC1.DK21
SD3_RCOMP: RC20.1 UC1.CJ43
SD_CD#: JP1.9 UCR1.30
SD_CLK: CR13.1 JP1.5 RR4.2
SD_CLK_L: RR4.1 UCR1.17
SD_CMD: CR16.1 JP1.3 RR6.2
SD_CMD_L: RR6.1 UCR1.19
SD_D2: CR18.1 JP1.1 RR9.2
SD_D2_L: RR9.1 UCR1.21
SD_D3: CR17.1 JP1.2 RR8.2
SD_D3_L: RR8.1 UCR1.20
SD_LN0_M: JP1.14 UCR1.25
SD_LN0_P: JP1.13 UCR1.26
SD_LN1_M: JP1.16 UCR1.23
SD_LN1_P: JP1.17 UCR1.22
SD_PWR_EN: R6171.1 UC1.DU12
SD_PWR_EN_R: R666.2 R667.2 R6171.2 UC31.4
SD_RCLK_M: CR10.1 JP1.8 RR2.2
SD_RCLK_M_L: RR2.1 UCR1.15
SD_RCLK_P: CR11.1 JP1.7 RR3.2
SD_RCLK_P_L: RR3.1 UCR1.16
SD_REG2: CR19.1 UCR1.24
SECURE_BIO: RH750.2 UC1.DU16
SIO_EXT_WAKE#: RC671.2 RE482.1 UC1.DK22
SIO_EXT_WAKE#_EC: RE482.2 UE1.M12
SIO_PWRBTN#: R257.1 RH57.2 UE1.K11
SIO_PWRBTN#_R: RH57.1 UC1.CY42
SIO_SLP_A#: CH55.2 JAPS1.6 RH685.2 UC1.DH47
SIO_SLP_S0#: JAPS1.15 R54.1 R649.2 R747.1 RH689.2 RH709.2 UC1.CL45
SIO_SLP_S3#: CH53.2 JAPS1.2 QE15.2 RC730.1 RE460.1 RH683.2 U15.1 UC1.DF47 UC4.1 UC7.1
SIO_SLP_S4#: CH54.2 JAPS1.5 RC695.1 RH684.2 UC1.DC48 UC5.1 UE1.N12
SIO_SLP_S5#: CH57.2 JAPS1.4 RH691.2 UC1.DF45
SIO_SLP_SUS#: CH56.2 RC699.1 RE115.1 RH686.2 RT84.1 RT95.1 UC1.DM49
SIO_SLP_SUS#_EC: RE115.2 UE1.N4
SIO_SLP_WLAN#: CH52.2 Q124.1 Q350.3 RH682.2 UC1.DE49
SLEEVE: L12.1 RA1.2 UA1.31
SLEEVE_CONN: CA58.1 DA1.1 JHP1.5 L12.2
SLP_VCCST_MIPI60_OVRD: RC619.2 RC623.2 RC626.1 UC9.1
SLP_VCCST_OVRD: RC619.1 RC700.1 UC7.4 UC8.3
SLP_WLAN#_GATE: Q124.2 R322.2 RE476.1
SLP_WLAN#_GATE_R: RE476.2 UE1.K10
SLP_WLAN#_M: D23.2 Q124.3 R616.2 RE321.1
SMB_CLK: CC655.1 R725.2 UC1.DK27
SMB_CLK_MIPI60: JMIPI60.48 R210.2 R725.1
SMB_DATA: R726.2 UC1.DP24
SMB_DATA_MIPI60: JMIPI60.50 R311.2 R726.1
SMC_ONOFF_MIPI60_N: C285.1 JMIPI60.40 R257.2 R267.1
SML0_SMBCLK: CC656.1 RH143.1 RT159.2 RT200.2 UC1.DK24
SML0_SMBDATA: RH144.1 RT160.2 RT201.2 UC1.DJ24
SML0B_SMBCLK: RC673.2 UC1.DW33 UE1.D8
SML0B_SMBDATA: RC672.2 UC1.DV33 UE1.E11
SML0BALERT#: RC727.1 UC1.DU33
SML1_SMBCLK: CC657.1 RH606.1 RPD21.2 RPD105.2 RT124.2 RT197.2 UC1.DN22
SML1_SMBDATA: RH607.1 RPD22.2 RPD106.2 RT125.2 RT198.2 UC1.DL22
SN_1.1V_MEM: PC701.1 PR701.2
SN_3V: PC341.1 PR301.2
SNDW_RCOMP: RC16.1 UC1.CV38
SNUB_CHG1: PC236.1 PR215.2
SNUB_CHG2: PC237.1 PR216.2
SOC_SPI_0_CLK: RC734.1 RH687.2 RH719.2 UC1.DB42
SOC_SPI_0_CLK_R: JSPI1.4 R703.1 RH24.2 RH719.1
SOC_SPI_0_CS#0: RH736.2 UC1.DB43
SOC_SPI_0_CS#0_R: JSPI1.5 RH736.1 UH8.1
SOC_SPI_0_CS#1: RH735.2 UC1.DF41
SOC_SPI_0_CS#1_R: JSPI1.1 RH735.1
SOC_SPI_0_CS#2: R702.1 UC1.DB41
SOC_SPI_0_D0: RH640.2 RH641.1 RH643.1 RH720.2 UC1.DD43
SOC_SPI_0_D0_R: JSPI1.2 R700.1 RH23.2 RH720.1
SOC_SPI_0_D1: RH721.2 UC1.DF43
SOC_SPI_0_D1_R: JSPI1.3 R701.1 RH25.2 RH721.1
SOC_SPI_0_D2: RH141.1 RH142.1 RH634.2 RH722.2 UC1.DF42
SOC_SPI_0_D2_R: RH26.2 RH722.1
SOC_SPI_0_D3: RH635.1 RH636.1 RH723.2 UC1.DD41
SOC_SPI_0_D3_R: JSPI1.7 RH27.2 RH723.1
SOC_SVID_ALERT#: RC601.2 UC1.H1
SOC_SVID_CLK: RC605.2 UC1.H2
SOC_SVID_DAT: RC603.2 UC1.H3
SOLC: JEDP1.5 TP118.1(TP-1) UE1.K3
SP7_SDWP: QR1.1 UCR1.29
SPI0_MOSI_SYS_PWROK_MIPI60: C220.1 JMIPI60.36 R260.2 R644.2
SPI_0_CLK_ROM: RH24.1 UH8.6
SPI_0_CLK_TPM: R648.2 R703.2 U712.19
SPI_0_CS#2_TPM: R702.2 U712.20
SPI_0_D0_ROM: RH23.1 UH8.5
SPI_0_D0_TPM: R700.2 U712.21
SPI_0_D1_ROM: RH25.1 UH8.2
SPI_0_D1_TPM: R701.2 U712.24
SPI_0_D2_ROM: RH26.1 UH8.3
SPI_0_D3_ROM: RH27.1 UH8.7
SPK1_DET#: JSPK1.3 RH745.1 UC1.CF49
SPK2_DET#: JSPK2.3 RH746.1 UC1.CC48
SPK_L+: CA110.1 DA8.2 JSPK1.1 LA20.2 UA2.5
SPK_L+_R: CA88.2 LA20.1 UA2.3
SPK_L-: CA109.1 DA9.2 JSPK1.2 LA21.2 UA2.6
SPK_L-_R: CA89.2 LA21.1 UA2.26
SPK_R+: CA111.1 DA14.2 JSPK2.1 LA22.2 UA3.5
SPK_R+_R: CA95.2 LA22.1 UA3.3
SPK_R-: CA112.1 DA15.2 JSPK2.2 LA23.2 UA3.6
SPK_R-_R: CA96.2 LA23.1 UA3.26
SPKR: RA9.1 RH667.1 UC1.CH47
SRTCRST#: CH46.1 RH572.2 UC1.DK46
SSD_DEVSLP: JNGFF1.38 RS380.1 UC1.DU11
SSD_IFDET: RS384.1 UC1.CR42
SSD_PWR_EN: R81.1 UC1.CH48
SSD_SCP#: RE48.1 RE426.1 RE522.1 RS379.2 UE1.H5
SSD_SCP_PWR_EN: RE525.2 UE1.N6 UZ6.2
SUS_ON_EC: RE22.1 RE95.2 UC5.2 UE1.D2
SUS_ON_P: QE26.2 R6229.1 RC695.2 RC736.1 RE21.1 RE22.2 UC5.4 UC23.4
SUS_ON_P_R: R6229.2 UT3.3
SUSCLK: CH49.1 RS382.2 RW8.2 UC1.DF49
SUSCLK_R: RW8.1 UWL1.27 UWL1.A25
SVID_ALERT#: PR1127.2 PR1130.2 RC601.1 RC602.2
SVID_ALERT#_VR: PR1130.1 PU1100.14
SVID_CLK: C4195.1 PR1129.2 PR1132.2 RC605.1 RC606.2
SVID_CLK_VR: PR1132.1 PU1100.12
SVID_DAT: PR1128.2 PR1131.2 RC603.1 RC604.2
SVID_DAT_VR: PR1131.1 PU1100.13
SW_USB20_1_N4: ML16.1 UM2.2
SW_USB20_1_N4_R: D416.2 JUSBC2.A7 ML16.2
SW_USB20_1_N8: ML6.1 UM1.2
SW_USB20_1_N8_R: D408.2 JUSBC1.A7 ML6.2
SW_USB20_1_P4: ML16.4 UM2.1
SW_USB20_1_P4_R: D415.1 JUSBC2.A6 ML16.3
SW_USB20_1_P8: ML6.4 UM1.1
SW_USB20_1_P8_R: D407.1 JUSBC1.A6 ML6.3
SW_USB20_2_N4: ML17.1 UM2.4
SW_USB20_2_N4_R: D418.2 JUSBC2.B7 ML17.2
SW_USB20_2_N8: ML7.1 UM1.4
SW_USB20_2_N8_R: D410.2 JUSBC1.B7 ML7.2
SW_USB20_2_P4: ML17.4 UM2.3
SW_USB20_2_P4_R: D417.1 JUSBC2.B6 ML17.3
SW_USB20_2_P8: ML7.4 UM1.3
SW_USB20_2_P8_R: D409.1 JUSBC1.B6 ML7.3
SWD_CLK_MCU: RW127.2 UW1.1
SWD_DAT_MCU: RW126.2 UW1.24
SYNC: PU1100.19 PU1200.10 PU1201.10
SYS_CFG: RW226.1 RW227.2 UW1.3
SYS_PRES#: JBATT1.7 PR110.2 PR605.1 PU600.5
SYS_PWROK: R644.1 RE157.2 RH594.2 UE1.G4
SYS_PWROK_R: RH594.1 UC1.DP19
SYS_RESET#: CC651.1 JAPS1.13 RC244.1 RC432.1 UC1.DK19
SYS_RESET#_R: RC430.2 RC432.2 UC29.4
SYSPWR_PRES: RE152.2 RE154.2 UE1.B1
TACH_FAN1: D132.2 R37.1 UE1.E3
TACH_FAN2: D12.2 R40.1 UE1.D1
TAP_FW_RDY#: JIO1.31 RE493.1 UE1.M10
TAP_RESET#: JIO1.28 UE1.M11
TAP_SMBCLK: RE483.1 RE535.1 UE1.D7
TAP_SMBCLK_R: JIO1.4 RE535.2
TAP_SMBDAT: RE484.1 RE534.1 UE1.E7
TAP_SMBDAT_R: JIO1.2 RE534.2
TBT_0_AUXN: RT113.1 UC1.AY5
TBT_0_AUXN_R: RT113.2 URT1.M8
TBT_0_AUXP: RT112.1 UC1.AY6
TBT_0_AUXP_R: RT112.2 URT1.L8
TBT_0_LSX_RX: R6172.2 RC691.2 RT165.1 UC1.DK17
TBT_0_LSX_RX_R: RT2.2 RT165.2 URT1.L7
TBT_0_LSX_TX: RT164.1 UC1.DL17
TBT_0_LSX_TX_R: RT1.2 RT164.2 URT1.M7
TBT_0_SBU1: CT206.2 D412.2 JUSBC1.A8 RT118.1 URT1.M10
TBT_0_SBU2: CT207.2 D413.1 JUSBC1.B8 RT119.1 URT1.L10
TBT_0_TRX_C_RD_DTX_N0: CT4.2 URT1.G2
TBT_0_TRX_C_RD_DTX_N1: CT8.2 URT1.E2
TBT_0_TRX_C_RD_DTX_P0: CT3.2 URT1.G1
TBT_0_TRX_C_RD_DTX_P1: CT7.2 URT1.E1
TBT_0_TRX_DTX_N0: CT4.1 UC1.BH2
TBT_0_TRX_DTX_N1: CT8.1 UC1.BF1
TBT_0_TRX_DTX_P0: CT3.1 UC1.BH1
TBT_0_TRX_DTX_P1: CT7.1 UC1.BF2
TBT_0_TRX_RD_DTX_N1: D81.1 JUSBC1.B10 URT1.J11
TBT_0_TRX_RD_DTX_N2: D82.2 JUSBC1.A10 URT1.C11
TBT_0_TRX_RD_DTX_P1: D79.1 JUSBC1.B11 URT1.J12
TBT_0_TRX_RD_DTX_P2: D80.2 JUSBC1.A11 URT1.C12
TBT_0_TTX_C_DRX_N1: CT31.2 JUSBC1.A3
TBT_0_TTX_C_DRX_N2: CT33.2 JUSBC1.B3
TBT_0_TTX_C_DRX_P1: CT30.2 JUSBC1.A2
TBT_0_TTX_C_DRX_P2: CT32.2 JUSBC1.B2
TBT_0_TTX_C_RD_DRX_N0: CT2.2 URT1.J2
TBT_0_TTX_C_RD_DRX_N1: CT6.2 URT1.C2
TBT_0_TTX_C_RD_DRX_P0: CT1.2 URT1.J1
TBT_0_TTX_C_RD_DRX_P1: CT5.2 URT1.C1
TBT_0_TTX_DRX_N0: CT2.1 UC1.BB5
TBT_0_TTX_DRX_N1: CT6.1 UC1.AV6
TBT_0_TTX_DRX_P0: CT1.1 UC1.BB6
TBT_0_TTX_DRX_P1: CT5.1 UC1.AV5
TBT_0_TTX_RD_DRX_N1: CT31.1 D77.1 URT1.G11
TBT_0_TTX_RD_DRX_N2: CT33.1 D78.2 URT1.E11
TBT_0_TTX_RD_DRX_P1: CT30.1 D75.1 URT1.G12
TBT_0_TTX_RD_DRX_P2: CT32.1 D76.2 URT1.E12
TBT_2_AUXN: RT117.1 UC1.BG6
TBT_2_AUXN_R: RT117.2 URT2.M8
TBT_2_AUXP: RT116.1 UC1.BG5
TBT_2_AUXP_R: RT116.2 URT2.L8
TBT_2_LSX_RX: R6174.2 RC693.2 RT166.1 UC1.DL34
TBT_2_LSX_RX_R: RT4.2 RT166.2 URT2.L7
TBT_2_LSX_TX: RT167.1 UC1.DK34
TBT_2_LSX_TX_R: RT3.2 RT167.2 URT2.M7
TBT_2_SBU1: CT306.2 D419.2 JUSBC2.A8 RT120.1 URT2.M10
TBT_2_SBU2: CT307.2 D422.1 JUSBC2.B8 RT121.1 URT2.L10
TBT_2_TRX_C_RD_DTX_N0: CT12.2 URT2.G2
TBT_2_TRX_C_RD_DTX_N1: CT16.2 URT2.E2
TBT_2_TRX_C_RD_DTX_P0: CT11.2 URT2.G1
TBT_2_TRX_C_RD_DTX_P1: CT15.2 URT2.E1
TBT_2_TRX_DTX_N0: CT12.1 UC1.BL1
TBT_2_TRX_DTX_N1: CT16.1 UC1.BM2
TBT_2_TRX_DTX_P0: CT11.1 UC1.BL2
TBT_2_TRX_DTX_P1: CT15.1 UC1.BM1
TBT_2_TRX_RD_DTX_N1: D89.1 JUSBC2.B10 URT2.J11
TBT_2_TRX_RD_DTX_N2: D90.2 JUSBC2.A10 URT2.C11
TBT_2_TRX_RD_DTX_P1: D87.1 JUSBC2.B11 URT2.J12
TBT_2_TRX_RD_DTX_P2: D88.2 JUSBC2.A11 URT2.C12
TBT_2_TTX_C_DRX_N1: CT39.2 JUSBC2.A3
TBT_2_TTX_C_DRX_N2: CT41.2 JUSBC2.B3
TBT_2_TTX_C_DRX_P1: CT38.2 JUSBC2.A2
TBT_2_TTX_C_DRX_P2: CT40.2 JUSBC2.B2
TBT_2_TTX_C_RD_DRX_N0: CT10.2 URT2.J2
TBT_2_TTX_C_RD_DRX_N1: CT14.2 URT2.C2
TBT_2_TTX_C_RD_DRX_P0: CT9.2 URT2.J1
TBT_2_TTX_C_RD_DRX_P1: CT13.2 URT2.C1
TBT_2_TTX_DRX_N0: CT10.1 UC1.BF6
TBT_2_TTX_DRX_N1: CT14.1 UC1.BJ5
TBT_2_TTX_DRX_P0: CT9.1 UC1.BF5
TBT_2_TTX_DRX_P1: CT13.1 UC1.BJ6
TBT_2_TTX_RD_DRX_N1: CT39.1 D85.1 URT2.G11
TBT_2_TTX_RD_DRX_N2: CT41.1 D86.2 URT2.E11
TBT_2_TTX_RD_DRX_P1: CT38.1 D83.1 URT2.G12
TBT_2_TTX_RD_DRX_P2: CT40.1 D84.2 URT2.E12
TBT_I2C_INT#: RC687.1 RPD112.2 RPD113.2 RT152.2 RT199.2 UC1.CL39
TBT_L_CC1: CPD3.1 D411.1 JUSBC1.A5 UPD1.24
TBT_L_CC2: CPD2.1 D414.2 JUSBC1.B5 UPD1.26
TBT_L_FLASH_BUSY#: RT8.1 RT9.1 URT1.A9
TBT_L_FLASH_MSTR_SLV: RT15.1 RT16.1 URT1.A5
TBT_L_FLASH_SHARE_EN: RT13.1 RT14.1 URT1.A4
TBT_L_GPIO_5: RT10.1 RT172.1 URT1.B9
TBT_L_GPIO_6: RT11.1 RT12.1 URT1.A8
TBT_L_GPIO_12: RT17.1 RT18.1 URT1.A6
TBT_L_JTAG_TCK: RT64.1 RT218.1 TP46.1(TP-1) URT1.B5
TBT_L_JTAG_TDI: RT63.1 TP45.1(TP-1) URT1.A3
TBT_L_JTAG_TDO: RT97.1 TP48.1(TP-1) URT1.C5
TBT_L_JTAG_TMS: RT65.1 TP47.1(TP-1) URT1.C3
TBT_L_PERST#: RT59.1 RT162.1 URT1.B8
TBT_L_RBIAS: RT19.2 URT1.L4
TBT_L_RESET#: QT1.3 RT226.1 RT227.1 URT1.L11
TBT_L_ROM_CLK: JDB3.2 URT1.C7 UTS1.6
TBT_L_ROM_CS#: JDB3.5 RT20.1 URT1.B6 UTS1.1
TBT_L_ROM_DI: JDB3.3 URT1.C6 UTS1.5
TBT_L_ROM_DO: JDB3.4 RT21.1 URT1.B4 UTS1.2
TBT_L_ROM_HOLD#: RT23.1 UTS1.7
TBT_L_ROM_WP#: RT22.1 UTS1.3
TBT_L_RSENSE: RT19.1 URT1.L5
TBT_L_SMBCLK: RT159.1 RT193.1 URT1.A7
TBT_L_SMBDAT: RT160.1 RT194.1 URT1.B7
TBT_L_TEST_PWR_GOOD: RT7.2 URT1.B3
TBT_L_THERMDA: TP6A4.1(TP-1) URT1.M11
TBT_L_XTAL_25_IN: RT53.1 URT1.L9
TBT_L_XTAL_25_IN_R: CT42.1 RT53.2 YT1.1
TBT_L_XTAL_25_OUT: RT54.1 URT1.M9
TBT_L_XTAL_25_OUT_R: CT43.1 RT54.2 YT1.3
TBT_R_CC1: CPD12.1 D420.1 JUSBC2.A5 UPD2.24
TBT_R_CC2: CPD13.1 D421.2 JUSBC2.B5 UPD2.26
TBT_R_FLASH_BUSY#: RT189.1 RT190.1 URT2.A9
TBT_R_FLASH_MSTR_SLV: RT38.1 RT39.1 URT2.A5
TBT_R_FLASH_SHARE_EN: RT36.1 RT37.1 URT2.A4
TBT_R_GPIO_5: RT33.1 RT173.1 URT2.B9
TBT_R_GPIO_6: RT34.1 RT35.1 URT2.A8
TBT_R_GPIO_12: RT40.1 RT41.1 URT2.A6
TBT_R_JTAG_TCK: RT98.1 RT219.1 TP51.1(TP-1) URT2.B5
TBT_R_JTAG_TDI: RT71.1 TP49.1(TP-1) URT2.A3
TBT_R_JTAG_TDO: RT73.1 TP52.1(TP-1) URT2.C5
TBT_R_JTAG_TMS: RT72.1 TP50.1(TP-1) URT2.C3
TBT_R_PERST#: RT62.1 RT163.1 URT2.B8
TBT_R_RBIAS: RT50.2 URT2.L4
TBT_R_RESET#: QT2.3 RT175.1 RT224.1 URT2.L11
TBT_R_ROM_CLK: JDB4.2 URT2.C7 UTS2.6
TBT_R_ROM_CS#: JDB4.5 RT42.1 URT2.B6 UTS2.1
TBT_R_ROM_DI: JDB4.3 URT2.C6 UTS2.5
TBT_R_ROM_DO: JDB4.4 RT43.1 URT2.B4 UTS2.2
TBT_R_ROM_HOLD#: RT45.1 UTS2.7
TBT_R_ROM_WP#: RT44.1 UTS2.3
TBT_R_RSENSE: RT50.1 URT2.L5
TBT_R_SMBCLK: RT196.1 RT200.1 URT2.A7
TBT_R_SMBDAT: RT195.1 RT201.1 URT2.B7
TBT_R_TEST_PWR_GOOD: RT30.2 URT2.B3
TBT_R_THERMDA: TP6A5.1(TP-1) URT2.M11
TBT_R_XTAL_25_IN: RT55.1 URT2.L9
TBT_R_XTAL_25_IN_R: CT45.1 RT55.2 YT2.1
TBT_R_XTAL_25_OUT: RT56.1 URT2.M9
TBT_R_XTAL_25_OUT_R: CT44.1 RT56.2 YT2.3
TCP0_RST#: QT1.1 RPD124.1 RPD169.1 RPD170.1 RT227.2
TCP0_RST#_R: RPD124.2 UPD1.17
TCP2_RST#: QT2.1 RPD132.1 RPD167.1 RPD168.1 RT175.2
TCP2_RST#_R: RPD132.2 UPD2.17
TCRCOMP_DN: RC1.1 UC1.AY1
TCRCOMP_DP: RC1.2 UC1.AY2
THERMTRIP1#: RE124.1 UE1.B12
THERMTRIP2#: CE61.1 QE16.1 RE215.2 UE1.H3
TOUCH_SCREEN_PD#: D468.1 RH654.1 RH655.1 UC1.DT11
TOUCH_SCREEN_PD#_R: D465.2 D468.2 JEDP1.42 QC2.3 RH654.2 RH743.2 TP123.1(TP-1)
TOUCHPAD_INTR#: JIO1.15 JTP1.5 Q351.1 Q351.4 R6214.1
TP_AH10: TP90.1(TP-1) UC1.AH10
TP_AK10: TP89.1(TP-1) UC1.AK10
TP_AM10: TP93.1(TP-1) UC1.AM10
TP_BC10: TP91.1(TP-1) UC1.BC10
TP_BH10: TP94.1(TP-1) UC1.BH10
TP_BW11: TP3.1(TP-1) UC1.BW11
TP_C1: TP59.1(TP-1) UC1.C1
TP_CA11: TP4.1(TP-1) UC1.CA11
TP_CH33: TP92.1(TP-1) UC1.CH33
TP_CL32: TP97.1(TP-1) UC1.CL32
TP_CM33: TP16.1(TP-1) UC1.CM33
TP_CN32: TP98.1(TP-1) UC1.CN32
TP_DA11: TP96.1(TP-1) UC1.DA11
TP_DB10: TP15.1(TP-1) UC1.DB10
TP_DV3: TP19.1(TP-1) UC1.DV3
TP_DV47: TP24.1(TP-1) UC1.DV47
TP_DW3: TP17.1(TP-1) UC1.DW3
TP_DW47: TP23.1(TP-1) UC1.DW47
TP_E1: TP60.1(TP-1) UC1.E1
TP_EN: R6211.1 UE1.H9
TP_EN_R: R6211.2 R6212.2 U713.3
TP_F15: TP7.1(TP-1) UC1.F15
TP_G15: TP8.1(TP-1) UC1.G15
TP_J34: TP95.1(TP-1) UC1.J34
TP_N34: TP88.1(TP-1) UC1.N34
TP_P01: DR12.2 RW1236.1 UW1.10
TP_P17: DR9.2 RW1235.1 UW1.9
TP_P23: DR6.1 UW1.11
TP_P25: DR7.1 UW1.12
TP_P26: DR8.2 UW1.14
TP_R1: TP18.1(TP-1) UC1.R1
TP_WAKE_KBC#: Q351.3 RE449.1 UE1.G2
TPM_GPIO0: R747.2 U712.6
TPM_GPIO0_NU: R54.2 U712.29
TPM_GPP_B17_SMI#_NMI: RC254.2 RC339.2 UC1.CF47
TPM_PIRQ#: RC255.2 RC338.2 UC1.CL47
TPM_PIRQ#_R: R656.2 RC254.1 RC255.1 U712.18
TS_DET#: D486.2 JEDP1.33 R237.1 UC1.CY43
TS_INT#: D471.2 JEDP1.39 R288.1 TP124.1(TP-1) UC1.DV14
TS_RST#: D466.2 JEDP1.41 R245.1 TP125.1(TP-1) UC1.CV47
UART_2_CCTS_DRTS: JUART1.4 RC656.1 UC1.DU22
UART_2_CRTS_DCTS: JUART1.1 RC655.1 UC1.DV22
UART_2_CRXD_DTXD: JUART1.3 R157.2 RC222.1 UC1.DT22
UART_2_CRXD_R_DTXD: JMIPI60.56 R157.1
UART_2_CTXD_DRXD: JUART1.2 R249.2 RC223.1 UC1.DW22
UART_2_CTXD_R_DRXD: JMIPI60.54 R249.1
UART_WAKE#: RW47.2 UWL1.53
UART_WAKE_HOST: RH748.2 RW47.1 UC1.DL38
UPD_L_SMBCLK: RM19.1 UM1.18
UPD_L_SMBDAT: RM20.1 UM1.17
UPD_L_SMBINT#: RE108.1 RPD17.2 UE1.F10
UPD_R_SMBCLK: RM21.1 UM2.18
UPD_R_SMBDAT: RM22.1 UM2.17
UPD_R_SMBINT#: RE109.1 RPD109.2 UE1.F5
UPD_SMBCLK: Q30.1 RE445.1 RE462.1 UE1.C3
UPD_SMBCLK_Q: Q30.6 RE462.2 RM19.2 RM21.2 RPD163.2 RPD165.2 RW1236.2
UPD_SMBDAT: Q30.4 RE446.1 RE463.1 UE1.B4
UPD_SMBDAT_Q: Q30.3 RE463.2 RM20.2 RM22.2 RPD164.2 RPD166.2 RW1235.2
USB2_COMP: RH10.1 UC1.DN5
USB2_ID: RH8.1 UC1.DL6
USB2_VBUSSENSE: RH9.1 UC1.DL11
USB3_CRX_DTX_N2: JDEBUG1.10 UC1.DG9
USB3_CRX_DTX_P2: JDEBUG1.9 UC1.DG7
USB3_CTX_C_DRX_N2: CH45.2 JDEBUG1.7
USB3_CTX_C_DRX_P2: CH44.2 JDEBUG1.6
USB3_CTX_DRX_N2: CH45.1 UC1.DJ3
USB3_CTX_DRX_P2: CH44.1 UC1.DJ5
USB20_N1: JDEBUG1.4 UC1.DN8
USB20_N4: UC1.DK10 UM2.9
USB20_N5: ML18.4 UC1.DL5
USB20_N5_R: D14.1 JFP1.6 ML18.3
USB20_N8: UC1.DN6 UM1.9
USB20_N9: D485.1 JUFC1.38 UC1.DL2
USB20_N10: ML1.1 UC1.DP10
USB20_N10_R: ML1.2 UWL1.69
USB20_P1: JDEBUG1.3 UC1.DP8
USB20_P4: UC1.DJ10 UM2.8
USB20_P5: ML18.1 UC1.DL3
USB20_P5_R: D13.1 JFP1.5 ML18.2
USB20_P8: UC1.DP6 UM1.8
USB20_P9: D484.1 JUFC1.40 UC1.DL1
USB20_P10: ML1.4 UC1.DN10
USB20_P10_R: ML1.3 UWL1.70
USB_OC0#: RH604.1 UC1.DW14
USB_OC1#: RH718.1 RH742.1 UC1.CR41
USB_OC2#: RH603.1 UC1.CT41
USB_OC3#: RH605.1 UC1.CT43
VCI_IN3#: RE244.1 UE1.E4
VFB: PC1103.1 PR1117.1 PR1120.2 PU1100.5
VRACPU_VTEMP: PC1100.1 PR1101.1 PR1204.1 PR1205.1 PU1100.26
VRALERT#: RC688.1 UC1.CN38
VRALERT#_R: D21.1 PR217.1 RC688.2 RC744.1
VSET_5105: CE79.2 RE199.1 UE1.C9
VTT_1.1V_MEM: PC713.1 PU700.5 PU700.8
WAKE#: RH207.1 UC1.DL45
WAKE_BT: DR13.1 RW53.2 UC1.DV24
WIFI_UART_RX: DR1.1 QW2.1 RW1.1
WIFI_UART_RX_R: DR10.2 RW54.1 UW1.16
WIFI_UART_TX: DR2.1 QW2.4 RW43.1
WIFI_UART_TX_R: DR11.2 RW45.1 UW1.17
WLAN_PWR_EN: R533.2 R534.2 U34.3
WLAN_PWR_EN_EC: D23.1 R533.1 R6137.2 RE321.2 RE322.2
WLAN_PWR_EN_PCH: Q350.1 R532.2 R534.1
WLAN_WIGIG60GHZ_DIS#: DZ4.1 RE208.2 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ4.2 RW56.2 UWL1.28
WOV_DMIC_CLK0: RH705.1 UC1.DG36
WOV_DMIC_DATA0: RH706.1 UC1.DG34
XRES_MCU: CW228.2 RW52.1 RW128.2 UW1.7
XTAL_38P4M_IN: CH11.2 RH14.2 RH17.2 YH1.3
XTAL_38P4M_IN_CPU: RH14.1 UC1.DW8
XTAL_38P4M_OUT: CH10.2 RH15.2 RH17.1 YH1.1
XTAL_38P4M_OUT_CPU: RH15.1 UC1.DU8
N04830: PC235.1 PR218.1 PU200.3
N19757307: RA57.2 UA1.2
N20151644: PR200.2 PR202.1
N20151664: PR200.3 PR203.1
N27076067: PC243.1 PR231.2
N30248348: PR211.2 PR221.1
N30252391: PC230.2 PR210.2
N30253802: PC244.1 PR230.2 PR233.1 PR234.1
N30256954: PR220.2 PU200.24
N30258320: PC225.2 PR205.1
N30277718: PD201.1 PD202.1 PR208.1
N35975325: PR224.2 PU200.25
N39629096: LED1.2 R530.2
N39629103: LED2.2 R531.2
N41228936: PR226.1 PU200.27
N49696201: PC1206.1 PR1200.2 PU1200.14
N49776653: CE65.1 RE172.2
N51014739: PR901.2 PU900.7
N52032474: PC501.1 PC502.1 PC503.1 PC504.1 PR511.2 PU500.1
N52343314: RD21.2 UD2.A5
N52343316: RD22.2 UD2.A8
N52343354: RD2.2 UD1.A5
N52343360: RD1.2 UD1.A8
N52360782: RD4.2 UD3.A5
N52360800: RD3.2 UD3.A8
N52360829: RD24.2 UD4.A8
N52416800: PQ205.2 PR223.2 PR227.1
N52576195: RM10.1 UM1.11
N52576366: RM9.1 UM1.15
N52676089: RR10.2 UCR1.28
N52692386: PC1105.2 PR1120.1
N52692507: PC1101.1 PR1102.2 PU1100.25
N52692519: PC1104.1 PR1104.2 PR1106.1 PU1100.28
N52692565: PR1134.1 PU1100.10
N52692863: PR1114.2 PR1125.1 PU1100.15
N52692927: PC1102.1 PR1100.1 PR1103.2 PU1100.27
N52693170: PR1108.2 PR1110.2 PU1100.2
N52693178: PR1107.2 PR1116.2 PU1100.3
N52751344: PC510.1 PR503.2 PU500.8
N52752182: PC500.1 PR507.2
N52752447: PC505.1 PR501.1 PR510.2
N52755459: PC911.1 PR912.2 PU900.8
N52755987: PR907.1 PU900.14
N52759880: PC900.1 PR900.2 PU900.18
N52761358: PC901.1 PR902.2
N52765760: PC1208.1 PR1201.2
N52768180: PC1219.1 PR1202.2 PU1201.14
N52768296: PC1221.1 PR1203.2
N52827933: RT122.1 URT1.J6
N52924590: PC802.1 PC803.1 PC804.1 PC805.1 PR806.2 PU800.1
N52924674: PC810.1 PR802.2 PU800.8
N52928923: PC512.1 PR506.2
N52929663: PC811.1 PR804.2
N52929949: PC912.1 PR910.2
N52995203: PQ600.2 PR603.2 PR604.1
N53135832: CC176.1 RC589.2
N53169467: PC600.1 PR602.2 PU600.7
N53177904: PC910.1 PR904.2
N53193542: PR211.3 PR222.1
N53201443: PC401.1 PC402.1 PC403.1 PC404.1 PC432.1 PL400.2 PL404.2 PU400.1
N53201562: PR400.2 PU400.16
N53201576: PC400.1 PR403.2
N53201602: PR401.2 PU400.11
N53201659: PC405.1 PR406.2 PR407.1
N53201824: PC414.1 PR408.2 PU400.3
N53201840: PR411.1 PU400.14
N53201891: PC415.1 PR410.2
N53202040: PC417.1 PC418.1 PC419.1 PC420.1 PC433.1 PL402.2 PL405.2 PU401.1
N53202160: PR412.2 PU401.16
N53202164: PC416.1 PR415.2
N53202194: PR413.2 PU401.11
N53202247: PC421.1 PR418.2 PR419.1
N53202418: PC430.1 PR420.2 PU401.3
N53202436: PR423.1 PU401.14
N53202478: PC431.1 PR422.2
N53355134: PR1123.1 PU1100.16
N53373804: QM1.2 QM1.3 RC616.2
N53375471: RC627.1 UC9.4
N53408431: C1467.1 U31.10
N53408470: C217.1 U31.12
N53659927: RD23.2 UD4.A5
N54122777: RC623.1 UC8.4
N54819198: RT101.2 URT1.A12
N54819372: RT102.2 URT2.A12
N55030338: RT123.1 URT2.J6
N55957128: CA13.1 CA14.1 CA48.1 RA9.2 RA28.2 RA30.1
N55957255: CA47.1 RA27.2 RA28.1
N55957257: CA46.1 RA8.2 RA27.1
N55962826: CA15.1 UA1.32
N55978423: CA17.2 UA1.38
N55978441: CA20.2 RA10.2 UA1.39
N56357496: RA63.2 UA1.1
N56357525: RA64.1 UA1.33
N56877756: RM12.1 UM2.11
N56877758: RM11.1 UM2.15
N57277748: RC624.1 UC6.4
N57457324: PC1103.2 PR1117.2 PU1100.4
N57485049: PR1204.2 PU1200.11
N57485111: PR1205.2 PU1201.11
N57581670: PC801.1 PR801.2
N57612688: PR908.1 PU900.15
N57652232: PQ100.5 PR100.1 PR103.2 PR104.2
N57652736: PQ100.6 PR102.1
N57652767: PQ100.2 PQ100.3 PR101.2
N57792379: C100.1 JMIPI60.12 R113.2 R114.2
N58351095: JDEBUG2.8 RE193.2 RE428.2
N58555592: CV633.1 DV11.1 R621.2 R624.1
N58555606: CV651.1 DV12.1 R622.2 R623.1
N58555679: QV20.1 R628.2
N58555687: QV20.2 R622.1
N58555721: QV20.3 R652.2
N58555838: QV18.1 R627.2
N58555842: QV18.2 R621.1
N59045842: QE15.3 RE219.1 RE477.2
N59045862: QE16.2 RE219.2
N59074234: CE109.1 RE479.2 UE6.7
N59074258: RE478.2 UE6.3
N59074292: QE19.2 RE480.1 UE6.5
N59591541: C237.1 U34.6
N59636611: C1131.1 D116.1 Q349.2 R2745.1 R5769.2 R5779.1
N59636658: Q348.1 R5768.2
N60434250: CC659.1 RC734.2
N62320917: CS95.1 US1.6
N62322923: CT362.1 UT1.6
N62323625: CT210.1 UT2.6
N62327553: C4189.1 UC24.6
N62327555: C234.1 UC25.6
N62327559: C4205.1 UC28.6
N64510614: C4213.1 U60.6
N65197718: C245.1 U36.6
N65755618: C227.1 UC30.6
N66651145: QW2.3 RW39.1 RW45.2
N67742614: C453.1 R648.1
N67754895: TP148.1(TP-1) UE1.K1
N73050981: QZ20.1 R789.1
N73527472: JNGFF1.54 RS377.1 RS381.1
N73528232: JNGFF1.8 RS379.1
N73529044: JNGFF1.68 RS382.1
N73529838: JNGFF1.69 RS383.2 RS384.2
N73573884: RA82.2 UA3.19
N73644088: CA88.1 UA2.4
N73644091: CA89.1 UA2.1
N73645370: CA90.1 CA103.1 UA2.24
N73645628: CA91.1 CA104.1 UA2.7
N73649539: CA95.1 UA3.4
N73649541: CA96.1 UA3.1
N73649585: CA97.1 CA106.1 UA3.24
N73649611: CA98.1 CA107.1 UA3.7
N73656820: TP156.1(TP-1) UA3.17
N73656823: TP157.1(TP-1) UA3.18
N73656826: RA80.2 UA3.20
N73656829: TP153.1(TP-1) UA2.17
N73656832: TP154.1(TP-1) UA2.18
N73656835: RA79.2 UA2.20
N73928341: C4236.1 U713.6
N74028108: QC2.5 QC2.6 RC147.1
N74740396: RA84.1 UA1.13
N75620288: TP147.1(TP-1) UE1.M4
N77061749: R6225.1 R6226.1 RTCD3.2
N77098291: R6227.2 ULID1.2
N78164634: CW223.1 JWLA1.2 L72.2
N78166986: CW225.1 JWLA2.2 L74.2
N78422576: DR13.2 UWL1.67
N78816294: DR2.2 UWL1.19
N78816296: DR1.2 UWL1.18
N79011622: Q3.1 R271.2
N79012834: QT2.2 RT225.1
N79027926: D132.1 JFAN1.3 R38.1
N79028066: D12.1 JFAN2.3 R41.1
N79087328: QT1.2 RT228.1
N79266901: QE26.5 QE26.6 RD48.2
N79266909: QE26.3 RD47.2
N79384190: C3314.2 QZ10.3 R5867.2 R5868.1
N79384208: QZ11.1 R5868.2
N79413033: Q16.6 R30.2 R633.2
N79413091: Q16.3 R931.2 R932.2
N79476902: CW123.2 UW1.22
N79477480: DR3.2 UW1.8
N79477679: RW1234.2 UW1.2
N79766737: C4247.1 UT3.6
N79796602: QW2.6 RW40.1 RW54.2
N80090458: Q16.5 R633.1
N81124602: QC5.6 RC782.2
N81124608: QC5.2 QC5.3 RC783.2

Pads without a net: DR6 2; DR7 2; DR8 1; DR9 1; DR10 1; DR11 1; DR12 1; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; JAPS1 16 17 18; JEDP1 8 9 11 15 17 21 23 27 29 44; JIO1 11 34; JMIPI60 18 20 22 24 26 28 30 32 34 44 46; JNGFF1 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JP1 11; JUFC1 1 2 4 5 14 16 17 19 21 23 24 26 27 28 30 31 33 37 39; PU200 13 26; PU302 4; PU400 8; PU401 8; PU1100 1 22; RC727 2; RE486 2; RE487 2; RH715 1; RPD131 1; RPD142 1; RPD146 1; RPD155 1; RPD194 1; RPD199 1; RW126 1; RW127 1; RW128 1; RW1237 1; RW1238 1; U7 3; U55 3; U712 3 4 5 7 9 10 11 12 13 14 15 25 26 27 28 30 31; U714 3; UA1 11 42 43 44 45 47; UC1 A4 A5 A7 A9 A12 A33 A47 AC1 AC2 AC3 AC5 AD3 AD4 AE1 AE2 AE3 AE5 AE11 AF10 AJ11 AL3 AL5 AL11 AN3 AN5 AN7 AN9 AN11 AP10 AR5 AR6 AR10 AT1 AT2 AU1 AU2 AV1 AV2 B7 B9 B12 B33 B45 B47 BB1 BB2 BB45 BB47 BB48 BD1 BD2 BD47 BE48 BE49 BF39 BG11 BG39 BJ11 BJ38 BJ39 BJ46 BL10 BL45 BL49 BM36 BP5 BP6 BP36 BP41 BR1 BR2 BT1 BT2 BT5 BT6 BT36 BV5 BV6 C2 C5 C7 C8 C9 C12 C33 C44 CC5 CC6 CC49 CD3 CE6 CE7 CF3 CF5 CG6 CG7 CG32 CJ32 CJ39 CK3 CK4 CK33 CK47 CL3 CL5 CL41 CN42 CN43 CP3 CP5 CR3 CR4 CR39 CR43 CT1 CT2 CT3 CT5 CT6 CT7 CT32 CT38 CV6 CV7 CV32 CV37 CV42 CV48 CY6 CY7 CY35 CY37 CY38 CY39 D1 D4 D7 D8 D9 D12 D14 D33 DA3 DA5 DA6 DA7 DA47 DB37 DB39 DC7 DC9 DD1 DD2 DD3 DD5 DD38 DE3 DE4 DF1 DF2 DF37 DF48 DG38 DG40 DH49 DJ1 DJ2 DJ6 DJ8 DJ11 DJ13 DJ17 DJ34 DJ40 DK11 DK13 DK15 DK31 DK36 DK38 DK40 DL8 DL33 DL36 DL40 DN11 DN13 DN17 DN27 DN33 DN38 DN48 DP1 DP2 DP3 DP5 DP11 DP13 DP15 DP17 DP29 DP34 DP36 DP38 DP40 DP42 DR5 DT2 DT14 DT16 DT18 DT19 DT28 DT33 DT36 DT38 DT41 DU18 DU24 DU29 DU36 DU38 DU41 DU42 DV4 DV6 DV16 DV19 DV28 DV36 DV38 DV41 DW4 DW6 DW12 DW16 DW18 DW19 DW28 DW29 DW30 DW38 DW41 DW42 E16 F6 F10 F13 G6 G8 G10 G11 G13 G34 H5 H34 J8 J11 K6 K10 K13 L6 L8 L10 L11 L13 M8 M11 M13 M38 M39 M48 N46 N47 P10 P38 P39 P42 R48 T42 U47 V38 V43 Y11 Y45 Y49; UC31 3; UCR1 31; UD1 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD2 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD3 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UD4 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; UE1 A12 B13 C11 H2 J3 J6 J8 J12 K4 K9 L9 M6 N3 N9; UE8 1; UM1 6 7 19 20; UM2 6 7 19 20; URT1 A1 A2 L3; URT2 A1 A2 L3; UW1 4 5 6; UWL1 1 2 3 7 8 9 10 11 12 13 14 15 16 21 22 24 25 42 43 44 45 46 47 48 49 50 51 52 64 65 66 A08 A09 A10 A11 A12 A13 A14 A16 A17 A18 A27 A28 A29 A30 A44 A45 A46 A47

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 591 vias
v2: diameter 0.254, hole 0.102, TOP to IN1, 1654 vias
v3: diameter 0.406, hole 0.203, IN1 to IN3, 2897 vias
v4: diameter 0.254, hole 0.102, IN3 to BOTTOM, 1977 vias
v5: diameter 0.457, hole 0.203, TOP to BOTTOM, 1715 vias
v6: diameter 0.406, hole 0.203, TOP to BOTTOM, 113 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 61 vias
v8: diameter 0.254, hole 0.102, IN3 to GND4, 529 vias
v9: diameter 0.254, hole 0.102, GND1 to IN1, 1766 vias
v10: diameter 0.254, hole 0.102, TOP to GND2, 278 vias
v11: diameter 0.254, hole 0.102, TOP to GND1, 842 vias
v12: diameter 0.254, hole 0.102, GND4 to BOTTOM, 2082 vias
v13: diameter 0.254, hole 0.102, GND1 to GND2, 1337 vias
v14: diameter 0.254, hole 0.102, GND3 to BOTTOM, 408 vias
v15: diameter 0.254, hole 0.102, GND3 to IN3, 561 vias
v16: diameter 0.254, hole 0.102, GND3 to GND4, 641 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_VDDQ_EN: length 1.8
  BOTTOM w0.069: RD43.1 199.8,48.91 RD44.2 200,48.18 RD400.1
0.6V_VDDQ_EN_P: length 152.2
  TOP w0.069: v2(171.18,21.82) 171.18,21.83 171.38,22.03 171.38,25.98 172.1,26.7 172.1,29.35 172.62,29.87 181.24,29.87 183.39,32.02 184.98,32.02 186.07,30.93 189.23,30.93 191.83,33.54 191.83,34.51 193.1,35.78 197.6,35.78 197.88,35.5 199.48,35.5 v4(199.5,35.52) ; v1(99.35,21.33) 99.18,21.51 v2(97.3,21.51)
  IN1 w0.061: v2(171.18,21.82) 171.18,21.82 171.18,21.34 171.12,21.28 171.12,20.79 171.08,20.75 171.08,18.67 171.08,15.57 171.7,14.94 171.7,12.99 169.96,11.25 168.64,11.25 167.83,10.45 166.91,10.45 165.85,9.38 148.27,9.38 148.1,9.21 146.27,9.21 145.12,8.07 128.08,8.07 127.85,7.84 115.58,7.84 114.45,8.97 112.91,8.97 112.59,9.29 108.21,9.29 106.15,11.35 105.55,11.35 101.44,15.46 101.44,18.86 98.79,21.51 v2(97.3,21.51)
  BOTTOM w0.069: v4(199.5,35.52) 199.48,35.5 199.48,35.45 199.42,35.39 198.58,35.39 197.88,36.09 197.88,38.37 198.38,38.88 198.38,44.26 199.18,45.05 199.18,45.74 199.45,46.02 200.04,46.02 CD309.1 ; CD309.1 201.12,46.55 201.24,46.67 PU800.11 ; CD309.1 200.41,46.72 RD300.1 200.75,47.66 RD400.2
0.6V_VDDQ_PG: length 3.7
  TOP w0.069: v5(204.81,44.58) 205.44,43.96 v1(205.45,43.96)
  TOP w0.254: v5(204.81,44.58) 204.32,45.08 RD41.2
  BOTTOM w0.254: v5(204.81,44.58) 204.94,44.71 205.21,44.71 PR802.1 204.99,45.17 PU800.5
1.1V_MEM_EN: length 120.6
  TOP w0.069: RC21.2 169.89,9.11 169.66,9.34 169.66,10.15 v3(169.61,10.2) ; v5(102.83,11.88) 102.33,12.39 PR709.1 ; v2(97.35,17.47) 99.25,17.47 v1(99.3,17.52)
  IN1 w0.061: v2(97.35,17.47) 97.35,17.37 v5(102.83,11.88)
  IN2 w0.051: v4(186.78,13.81) 186.73,13.86 186.26,13.86 184.31,11.9 176.35,11.9 175.97,11.52 175.15,11.52 173.86,10.23 169.64,10.23 v3(169.61,10.2) 168.07,10.2 166.29,8.43 112.09,8.43 111.48,7.82 108.04,7.82 v3(107.66,7.43)
  IN3 w0.061: v3(107.66,7.43) 107.66,7.69 103.6,11.75 102.96,11.75 v5(102.83,11.88)
  BOTTOM w0.069: CC707.1 195.85,20.82 195.83,20.85 RC736.2 RC737.1 194.7,21 194.53,21.18 194.3,21.18 194.04,21.43 194.04,22.03 193.58,22.5 192.67,22.5 192.52,22.34 191.53,22.34 191.33,22.55 187.96,22.55 185.94,20.53 185.94,14.64 v4(186.78,13.81)
1.1V_MEM_PG: length 225.4
  TOP w0.069: D487.1 173.18,12.48 v2(173.09,12.57)
  IN1 w0.061: v3(174.86,29.96) 174.86,29.16 175.17,28.86 175.17,26.73 175.4,26.51 175.4,24.38 175.57,24.21 175.57,23.17 175.81,22.93 175.81,16.64 174.93,15.76 174.93,13.78 173.97,12.82 173.58,12.82 173.32,12.57 v2(173.09,12.57)
  IN2 w0.051: v3(174.86,29.96) 174.68,29.78 171.65,29.78 169.38,32.05 164.85,32.05 164.31,32.58 160,32.58 159.46,33.11 159.3,33.11 158.59,33.83 158.59,36.39 158.36,36.62 158.08,36.62 157.6,37.1 157.6,37.81 157.16,38.24 157.16,38.83 158.03,39.69 158.56,39.69 160.54,41.67 160.54,42.69 161.46,43.6 163.17,43.6 163.39,43.82 163.39,44.39 163.75,44.75 v3(163.95,44.75) ; v3(197.27,47.46) 197.6,47.13 197.6,39.57 196.66,38.63 196.66,35.88 196.31,35.53 195.29,35.53 191.89,38.93 191.89,40.94 190.89,41.94 190.89,42.5 189.09,44.3 187.89,44.3 187.62,44.57 186.98,44.57 v3(186.78,44.37)
  IN3 w0.061: v3(197.27,47.46) 198.31,48.51 v4(198.31,48.68) ; v4(101.97,15.11) 101.97,15.11 101.97,15.33 101.68,15.63 101.68,16.64 93.97,24.35 93.97,28.72 92.29,30.4 92.29,44.29 92.99,44.99 92.99,46.41 94.93,48.35 95.67,48.35 96.33,47.69 100.67,47.69 102.32,49.34 115.98,49.34 116.12,49.48 121.26,49.48 122.11,48.63 123.68,48.63 124.16,48.16 135.09,48.16 137.17,50.23 160.47,50.23 160.97,49.73 161.56,49.73 161.91,49.37 161.91,46.78 163.59,45.1 163.59,45.1 v3(163.95,44.75) 164.84,43.86 165.6,43.86 165.8,43.65 166.28,43.65 166.79,44.16 167.62,44.16 167.98,44.53 168.45,44.53 169.18,45.26 170.52,45.26 170.92,45.65 172.63,45.65 172.85,45.43 177.26,45.43 177.66,45.03 180.44,45.03 181.03,45.62 182.77,45.62 183.52,44.86 184.12,44.86 184.61,44.37 v3(186.78,44.37)
  BOTTOM w0.069: v4(101.97,15.11) 101.28,14.42 RD42.2 101.18,14.17 100.66,13.65 PU700.12 ; v4(198.31,48.68) 199,48 RD43.2
1.8V_PRIM_PG: length 121.2
  TOP w0.069: v3(193.87,10.74) 193.87,11.4 194.5,12.03 194.5,12.64 193.79,13.35 193.79,16.77 194.3,17.29 v1(194.3,18.66) 194.42,18.78 194.42,20.01 197.04,22.62 197.04,25.36 195.02,27.37 195.02,29.8 194.65,30.17 192.2,30.17 191.76,30.61 191.76,31.82 194.6,34.66 v3(197.83,34.66)
  IN1 w0.061: v5(190.84,73.89) 191.31,73.89 192.29,72.92 192.29,67.65 200.29,59.64 v4(200.71,59.64) 201.91,59.64 v2(204.06,61.79) ; v2(173.48,8.17) 174.8,8.17 v3(175.53,8.89) ; v2(183.7,10.16) 183.7,10.21 183.58,10.33 183.58,10.51 183.73,10.66 v3(183.85,10.66)
  IN2 w0.051: v3(175.53,8.89) 175.92,8.89 177.62,10.58 182.89,10.58 183,10.48 183.67,10.48 v3(183.85,10.66) 184.57,10.66 186.45,12.54 190.93,12.54 191.11,12.37 191.11,11.22 191.58,10.74 193.86,10.74 v3(193.87,10.74) ; v3(199.12,46.5) 199,46.37 199,39.16 197.65,37.81 197.65,36.19 197.8,36.03 197.8,34.69 v3(197.83,34.66)
  IN3 w0.061: v3(199.12,46.5) 200.27,47.64 200.27,48.25 201.71,49.69 201.71,51.51 200.52,52.7 200.52,59.45 v4(200.71,59.64) 200.52,59.83 200.52,60.42 200.8,60.7 200.8,62.2 198.9,64.1 197.25,64.1 197.02,63.87 v4(197.02,63.19)
  BOTTOM w0.069: PR912.1 196.33,63.68 196.53,63.68 v4(197.02,63.19) 197.02,63.01 196.61,62.6 PR503.1 ; QC5.5 191.24,74.29 v5(190.84,73.89) ; PU500.5 200.71,59.78 v4(200.71,59.64)
3.3V_CAM_EN: length 42.1
  IN2 w0.051: v3(173.06,44.92) 173.06,44.65 173.24,44.47 173.24,42.54 172.99,42.28 172.99,40.3 v4(172.05,39.36)
  IN3 w0.061: v4(181.14,45.33) 181.14,45.24 180.63,44.73 177.76,44.73 177.54,44.51 177.1,44.51 177.01,44.59 177.01,44.76 176.74,45.04 176.31,45.04 175.84,44.56 173.46,44.56 173.09,44.92 v3(173.06,44.92)
  BOTTOM w0.069: R6163.1 191.23,46.7 190.59,47.34 188.33,47.34 187.9,47.77 187.08,47.77 186.97,47.66 186.16,47.66 185.65,48.18 v1(185.26,48.18) 183.3,48.18 182.56,47.44 182.06,47.44 181.62,47.01 181.62,46.64 181.28,46.31 181.28,45.47 v4(181.14,45.33) ; UC1.CV43 160.3,38.51 161.1,39.31 163.23,39.31 163.84,39.92 164.3,39.92 164.61,40.23 165.62,40.23 165.8,40.05 165.8,39.72 166,39.51 168.06,39.51 168.37,39.82 169.49,39.82 169.62,39.69 169.67,39.69 169.86,39.5 169.86,39.26 170.02,39.11 170.96,39.11 171.21,39.36 v4(172.05,39.36)
3.3V_CAM_EN_R: length 7.5
  BOTTOM w0.069: U55.4 192.02,47.4 R6163.2 192.27,46.87 R6162.2 192.2,46.36 191.71,45.86 v1(191.4,45.86) 191.17,46.09 191.17,46.25 190.25,47.17 187.79,47.17 R704.2
3.3V_TBT_L_EN: length 3.3
  IN3 w0.254: v4(22.27,47.14) 22.27,48.06 v4(21.91,48.42)
  BOTTOM w0.254: v4(21.91,48.42) RT179.1 RT83.2 RT84.2
3.3V_TBT_R_EN: length 4.6
  TOP w0.069: RT158.1 255.41,51.88 RT94.2 RT95.2 254.04,51.94 v1(253.69,52.28) ; RT158.1 256.39,51.49 UT2.3 ; RT158.1 256.5,52.39 RT93.1
3.3V_TS_EN: length 166.1
  TOP w0.069: v3(181.2,15.91) 181.26,15.91 UE1.J7 ; v3(111.7,55.67) 111.7,57.56 108.38,60.88 108.38,64.7 v2(107.88,65.21)
  IN1 w0.061: v3(107.86,65.56) 107.88,65.55 v2(107.88,65.21)
  IN2 w0.051: v3(181.2,15.91) 181.5,16.2 181.5,16.86 181.27,17.09 180.81,17.09 179.77,18.13 175.05,18.13 174.59,18.58 171.37,18.58 169.71,20.24 169.71,23.61 166.6,26.73 161.16,26.73 160.52,27.37 160.34,27.55 115.54,27.55 114.14,26.15 110.9,26.15 110.52,25.77 107.65,25.77 107.19,25.31 101.62,25.31 v3(101.28,25.65) 100.78,26.15 96.46,26.15 89.57,33.04 89.57,48.96 94.17,53.55 94.17,55.64 95.44,56.91 97.22,56.91 97.68,56.46 109.61,56.46 110.02,56.05 110.02,55.52 110.35,55.19 111.22,55.19 v3(111.7,55.67)
  IN3 w0.061: v3(107.86,65.56) 107.34,65.56 106.49,66.41 106.49,66.98 105.45,68.03 103.62,68.03 103.16,67.57 v4(103.16,67.38)
  BOTTOM w0.069: R6168.1 103.16,67.75 v4(103.16,67.38)
3V3_1.1V_MEM: length 3.7
  BOTTOM w0.069: PR708.1 94.65,9.62 v1(94.65,9.54)
  BOTTOM w0.254: PU700.3 95.82,11.65 PC715.1 PR708.1
3V_PRIM_EN: length 1.6
  TOP w0.069: U31.5 184.39,44.78 184.54,44.62 184.54,43.72 RC657.2
3VALW_DSW_EN: length 1.7
  TOP w0.069: RC651.2 183.4,43.87 183.4,44.57 183.59,44.75 U31.3
3VALW_PG: length 205.7
  TOP w0.069: v5(87.7,59.8) 87.91,60.01 91.48,60.01 93.61,57.88 93.61,48.07 92.93,47.39 90.71,47.39 v1(89.29,45.97) 89.17,45.86 89.17,42.12 92.47,38.83 92.47,38.65 v3(92.95,38.17)
  IN2 w0.051: v3(209.84,9.52) 208.96,10.41 201.73,10.41 195.25,16.88 189.55,16.88 188.35,18.08 188.35,20.89 185.27,23.97 182.12,23.97 179.53,26.56 177.69,26.56 177.33,26.21 174.43,26.21 173.49,27.14 170.53,27.14 169.72,27.96 164.11,27.96 162.33,29.74 114.74,29.74 112.93,27.93 110.16,27.93 109.78,27.55 106.57,27.55 106.26,27.25 v3(106.14,27.25)
  IN3 w0.061: v3(209.84,9.52) 210.03,9.33 213.22,9.33 v4(213.28,9.39) ; v3(106.14,27.25) 105.5,27.25 104.74,28.01 95.37,28.01 92.72,30.65 92.72,34.82 93.18,35.27 93.18,37.76 92.95,37.99 v3(92.95,38.17) ; v4(214.03,18.11) 215.29,16.86 v4(217.81,16.86)
  BOTTOM w0.069: v4(217.81,16.86) 217.81,15.15 217.62,14.95 216.73,14.95 216.46,14.68 216.46,13.7 213.28,10.52 v4(213.28,9.39) ; RC702.1 100.88,69.03 99.96,69.03 99.05,68.12 97.04,68.12 96.91,67.99 96.23,67.99 95.89,68.33 95.65,68.33 95.39,68.06 95.39,67.31 93.86,65.78 93.46,65.78 92.19,64.51 92.19,63.14 89.23,60.17 88.07,60.17 v5(87.7,59.8)
5VALW_PG: length 127.5
  TOP w0.069: v2(29.17,16.86) v1(29.9,17.58) 29.9,19.35 v3(32.91,22.36)
  IN1 w0.061: v4(26.23,15.96) 27.13,15.96 27.88,16.71 29.02,16.71 v2(29.17,16.86)
  IN2 w0.051: v5(95.77,67.78) 95.77,67.28 95.37,66.87 93.82,66.87 92.11,65.17 92.11,53.94 87.77,49.6 87.77,29.99 73.65,15.87 67.65,15.87 67.37,15.59 44.31,15.59 40.29,19.6 38.48,19.6 36.85,21.23 35.54,21.23 34.4,22.36 v3(32.91,22.36)
  IN3 w0.061: v4(26.23,15.96) 28.26,13.93 28.26,10.86 28.2,10.8 v4(28.2,10.6)
  BOTTOM w0.069: RC703.1 100.62,68.64 99.92,67.95 97.15,67.95 96.99,67.78 v5(95.77,67.78)
5VALWB_PG: length 222
  TOP w0.069: v2(254.09,28.47) 254.09,26.81 v1(254.85,26.05) 256.5,24.4 257.88,24.4 261.88,20.4 264.21,20.4 265.01,21.2 v3(266.66,21.2)
  IN1 w0.061: v3(252.02,28.45) 252.02,28.54 252.27,28.79 253.77,28.79 v2(254.09,28.47)
  IN2 w0.051: v3(114.24,70.17) 114.23,70.17 114.23,70.13 114.44,69.92 114.44,68.99 115.79,67.65 116.83,67.18 139.87,67.18 140.76,66.29 142.17,66.29 142.78,66.9 145.7,66.9 146.2,66.39 149.02,66.39 149.52,66.9 167.39,66.9 167.91,66.38 167.91,65.16 171.39,61.68 175.68,57.39 175.68,53.6 176.71,52.57 179.35,52.57 180.71,51.21 180.71,49.24 181.76,48.2 181.76,45.86 181.09,45.19 181.09,44.23 183.88,41.43 183.88,40.25 184.72,39.42 184.72,38.61 186.05,37.27 186.05,36.12 186.57,35.6 188.38,35.6 189.09,34.89 191.76,34.89 191.94,35.06 192.25,35.06 192.93,34.38 193.08,34.38 193.12,34.35 193.58,34.35 194.16,33.77 194.16,33.76 196.5,31.43 196.5,30.42 199.96,26.95 199.96,23.97 206.57,17.37 211.4,17.37 212.51,16.26 224.03,16.26 224.12,16.35 227.05,16.35 227.69,15.71 237.41,15.71 238.94,17.24 241.44,17.24 242.66,18.46 243.76,18.46 245.84,20.54 245.84,22.77 249.53,26.46 250.41,26.46 252.02,28.07 v3(252.02,28.45)
  IN3 w0.061: v3(266.66,21.2) 266.84,21.02 266.84,19.78 267.56,19.06 ; 267.56,19.06 270.74,19.06 271.79,20.11 v4(271.84,20.11) ; 267.56,19.06 v4(267.55,19.06) ; v4(109.39,71.04) 111.44,71.04 112.43,70.05 114.06,70.05 114.19,70.17 v3(114.24,70.17)
  BOTTOM w0.069: v4(109.39,71.04) 108.9,70.55 108.47,70.55 108.29,70.38 108.29,69.64 107.99,69.33 102.78,69.33 102.52,69.08 RC704.1 ; v4(271.84,20.11) 272,20.11 272.11,20.22 PU401.12
+0.6V_VDDQ:
  vias: v2(198.16,36.82) v2(198.49,36.51) v2(198.57,36.97) v2(198.82,36.21) v2(198.9,36.66) v2(199.15,35.9) v2(199.2,36.36) v3(198.16,36.82) v3(198.49,36.51) v3(198.57,36.97) v3(198.82,36.21) v3(198.9,36.66) v3(199.15,35.9) v3(199.2,36.36) v4(198.16,36.82) v4(198.49,36.51) v4(198.57,36.97) v4(198.82,36.21) v4(198.9,36.66) v4(199.15,35.9) v4(199.2,36.36) v6(195.44,36.75)
+0.6V_VDDQP: length 5.9
  TOP w0.508: v3(199.84,44.9) PR803.1
  IN2 w0.508: v3(199.84,44.9) 199.84,42.49 v4(201.18,41.14)
  BOTTOM w0.127: v1(204.18,35.5) 204.18,36.11 204.2,36.14
+0.9V_TBT_L_LC: length 1
  IN1 w0.254: v2(26.8,54.29) 27.05,54.04 v3(27.05,53.96)
  IN3 w0.254: v4(26.79,54.4) 27.05,54.14 v3(27.05,53.96)
+0.9V_TBT_L_LVR: length 3.4
  TOP w0.127: v2(25.34,55.58) 25.29,55.58 25.15,55.44 25.15,55.18 v1(24.69,54.72)
  IN1 w0.254: v4(24.22,55.64) 24.94,55.64 25.01,55.58 v2(25.34,55.58)
  BOTTOM w0.229: URT1.L6 URT1.M6 24.96,55.47 24.96,55.47
+0.9V_TBT_L_SVR: length 5.6
  TOP w0.127: v5(23.8,51.04) 23.8,50.78 v1(23.23,50.21)
  IN1 w0.254: v2(28.07,55.74) v3(28.07,55.37) ; v2(27.43,55.74) v3(27.43,55.37) ; v3(27.56,54) 27.56,54.22 v2(27.39,54.38) ; v3(28.74,57.33) 28.7,57.29 v2(28.7,56.99) ; v2(28.79,54.38) 28.79,54.35 28.58,54.13 28.58,54.12 v3(28.57,54.12) ; v2(27.39,56.92) v3(27.39,57.36)
  IN3 w0.254: v4(27.44,55.7) 27.44,55.38 v3(27.43,55.37) ; v3(27.56,54) 27.56,54.29 v4(27.44,54.4) ; v3(28.07,55.37) 28.09,55.4 v4(28.09,55.7) ; v3(28.57,54.12) 28.58,54.12 28.58,54.13 28.74,54.3 v4(28.74,54.4) ; v4(28.74,57) v3(28.74,57.33) ; v4(27.44,57) 27.44,57.31 v3(27.39,57.36)
  vias: v5(23.8,51.68)
+0.9V_TBT_R_LC: length 0.9
  IN1 w0.254: v2(266.57,51.25) 266.87,50.95 v3(266.87,50.94)
  IN3 w0.254: v3(266.87,50.94) 266.87,51.11 v4(266.67,51.31)
+0.9V_TBT_R_LVR: length 6.1
  TOP w0.127: v1(263.51,53.15) 263.51,52.85 264.04,52.32 v5(264.65,52.32)
  TOP w0.356: v5(264.65,52.32) 264.65,52.56 264.82,52.73 265.77,52.73 CT84.1
  BOTTOM w0.203: 264.7,52.38 URT2.M6 URT2.L6
  BOTTOM w0.254: 264.7,52.38 v5(264.65,52.32) 264.58,52.39 263.52,52.39 CT201.1
+0.9V_TBT_R_SVR: length 4.9
  TOP w0.127: v1(268.36,50.36) 268.71,50.7 v2(268.71,51.21)
  IN1 w0.203: v2(267.91,52.69) v3(267.67,52.46) ; v3(268.31,51) 268.52,51.21 v2(268.71,51.21) ; v3(267.51,52.93) v2(267.27,52.69)
  IN1 w0.254: v2(268.57,53.88) 268.56,53.88 v3(268.28,53.59) ; v3(267.66,50.99) 267.4,51.25 v2(267.21,51.25) ; v3(267,53.58) 267.29,53.88 v2(267.3,53.88)
  IN3 w0.203: v3(267.66,50.99) 267.34,51.31 v4(267.32,51.31) ; v4(268.62,51.31) v3(268.31,51)
  IN3 w0.254: v3(268.28,53.59) 268.59,53.91 v4(268.62,53.91)
  vias: v4(262.93,47.59) v4(262.93,47.26) v4(263.11,47.87) v4(263.34,47.59) v4(263.31,47.26) v4(267.32,53.91) v4(267.32,52.61) v4(267.97,52.61)
+1.1V_MEM: length 88.3
  TOP w0.203: v3(150.49,16.87) 150.49,16.87 UD2.N10
  TOP w0.254: UD4.H12 v3(120.18,20.38) ; 114.09,10.98 UD4.AB4 ; UD1.K12 v3(166.44,18.82) ; UD2.H8 148.94,20.12 v3(148.67,20.39) ; v2(142.81,17.08) 143.01,16.87 UD2.N1 ; v3(164.83,19.23) 164.72,19.12 UD1.K10 ; UD3.R8 v3(130.19,15.82) ; v3(133.97,17.34) 134.03,17.28 UD3.N12
  IN1 w0.203: v2(158.83,18.82) 158.71,18.7 158.71,18.49 v3(158.7,18.49) ; v3(152.9,16.73) 152.59,16.73 v2(152.45,16.87)
  IN1 w0.254: v2(166.03,16.87) 166.37,16.87 v3(166.45,16.95) ; v3(129.05,41.65) 128.92,41.65 v2(128.73,41.46) ; v2(146.85,21.42) 146.77,21.42 v3(146.46,21.73) ; v2(162.83,15.57) v3(162.39,15.57) ; v3(150.48,18.61) 150.63,18.61 v2(150.85,18.82) ; v2(132.43,18.82) 132.43,18.63 v3(132.58,18.48) ; v3(126.89,18.46) 126.89,18.47 126.89,18.5 126.88,18.52 126.88,18.77 v2(126.83,18.82) ; v2(160.43,15.57) v3(160.89,15.57) ; v3(124.88,20.03) 124.88,20.01 125,20.12 v2(125.23,20.12) ; v2(166.44,17.43) v3(166.44,17.76) ; v2(128.43,21.42) 128.85,21.42 128.89,21.39 128.95,21.39 128.95,21.39 v3(128.94,21.39) ; v3(160.9,14.48) 160.9,14.46 160.86,14.46 160.68,14.27 v2(160.43,14.27) ; v3(156.53,16.73) 156.67,16.87 v2(157.23,16.87) ; v2(143.64,18.82) v3(143.26,18.82) ; v2(149.25,14.27) v3(148.78,14.27) ; v2(126.83,16.87) 126.83,17.36 126.86,17.39 v3(126.89,17.39) ; v2(140.94,15.47) 140.94,15.69 v3(141.07,15.82) ; v3(116.88,14.5) 117.1,14.27 v2(117.24,14.27) ; v3(128.91,14.31) 128.88,14.27 v2(128.43,14.27) ; v2(130.83,20.12) 130.71,20 v3(130.45,20) ; v3(124.88,18.97) 124.91,18.97 125.05,18.82 v2(125.23,18.82) ; v2(134.03,15.57) v3(134.43,15.57) ; v3(153.57,22.13) v2(153.93,22.13) ; v2(146.85,15.57) v3(147.33,15.57) ; v2(111.64,15.57) 111.64,15.61 111.42,15.83 v3(111.42,15.86) ; v2(114.84,21.42) 114.96,21.42 v3(115.18,21.2) ; v2(130.83,21.42) 130.82,21.41 v3(130.38,21.41) ; v2(162.83,14.27) 162.77,14.21 162.4,14.21 162.33,14.28 v3(162.33,14.21) ; v3(124.28,16.34) 124.81,16.87 v2(125.23,16.87) ; v3(132.43,16.48) v2(132.43,16.87) ; v3(160.69,20.39) 160.69,20.38 160.43,20.13 v2(160.43,20.12) ; v2(125.23,15.57) 124.58,15.57 v3(124.53,15.63) ; v3(147.3,14.27) v2(146.85,14.27) ; v2(128.43,15.57) 128.7,15.57 v3(128.85,15.72) ; v3(141.25,18.25) 141.25,18.13 v2(141.43,17.94) ; v2(166.03,20.12) 166.36,20.12 v3(166.44,20.04) ; v3(162.44,21.5) 162.52,21.42 v2(162.83,21.42) ; v2(134.03,20.12) 134.06,20.12 v3(134.33,20.39) ; v3(156.85,15.48) 156.85,15.53 156.9,15.57 v2(157.23,15.57) ; v2(140.81,19.65) 140.81,19.31 v3(140.91,19.21) 140.91,19.12 v2(141.27,18.77) ; v3(141.17,16.64) 141.16,16.65 141.16,17.01 v2(141.33,17.18) ; v2(130.83,14.27) 130.4,14.27 v3(130.28,14.16) ; v3(122.11,16.02) 122.3,15.83 v2(122.82,15.83) ; v2(117.24,21.42) v3(116.88,21.42) ; v3(128.94,20.22) 128.84,20.12 v2(128.43,20.12) ; v2(149.25,15.57) v3(148.76,15.57) ; v2(143.64,20.12) 143.35,20.12 v3(143.26,20.04) ; v3(157.71,20.6) v2(157.23,20.12) ; v3(144.97,18.51) 144.97,18.55 v2(145.24,18.82) ; v3(153.83,19.45) v2(153.48,19.45) ; v3(153.81,20.77) v2(153.48,20.77) ; v2(113.24,18.82) 113.48,18.58 113.65,18.58 113.65,18.59 v3(113.62,18.59) ; v3(156.79,18.38) v2(156.79,17.88) ; v3(111.96,20.36) 111.73,20.12 v2(111.64,20.12) ; v2(160.8,21.56) 160.97,21.73 161.04,21.73 161.07,21.75 161.07,21.83 v3(161.09,21.83) ; v2(117.24,15.57) 117.12,15.57 v3(116.85,15.84) ; v3(143.01,17.52) 142.87,17.38 142.87,17.14 v2(142.81,17.08) ; v2(166.03,15.57) 166.15,15.69 v3(166.43,15.69) ; v3(128.12,41.6) v2(128.12,41.27) ; v3(153.34,18.43) 153.36,18.43 153.36,18.6 v2(153.48,18.73) ; v2(143.64,15.57) v3(143.27,15.57)
  IN1 w0.305: v2(114.84,20.12) 114.89,20.12 115.15,20.39 v3(115.23,20.39)
  IN3 w0.254: v4(127.11,40.91) v3(127.49,40.91) ; v4(128.72,41.65) v3(129.05,41.65) ; v4(133.51,41.83) v3(133.51,42.25) ; v4(132.14,41.37) v3(131.74,41.37) ; v4(133.05,42.3) v4(133.05,41.91) ; v4(151.81,40.26) v3(151.39,40.26) ; v4(132.6,41.83) v3(132.6,41.39) ; v4(128.35,41.83) 128.35,41.83 v3(128.12,41.6) ; v4(148.15,40.26) v3(148.14,40.25)
  BOTTOM w0.127: UC1.BE37 144.23,41.57 ; UC1.BE37 144.26,41.14 ; UC1.BE37 143.8,41.14 ; UC1.BE37 143.83,41.57 ; UC1.BA37 141.97,41.14 ; UC1.BA37 142.43,41.14 ; UC1.BA37 142,41.57 ; UC1.BA37 142.4,41.57 ; 139.69,41.14 UC1.AR37 ; UC1.AR37 139.23,41.15 ; UC1.AR37 139.66,41.57 ; UC1.AR37 139.26,41.57 ; UC1.BD36 143.97,42.23 ; UC1.BD36 143.35,41.6 ; UC1.BD36 143.78,41.63 ; UC1.BD36 143.18,42.23 ; v4(149.07,40.91) 149.26,41.11 ; v4(149.07,40.91) 148.83,40.68 ; v4(149.07,40.91) 149.32,40.66 ; v4(149.07,40.91) 148.86,41.11 ; 128.77,41.9 128.43,41.9 v4(128.35,41.83) 128.11,41.58 ; 137.86,41.61 UC1.AN36 ; UC1.AN36 138.29,41.63 ; UC1.AN36 137.86,42.05 ; UC1.AN36 138.31,42.05 ; v4(132.14,41.37) 131.92,41.59 ; v4(132.14,41.37) 132.35,41.58 ; v4(132.14,41.37) 131.93,41.17 ; v4(132.14,41.37) 132.37,41.14 ; UC1.AY36 142.14,42.23 ; UC1.AY36 141.95,41.63 ; UC1.AY36 141.35,42.23 ; UC1.AY36 141.54,41.63 ; 145.01,42.23 UC1.BG36 ; UC1.BG36 145.19,41.62 ; UC1.BG36 145.63,41.61 ; UC1.BG36 145.8,42.23 ; v4(132.6,41.83) 132.4,41.64 ; v4(132.6,41.83) 132.81,41.62 ; v4(132.6,41.83) 132.53,41.9 132.22,41.9 ; v4(132.6,41.83) 132.81,42.04 ; 134.95,42.23 UC1.AG36 ; UC1.AG36 135.57,41.6 ; UC1.AG36 135.12,41.61 ; UC1.AG36 135.73,42.23 ; UC1.BF37 145.15,41.57 ; UC1.BF37 144.75,41.57 ; UC1.BF37 145.15,41.17 ; UC1.BF37 144.72,41.14 ; v4(133.51,41.83) 133.32,42.03 ; v4(133.51,41.83) 133.3,41.62 ; v4(133.51,41.83) 133.74,41.6 ; v4(133.51,41.83) 133.72,42.04 ; UC1.BJ36 145.93,42.23 ; UC1.BJ36 146.52,41.63 ; UC1.BJ36 146.71,42.23 ; UC1.BJ36 146.09,41.6 ; UC1.BF36 144.29,41.63 ; UC1.BF36 144.88,42.23 ; UC1.BF36 144.1,42.23 ; UC1.BF36 144.69,41.63 ; v4(148.15,40.91) 147.95,41.11 ; v4(148.15,40.91) 148.35,41.11 ; v4(148.15,40.91) 148.4,40.66 ; v4(148.15,40.91) 147.92,40.68 ; 138.34,41.57 UC1.AP37 ; UC1.AP37 138.34,41.17 ; UC1.AP37 138.74,41.57 ; UC1.AP37 138.75,41.17 ; UC1.AE36 134.82,42.23 ; UC1.AE36 134.63,41.63 ; UC1.AE36 134.19,41.6 ; UC1.AE36 134.23,42.03 ; v4(149.52,41.37) 149.32,41.17 ; v4(149.52,41.37) 149.3,41.6 ; v4(149.52,41.37) 149.75,41.15 ; UC1.AD35 133.78,42.11 ; UC1.AD35 133.75,42.51 ; UC1.AD35 134.18,42.51 ; UC1.AD35 134.18,42.09 ; UC1.AL36 136.95,41.61 ; UC1.AL36 136.78,42.23 ; UC1.AL36 137.4,41.6 ; UC1.AL36 137.56,42.23 ; UC1.BL37 147,41.6 ; UC1.BL37 147,41.15 ; UC1.BL37 146.55,41.14 ; UC1.BL37 146.58,41.57 ; v4(148.15,40.26) 148.37,40.48 ; v4(148.15,40.26) 148.38,40.04 ; v4(148.15,40.26) 147.91,40.02 ; v4(148.15,40.26) 147.93,40.48 ; 133.28,41.14 UC1.AC37 ; UC1.AC37 133.25,41.57 ; UC1.AC37 132.82,41.14 ; UC1.AC37 132.86,41.57 ; v4(133.05,42.3) 133.26,42.09 ; v4(133.05,42.3) 132.86,42.1 ; v4(133.05,42.3) 133.26,42.5 ; UC1.AW37 141.06,41.14 ; UC1.AW37 141.49,41.57 ; UC1.AW37 141.52,41.14 ; UC1.AW37 141.09,41.57 ; 148.38,41.6 v4(148.61,41.37) ; v4(148.61,41.37) 148.83,41.6 ; v4(148.61,41.37) 148.81,41.17 ; v4(148.61,41.37) 148.4,41.17 ; 147.92,41.6 v4(147.69,41.37) ; v4(147.69,41.37) 147.46,41.14 ; v4(147.69,41.37) 147.89,41.17 ; v4(147.69,41.37) 147.47,41.6 ; UC1.AJ36 136.49,41.6 ; UC1.AJ36 135.86,42.23 ; UC1.AJ36 136.03,41.61 ; UC1.AJ36 136.65,42.23 ; v4(151.81,40.26) 152.07,40 ; v4(151.81,40.26) 152.06,40.51 ; v4(151.81,40.26) 151.57,40.02 ; v4(151.81,40.26) 151.54,40.53 ; 139.39,42.23 UC1.AR36 ; UC1.AR36 138.61,42.23 ; UC1.AR36 139.21,41.63 ; UC1.AR36 138.79,41.62 ; UC1.AT36 139.71,41.63 139.71,41.63 ; UC1.AT36 139.52,42.23 ; UC1.AT36 140.31,42.23 ; UC1.AT36 140.12,41.63 ; v4(127.11,40.91) 126.88,41.14 ; v4(127.11,40.91) 127.37,40.65 ; v4(127.11,40.91) 126.84,40.64 ; v4(127.11,40.91) 127.36,41.17 ; UC1.AV36 141.22,42.23 ; UC1.AV36 141.03,41.63 ; UC1.AV36 140.6,41.61 ; UC1.AV36 140.44,42.23 ; 142.27,42.23 UC1.BB36 ; UC1.BB36 143.05,42.23 ; UC1.BB36 142.46,41.63 ; UC1.BB36 142.89,41.61
  vias: v2(113.24,16.87) v2(115.34,15.57) v2(117.24,20.12) v2(130.34,22.01) v2(145.24,16.87) v2(146.85,20.12) v2(152.45,15.57) v2(152.92,16.17) v2(162.08,13.54) v2(162.5,20.47) v2(164.43,16.87) v3(113.24,16.87) v3(115.34,15.57) v3(117.24,20.12) v3(130.34,22.01) v3(145.24,16.87) v3(146.85,20.12) v3(152.45,15.57) v3(152.92,16.17) v3(162.08,13.54) v3(162.5,20.47) v3(164.43,16.87) v5(102.2,26.36) v5(102.83,26.36) v5(103.47,26.36) v5(104.1,26.36) v5(104.74,26.36) v5(111.59,17.43) v5(122.06,19.32) v5(134.88,42.23) v5(135.8,42.23) v5(136.71,42.23) v5(137.62,42.23) v5(138.54,42.23) v5(139.45,42.23) v5(140.37,42.23) v5(141.28,42.23) v5(142.2,42.23) v5(143.11,42.23) v5(144.03,42.23) v5(144.94,42.23) v5(145.85,42.23) v5(146.77,42.23) v5(147.68,42.23) v5(148.6,42.23) v5(153.81,16.29) v5(153.81,15.66) v5(153.98,17.1) v6(103.98,30.85)
+1.1V_MEMP: length 22.9
  IN3 w0.254: v4(103.09,13.4) 103.09,14.55 103.04,14.6 102.24,14.6 ; v4(101.44,23.69) 100.67,22.93 100.67,20.52 102.24,18.95 102.24,15.77 102.5,15.51 102.5,14.86 102.24,14.6 ; v5(95.72,13.02) 96.53,12.21 98.97,12.21 99.91,13.15 100.67,13.15 101.13,13.61 101.13,14.5 101.23,14.6 102.24,14.6
  BOTTOM w0.254: v5(95.72,13.02) 96.1,13.02 96.23,13.15 PU700.6 ; PC702.1 102.25,13.4 v4(103.09,13.4)
  vias: v1(97.09,24.88)

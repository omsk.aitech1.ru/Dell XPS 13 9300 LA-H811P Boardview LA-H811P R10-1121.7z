# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML0B_SMBCLK: length 70.2
  TOP w0.069: UE1.D8 182.64,20.19 182.97,20.52 183.35,20.52 183.5,20.36 183.5,20.19 183.62,20.07 183.62,20.06 183.8,19.88 183.81,19.88 183.9,19.79 v2(183.91,19.79)
  IN1 w0.061: v3(183.91,19.04) v2(183.91,19.79)
  IN2 w0.051: v3(183.91,19.04) 183.91,19.07 184.09,19.25 184.09,20.11 185.18,21.2 186.42,21.2 187.16,20.46 187.16,17.54 187.95,16.75 187.95,16.06 188.81,15.21 192.65,15.21 192.72,15.13 v3(193.03,15.13)
  IN3 w0.061: v4(174.41,42.56) 174.62,42.77 178.59,42.77 178.84,43.02 180.84,43.02 181.26,42.6 182.5,42.6 182.69,42.41 186.12,42.41 187.34,41.19 189.18,41.19 190.46,39.91 191.3,39.91 193.93,37.28 193.93,36.71 195.93,34.71 195.93,32.63 197.36,31.2 197.36,24.8 193.79,21.23 193.79,20.06 193.68,19.95 193.68,15.78 v3(193.03,15.13)
  BOTTOM w0.069: UC1.DW33 170.92,43.48 171.34,43.48 172.51,42.3 173.92,42.3 174.18,42.56 v4(174.41,42.56) 174.8,42.56 RC673.2
SML0B_SMBDATA: length 69.8
  IN1 w0.061: v3(184.73,19.04) v2(184.73,19.39)
  IN2 w0.051: v3(193.41,14.75) 192.85,14.75 192.57,15.03 188.74,15.03 187.78,15.99 187.78,16.67 186.98,17.47 186.98,20.39 186.35,21.02 185.26,21.02 184.27,20.03 184.27,19.07 184.47,18.86 184.55,18.86 v3(184.73,19.04)
  IN3 w0.061: v4(174.38,42.99) 174.41,42.96 178.51,42.96 178.76,43.21 180.92,43.21 181.34,42.79 182.58,42.79 182.77,42.6 186.2,42.6 187.42,41.38 189.26,41.38 190.54,40.1 191.38,40.1 194.12,37.36 194.12,36.79 196.12,34.79 196.12,32.71 197.55,31.27 197.55,24.72 193.98,21.15 193.98,19.98 193.87,19.87 193.87,15.7 193.53,15.37 193.53,14.87 v3(193.41,14.75)
  BOTTOM w0.069: RC672.2 174.83,42.99 v4(174.38,42.99) 174.33,42.99 173.84,42.5 172.59,42.5 171.42,43.67 170.92,43.67 170.84,43.69 170.69,43.64 170.62,43.59 170.41,43.37 UC1.DV33
SML0BALERT#: length 3.9
  BOTTOM w0.069: UC1.DU33 169.69,43.37 170.03,43.71 170.5,43.71 170.62,43.79 170.81,43.86 170.88,43.86 170.9,43.86 171.69,43.86 172.73,42.82 RC727.1
SML1_SMBCLK: length 384.2
  TOP w0.069: RT124.2 31.12,56.96 31.6,56.96 32.18,57.53 32.18,58.4 v5(31.92,58.67) ; v2(167.64,48.79) 168.1,48.32 RH606.1 CC657.1 ; v2(264.55,44.34) 264.33,44.56 264.33,44.76 264.64,45.06 270.17,45.06 271.5,46.39 271.5,50.47 270.57,51.39 270.57,51.54 RT197.2
  IN1 w0.061: v2(167.64,48.79) 167.59,48.84 167.48,48.84 167.4,48.76 167.4,48.66 v3(167.64,48.42) 167.64,48.21 168.05,47.8 169.38,47.8 169.71,47.46 170.83,47.46 171.79,46.5 173.24,46.5 174.25,45.49 178.14,45.49 179.93,43.7 180.87,43.7 181.8,42.77 182.06,42.77 183.03,41.8 183.86,41.8 185.94,39.72 186.73,39.72 186.89,39.56 186.89,39.27 v3(187.08,39.08) ; v2(264.55,44.34) 264.45,44.44 264.33,44.44 264.23,44.53 264.23,44.8 263.97,45.06 263.03,45.06 262.5,45.6 259.82,45.6 259.61,45.81 v3(259.61,45.86)
  IN2 w0.051: v3(187.08,39.08) 186.9,38.9 186.9,38.66 189.09,36.47 189.09,36.11 189.45,35.76 190.84,35.76 191.3,36.21 193.38,36.21 195.14,34.46 195.14,33.8 197.91,31.03 197.91,30.19 200.67,27.42 200.67,24.27 206.86,18.08 211.7,18.08 212.31,17.47 226.51,17.47 227.86,16.11 237.24,16.11 238.77,17.65 241.27,17.65 242.49,18.86 243.6,18.86 245.44,20.7 245.44,22.94 251.94,29.44 255.8,29.44 257.52,31.16 257.52,33.68 256.59,34.6 256.07,35.12 256.07,42.11 258.2,44.24 258.2,44.77 259.02,45.59 259.38,45.59 259.61,45.81 v3(259.61,45.86)
  IN3 w0.061: v4(167.38,48.16) v3(167.64,48.42) 167.09,48.96 166.36,48.96 165.89,49.44 165.89,50.25 165.85,50.28 165.67,50.46 164.29,50.46 163.13,51.62 161.71,51.62 161.35,51.26 136.65,51.26 134.56,49.17 124.93,49.17 124.03,50.07 122.25,50.07 121.83,50.49 115.66,50.49 115.57,50.4 101.82,50.4 100.32,48.9 96.8,48.9 96.2,49.5 94.4,49.5 91.2,46.29 91.2,28.5 82.46,19.76 81.66,19.76 75.1,13.2 44.47,13.2 36.49,21.19 35.78,21.19 33.22,23.75 33.22,24.92 33.82,25.52 v4(33.82,26.13) ; v4(25.94,42.55) 26.17,42.78 26.17,42.99 26.38,43.2 30.81,43.2 31.22,43.6 34.75,43.6 35.99,44.84 35.99,48.48 35.46,49.01 35.46,57.67 34.55,58.59 32.92,58.59 32.67,58.84 32.09,58.84 v5(31.92,58.67)
  BOTTOM w0.069: RPD21.2 25.85,42.46 v4(25.94,42.55) 26.16,42.77 26.16,42.95 26.61,43.4 v7(28.74,43.4) 33.31,43.4 35.57,41.15 35.57,28.56 33.71,26.71 33.71,26.24 v4(33.82,26.13)
SML1_SMBDATA: length 383.4
  TOP w0.069: v3(167.07,48.5) 166.89,48.32 RH607.1 ; v5(31.92,59.25) 32.37,58.79 32.37,57.45 31.69,56.76 31.12,56.76 RT125.2 ; RT198.2 270.37,51.5 270.37,51.31 271.3,50.39 271.3,46.47 270.09,45.26 264.55,45.26 264.14,44.84 264.14,44.56 v2(263.92,44.34)
  IN1 w0.061: v2(263.92,44.34) 264.05,44.47 264.05,44.72 263.89,44.87 262.95,44.87 262.42,45.41 259.69,45.41 v3(259.61,45.33) ; v3(186.55,39.08) 186.7,39.24 186.7,39.48 186.65,39.53 185.86,39.53 183.78,41.61 182.95,41.61 181.98,42.58 181.72,42.58 180.79,43.51 179.86,43.51 178.06,45.31 174.17,45.31 173.16,46.31 171.72,46.31 170.75,47.28 169.63,47.28 169.3,47.61 167.97,47.61 167.84,47.73 167.77,47.81 167.76,47.82 v3(167.07,48.5)
  IN2 w0.051: v3(259.61,45.33) 259.53,45.41 259.09,45.41 258.38,44.7 258.38,44.16 256.25,42.03 256.25,35.19 256.66,34.78 257.7,33.75 257.7,31.09 255.87,29.26 252.01,29.26 245.61,22.86 245.61,20.63 243.67,18.69 242.56,18.69 241.34,17.47 238.85,17.47 237.32,15.94 227.79,15.94 226.43,17.29 212.23,17.29 211.63,17.9 206.79,17.9 200.5,24.19 200.5,27.35 197.73,30.12 197.73,30.96 194.96,33.73 194.96,34.39 193.31,36.03 191.38,36.03 190.92,35.58 189.37,35.58 188.91,36.04 188.91,36.39 186.72,38.58 186.72,38.9 v3(186.55,39.08)
  IN3 w0.061: v5(31.92,59.25) 32.13,59.03 32.74,59.03 33,58.78 34.62,58.78 35.65,57.75 35.65,49.09 36.18,48.56 36.18,44.76 34.83,43.42 31.3,43.42 30.89,43.01 26.46,43.01 26.35,42.91 26.35,42.77 v4(26.58,42.55) ; v4(33.44,26.13) 33.14,26.13 33.06,26.05 33.06,25.9 33.11,25.85 33.59,25.85 33.63,25.81 33.63,25.6 33.03,25 33.03,23.67 35.7,21 36.41,21 44.4,13.02 75.17,13.02 81.73,19.58 82.54,19.58 91.39,28.42 91.39,46.22 94.48,49.31 96.13,49.31 96.72,48.71 100.39,48.71 101.9,50.21 115.65,50.21 115.74,50.3 121.75,50.3 122.17,49.88 123.95,49.88 124.85,48.98 134.64,48.98 136.73,51.07 161.43,51.07 161.79,51.43 163.06,51.43 164.21,50.27 165.59,50.27 165.7,50.17 165.7,49.36 166.28,48.78 166.8,48.78 v3(167.07,48.5) v4(166.73,48.16)
  BOTTOM w0.069: RPD22.2 26.48,42.46 v4(26.58,42.55) 26.36,42.77 26.36,42.87 26.69,43.21 33.23,43.21 35.37,41.07 v7(35.37,39.44) 35.37,28.64 33.52,26.79 33.52,26.18 33.47,26.13 v4(33.44,26.13)
SN_1.1V_MEM: length 1.5
  BOTTOM w0.069: PR701.2 100.45,19.8 v1(101.77,19.8)
SN_3V: length 1.9
  BOTTOM w0.069: v1(204.71,21.56) 204.81,21.46 206.54,21.46 PC341.1
SNDW_RCOMP: length 0.4
  IN3 w0.254: v4(160.3,40.91) 160.56,41.17 v3(160.61,41.17)
SNUB_CHG1:
  vias: v5(82.51,8.93)
SNUB_CHG2: length 2
  BOTTOM w0.069: v1(94.58,11.4) 94.25,11.73 93.78,11.73 PR216.2
SOC_SPI_0_CLK: length 30.8
  TOP w0.069: v1(163.58,38.89) 163.26,38.58 v3(162.72,38.58) 162.14,38.58 RC734.1
  IN3 w0.061: v4(162.45,38.8) 162.67,38.58 v3(162.72,38.58) 162.99,38.85 163.44,38.85 163.67,38.63 163.67,38.35 164.29,37.72 164.29,37.34 164.45,37.18 164.83,37.18 165.37,36.64 166.69,36.64 166.76,36.57 166.76,35.92 167.57,35.11 169.08,35.11 169.34,34.86 170.46,34.86 170.94,34.38 171.09,34.38 171.47,34.76 171.62,34.76 171.73,34.65 171.73,34.5 171.35,34.12 171.35,33.97 171.57,33.75 172.35,33.75 173.07,33.03 173.22,33.03 173.74,33.56 173.89,33.56 174,33.45 174,33.3 173.48,32.78 173.48,32.62 173.59,32.52 173.74,32.52 174.26,33.04 174.41,33.04 174.52,32.93 174.52,32.78 174,32.26 174,32.11 174.25,31.85 174.57,31.85 174.68,31.96 174.68,32.24 174.78,32.35 174.94,32.35 175.04,32.24 175.04,31.96 175.15,31.85 175.65,31.85 176.7,30.8 177.4,30.8 177.61,31.01 177.77,31.01 177.98,30.8 178.13,30.8 178.34,31.01 178.5,31.01 178.71,30.8 178.86,30.8 179.07,31.01 179.23,31.01 179.44,30.8 180.41,30.8 v4(180.51,30.7)
  BOTTOM w0.069: UC1.DB42 162.29,38.96 v4(162.45,38.8) ; RH719.2 180.61,30.6 v4(180.51,30.7)
SOC_SPI_0_CLK_R: length 23.3
  TOP w0.069: v3(189.87,28.55) 189.63,28.8 v6(189.45,28.8)
  IN3 w0.061: v4(181.33,27.02) 181.29,26.97 181.29,26.59 181.86,26.02 184.79,26.02 185.48,26.71 187.83,26.71 188.52,27.39 188.72,27.39 v3(189.87,28.55) 190.77,29.45 190.77,29.92 192.34,31.5 192.34,33.87 192.83,34.36 v4(193,34.36)
  BOTTOM w0.069: JSPI1.4 193.38,34.03 193.05,34.36 v4(193,34.36) ; R703.1 RH719.1 181.62,30.57 RH24.2 181.6,30.02 181.27,29.68 181.27,29.15 181.34,29.08 181.34,27.03 v4(181.33,27.02)
SOC_SPI_0_CS#0: length 41.2
  TOP w0.069: v6(171.92,37.91) 171.97,37.91 172.31,38.26 v3(172.31,38.33)
  IN3 w0.061: v4(162.13,38.31) 162.13,38.86 162.33,39.07 163.75,39.07 163.97,39.29 164.56,39.29 164.93,39.66 168.13,39.66 168.37,39.42 169.66,39.42 170.11,38.96 170.48,38.96 171.27,38.17 172.15,38.17 v3(172.31,38.33) 172.39,38.26 173.33,38.26 173.43,38.36 173.81,38.36 173.91,38.26 176.48,38.26 177.51,39.29 179.84,39.29 180.04,39.09 180.8,39.09 181.59,38.31 182.96,38.31 183.14,38.13 183.14,36.61 183.25,36.5 183.25,35.95 182.68,35.38 182.68,35.23 182.79,35.12 182.99,35.12 183.32,35.45 183.6,35.45 183.73,35.33 183.73,35.1 183.84,34.99 183.99,34.99 184.1,35.1 184.1,35.41 184.2,35.52 184.35,35.52 184.46,35.41 184.46,35.1 184.57,34.99 184.72,34.99 184.83,35.1 184.83,35.41 184.93,35.52 185.09,35.52 185.19,35.41 185.19,35.1 185.3,34.99 185.45,34.99 185.56,35.1 185.56,35.41 185.67,35.52 185.82,35.52 185.92,35.41 185.92,35.1 186.03,34.99 186.18,34.99 186.29,35.1 186.29,35.41 186.4,35.52 186.88,35.52 187.04,35.67 188.05,35.67 189.03,34.69 189.17,34.69 v4(189.19,34.66)
  BOTTOM w0.069: v4(189.19,34.66) 189.52,34.66 189.98,35.12 192.17,35.12 192.18,35.13 RH736.2
SOC_SPI_0_CS#0_R: length 12.6
  TOP w0.069: v6(192.75,34.59) 192.75,34.71 192.91,34.88 v4(192.91,35.01)
  IN3 w0.061: v4(191.83,34.74) 192,34.91 192,35.72 192.09,35.81 192.18,35.81 192.39,35.59 192.39,34.87 192.49,34.77 192.67,34.77 v4(192.91,35.01)
  BOTTOM w0.069: UH8.1 191.83,33.8 191.83,34.21 191.68,34.36 190.67,34.36 190.51,34.51 190.51,34.79 190.64,34.92 191.66,34.92 v4(191.83,34.74) ; v4(192.91,35.01) 192.91,34.86 192.6,34.55 RH736.1 192.18,34.55 192.01,34.38 192.01,34.21 192.09,34.13 192.62,34.13 192.7,34.05 192.7,33.83 192.62,33.75 192.29,33.75 192.22,33.67 192.22,33.29 192.37,33.14 192.72,33.14 192.77,33.19 192.77,33.34 192.96,33.53 JSPI1.5
SOC_SPI_0_CS#1: length 33.6
  IN3 w0.061: v4(163.96,39.61) 164.38,40.03 168.29,40.03 168.53,39.79 169.81,39.79 170.27,39.34 170.66,39.34 170.78,39.22 171.69,39.22 171.94,38.97 172.53,38.97 172.87,38.63 173.17,38.63 173.27,38.73 173.82,38.73 174.25,39.16 175.01,39.16 175.42,38.75 176.44,38.75 177.43,39.74 179.92,39.74 180.19,39.47 180.96,39.47 181.74,38.68 183.17,38.68 184.07,37.78 184.07,37.27 184.19,37.15 184.19,36.24 184.53,35.89 186.49,35.89 186.55,35.96 186.55,36.68 186.7,36.83 188.17,36.83 188.46,36.54 188.46,36.06 188.96,35.55 v4(189.52,35.55)
  BOTTOM w0.069: v4(189.52,35.55) 189.55,35.53 191.43,35.53 RH735.2
SOC_SPI_0_CS#1_R: length 6.8
  BOTTOM w0.069: JSPI1.1 193.92,35.53 194.02,35.63 194.02,35.73 193.38,36.37 193.35,36.37 193.3,36.32 193.3,35.92 193.19,35.81 193.04,35.81 192.93,35.92 192.93,36.55 192.83,36.65 192.67,36.65 192.47,36.45 192.31,36.45 192.2,36.56 192.2,36.71 192.41,36.92 192.41,37.07 192.22,37.26 191.92,37.26 v1(191.78,37.13) 191.68,37.03 191.68,36.57 RH735.1
SOC_SPI_0_CS#2: length 41
  IN3 w0.061: v4(187.8,37.28) 187.8,37.32 188.13,37.65 188.13,37.76 188.03,37.86 184.89,37.86 184.8,37.76 184.8,37.65 184.72,37.57 184.48,37.57 184.45,37.61 184.45,38.14 183.64,38.95 183,38.95 182.92,38.87 181.82,38.87 181.04,39.66 180.27,39.66 179.97,39.96 178.82,39.96 178.76,40.02 178.76,40.44 178.66,40.53 178.53,40.53 178.44,40.44 178.44,40.02 178.35,39.93 178.22,39.93 178.13,40.02 178.13,40.44 178.03,40.53 177.9,40.53 177.81,40.44 177.81,40.02 177.72,39.93 177.36,39.93 176.52,39.09 175.34,39.09 175.09,39.35 173.9,39.35 173.83,39.28 173.83,39.01 173.74,38.92 173.55,38.92 173.46,39.01 173.46,39.24 173.37,39.34 173.24,39.34 173.14,39.24 173.14,38.91 173.11,38.88 172.88,38.88 172.73,39.04 172.73,39.27 172.3,39.7 171.64,39.7 171.46,39.52 170.35,39.52 169.89,39.98 168.61,39.98 168.37,40.22 165.42,40.22 165.32,40.31 165.32,40.72 165.23,40.81 165.1,40.81 165.01,40.72 165.01,40.31 164.92,40.22 164.22,40.22 164.07,40.38 163.79,40.38 163.64,40.23 163.64,39.33 163.54,39.23 162.91,39.23 162.83,39.31 162.83,39.51 162.88,39.57 163.23,39.57 163.34,39.67 163.34,40.3 163.18,40.45 163.18,40.73 163.11,40.81 162.99,40.81 162.9,40.72 162.9,40.24 162.81,40.15 162.68,40.15 162.59,40.24 162.59,40.72 162.49,40.81 162.32,40.81 161.44,39.93 161.44,39.7 161.58,39.57 161.58,38.97 161.61,38.95 161.7,38.95 162.13,39.37 v4(162.13,39.61)
SOC_SPI_0_D0: length 34.5
  TOP w0.069: RH641.1 163.76,37.95 RH640.2 163.11,37.99 v2(162.52,37.99) 161.92,37.99 RH643.1
  IN1 w0.061: v4(162.83,37.84) 162.67,37.84 v2(162.52,37.99)
  IN3 w0.061: v4(187.29,35.25) 187.29,35.18 186.42,34.32 186.42,33.37 186.14,33.09 185.97,33.09 185.37,32.49 185.37,32 184.82,31.45 184.66,31.45 184.07,30.86 181.37,30.86 180.67,30.17 176.03,30.17 174.97,31.22 173.99,31.22 172.09,33.12 171.3,33.12 170.2,34.23 169.08,34.23 168.82,34.48 167.31,34.48 166.39,35.4 165.7,35.4 164.22,36.88 163.48,36.88 162.83,37.53 v4(162.83,37.84)
  BOTTOM w0.069: RH720.2 187.49,35.45 v4(187.29,35.25) ; UC1.DD43 162.83,38.1 v4(162.83,37.84)
SOC_SPI_0_D0_R: length 9.6
  TOP w0.069: v4(186.91,36.45) 186.7,36.45 v6(186.39,36.14)
  IN3 w0.061: v4(189.55,35.15) 189.39,35.32 188.94,35.32 188.11,36.14 187.03,36.14 186.91,36.26 v4(186.91,36.45)
  BOTTOM w0.069: v4(189.55,35.15) 189.72,35.32 191.68,35.32 191.86,35.5 192.88,35.5 193.35,35.03 JSPI1.2 ; RH23.2 187.78,36.52 187.73,36.47 RH720.1 187.48,36.45 v4(186.91,36.45)
SOC_SPI_0_D1: length 32.2
  IN3 w0.061: v4(164.48,39.59) 164.73,39.84 168.21,39.84 168.45,39.61 169.73,39.61 170.19,39.15 170.59,39.15 170.7,39.03 171.61,39.03 171.89,38.75 172.49,38.75 172.79,38.44 173.25,38.44 173.35,38.55 173.89,38.55 173.99,38.44 176.4,38.44 177.43,39.47 179.92,39.47 180.12,39.28 180.88,39.28 181.67,38.49 183.04,38.49 183.33,38.21 183.33,36.78 184.4,35.7 186.75,35.7 186.96,35.91 188.08,35.91 188.98,35.01 189.18,35.01 189.19,35.02 v4(189.22,35.02)
  BOTTOM w0.069: UC1.DF43 163.96,38.53 164.35,38.93 164.35,39.46 v4(164.48,39.59) ; v4(189.22,35.02) 189.22,35.32 189.17,35.37 v1(189.17,35.4) 189.17,35.65 189.4,35.88 RH721.2
SOC_SPI_0_D1_R: length 9.4
  TOP w0.069: v6(191.96,37.81) 191.58,37.43 v4(191.45,37.43)
  BOTTOM w0.069: JSPI1.3 194.09,34.53 194.21,34.66 194.21,35.81 193.4,36.63 193.13,36.63 192.2,37.56 191.58,37.56 v4(191.45,37.43) 191.35,37.33 191.35,37.03 191.48,36.9 191.48,36.21 191.15,35.88 RH721.1 190.92,36.47 R701.1 190.97,36.72 RH25.2
SOC_SPI_0_D2: length 41.7
  TOP w0.069: v2(163.69,38.27) 164.27,38.86 RH634.2 164.45,38.85 RH142.1 RH141.1
  IN1 w0.061: v2(163.69,38.27) 163.56,38.15 v4(163.56,37.94)
  IN3 w0.061: v4(184.95,31.95) 184.72,31.95 183.83,31.05 181.29,31.05 180.59,30.36 176.1,30.36 175.05,31.41 174.07,31.41 172.17,33.31 171.38,33.31 170.27,34.41 169.15,34.41 168.9,34.67 167.39,34.67 166.43,35.63 165.74,35.63 165.57,35.79 165.57,35.93 165.84,36.2 165.84,36.33 165.75,36.42 165.62,36.42 165.35,36.15 165.22,36.15 164.91,36.46 164.91,36.59 164.96,36.64 164.96,36.77 164.87,36.86 164.74,36.86 164.69,36.81 164.56,36.81 163.56,37.8 v4(163.56,37.94)
  BOTTOM w0.069: v4(163.56,37.94) 163.46,37.94 163.36,38.04 163.36,39.16 163.56,39.36 163.78,39.36 163.96,39.19 UC1.DF42 ; v4(184.95,31.95) 184.95,32.25 185.09,32.38 185.5,32.38 185.64,32.25 185.64,29.38 185.81,29.2 189.71,29.2 190.59,28.32 190.59,28.14 190.68,28.05 RH722.2
SOC_SPI_0_D2_R: length 0.6
  BOTTOM w0.069: RH722.1 RH26.2
SOC_SPI_0_D3: length 40.8
  TOP w0.069: RH635.1 v2(162.51,40.41)
  IN1 w0.061: v2(162.51,40.41) 162.51,40.03 162.57,39.97 v4(162.57,39.77)
  IN3 w0.061: v4(189.47,32.99) 187.43,30.94 185.47,30.94 185.21,30.68 181.45,30.68 180.75,29.98 175.95,29.98 174.9,31.03 173.91,31.03 172.01,32.93 171.23,32.93 170.12,34.04 169,34.04 168.74,34.29 167.23,34.29 166.31,35.21 165.61,35.21 164.12,36.7 163.2,36.7 162.35,37.55 162.35,37.71 161.86,38.19 161.86,38.88 162.57,39.59 v4(162.57,39.77)
  BOTTOM w0.069: UC1.DD41 162.88,39.77 v4(162.57,39.77) ; RH723.2 192.41,32.75 192.16,32.5 192.16,32 191.89,31.72 190.01,31.72 189.55,32.17 189.55,32.91 v4(189.47,32.99)
SOC_SPI_0_D3_R: length 3.5
  BOTTOM w0.069: JSPI1.7 193.31,32.53 193.08,32.76 193,32.76 192.85,32.61 192.85,32.48 193.1,32.22 193.1,31.82 193.03,31.74 192.88,31.74 192.8,31.82 192.8,32.12 192.76,32.16 RH723.1 RH27.2
SOC_SVID_ALERT#: length 14.8
  BOTTOM w0.069: RC601.2 115.28,57.93 117.53,57.93 v1(117.54,57.92) 119.07,57.92 121.48,55.52 124.2,55.52 124.42,55.75 124.42,56.58 124.8,56.96 124.8,57.32 125.54,58.06 125.92,58.06 126.07,58.21 126.07,58.49 125.78,58.79 UC1.H1
SOC_SVID_CLK: length 13.2
  BOTTOM w0.069: RC605.2 115.47,58.38 v1(116.3,58.38) 119.25,58.38 121.55,56.08 123.42,56.08 123.66,56.33 123.66,56.74 124.78,57.85 124.78,58.18 124.96,58.36 125.77,58.36 UC1.H2
SOC_SVID_DAT: length 13.9
  BOTTOM w0.069: UC1.H3 125.46,57.4 125.46,56.96 125.08,56.58 125.08,55.16 124.88,54.96 121.4,54.96 118.89,57.47 v1(118.76,57.47) RC603.2
SOLC: length 175.3
  TOP w0.069: v3(177.02,17.39) 177.56,17.39 177.94,17.01 177.94,16.02 178.33,15.63 UE1.K3
  IN2 w0.051: v4(132.2,56.05) 131.64,55.49 119.21,55.49 118.35,56.35 110.94,56.35 110.53,56.76 97.97,56.76 97.49,57.24 95.32,57.24 93.87,55.79 93.87,53.68 89.19,49.01 89.19,32.99 96.33,25.85 100.18,25.85 101.03,25 108.03,25 108.3,24.73 110.68,24.73 111.74,25.8 114.33,25.8 115.78,27.25 160.21,27.25 161.04,26.42 166.44,26.42 169.41,23.45 169.41,19.68 171.69,17.39 v3(177.02,17.39)
  BOTTOM w0.069: v4(132.2,56.05) 132.2,57.27 132.88,57.96 132.88,59.58 133.24,59.94 133.24,61.21 TP118.1 133.03,61.41 133.03,61.94 134.08,62.98 134.08,63.95 134,64.03 JEDP1.5
SP7_SDWP: length 2
  BOTTOM w0.069: QR1.1 11.35,38.24 11.35,38.49 11.92,39.06 UCR1.29
SPI0_MOSI_SYS_PWROK_MIPI60: length 3.7
  TOP w0.069: JMIPI60.36 99.38,73.05 99.79,73.45 C220.1 R644.2 R260.2
SPI_0_CLK_ROM: length 25.7
  BOTTOM w0.069: RH24.1 181.82,29.43 181.87,29.38 181.88,29.38 181.95,29.32 181.95,28.97 182.05,28.86 182.14,28.86 182.23,28.96 182.23,29.33 182.28,29.38 182.53,29.38 182.61,29.3 182.61,28.77 182.58,28.75 v1(182.44,28.75) 182.39,28.69 181.87,28.69 181.79,28.62 181.79,28.47 181.87,28.39 182.28,28.39 182.36,28.31 182.36,28.19 182.28,28.11 181.87,28.11 181.79,28.03 181.79,27.91 181.85,27.86 182.24,27.86 182.31,27.79 182.31,27.62 182.26,27.58 181.85,27.58 181.79,27.52 181.79,27.37 181.84,27.32 182.03,27.32 182.1,27.25 182.1,27.09 182.17,27.02 182.35,27.02 182.4,27.07 182.4,27.46 182.58,27.64 182.58,28.2 182.61,28.24 182.7,28.24 182.78,28.32 182.78,28.87 182.86,28.95 182.97,28.95 183.05,28.87 183.05,28.28 183.13,28.2 183.25,28.2 183.33,28.28 183.33,28.86 183.41,28.94 183.52,28.94 183.6,28.86 183.6,28.31 183.68,28.23 183.81,28.23 183.86,28.28 183.86,28.89 183.91,28.94 184.06,28.94 184.13,28.87 184.13,28.1 184.24,27.99 184.34,27.99 184.41,28.06 184.41,28.47 184.47,28.54 184.56,28.54 184.65,28.46 184.65,27.94 184.99,27.59 185.12,27.59 185.36,27.83 185.36,27.99 184.23,29.11 183.06,29.11 182.79,29.38 182.79,29.51 182.62,29.68 182.62,30.05 182.74,30.17 183.35,30.17 183.43,30.25 183.43,30.37 183.35,30.45 182.74,30.45 182.66,30.53 182.66,31.09 182.74,31.17 182.92,31.17 183,31.25 183,31.36 182.92,31.44 182.74,31.44 182.66,31.52 182.66,31.63 182.73,31.7 183.46,31.7 183.52,31.65 UH8.6
SPI_0_CLK_TPM: length 27.2
  BOTTOM w0.069: R648.2 182.06,31.67 181.29,31.67 181.01,31.39 R703.2 180.3,31.31 180.11,31.12 180.01,31.12 179.83,31.3 179.83,31.4 v1(180.03,31.6) 180.18,31.74 180.18,31.87 180.07,31.97 179.92,31.97 179.59,31.64 179.49,31.64 179.31,31.82 179.31,31.99 180.5,32.48 180.58,32.4 180.58,31.84 180.66,31.77 180.84,31.77 180.89,31.82 180.89,32.38 180.96,32.45 181.12,32.45 181.19,32.38 181.19,32.02 181.3,31.92 181.54,31.92 181.63,32.01 181.63,32.23 181.68,32.28 181.9,32.28 181.95,32.23 181.95,32.01 182.05,31.92 182.29,31.92 182.38,32.01 182.38,32.43 182.51,32.57 182.72,32.57 182.93,32.78 184.82,32.78 185.08,33.04 185.08,33.83 185.15,33.9 185.61,33.9 185.65,33.94 185.65,34.59 185.75,34.69 185.95,34.69 186.07,34.57 186.07,33.94 186.14,33.86 186.24,33.86 186.37,33.99 186.37,34.69 186.42,34.74 186.6,34.74 186.68,34.66 186.68,33.98 186.76,33.9 186.87,33.9 186.95,33.98 186.95,34.66 187.03,34.74 187.14,34.74 187.22,34.66 187.22,33.98 187.3,33.9 187.42,33.9 187.5,33.98 187.5,34.66 187.58,34.74 188.13,34.74 188.41,35.02 188.41,36.85 188.32,36.94 U712.19
SPI_0_CS#2_TPM: length 2.5
  BOTTOM w0.069: R702.2 187.76,37.86 187.57,38.05 187.57,38.2 187.62,38.24 188.07,38.24 188.14,38.32 188.14,38.46 188.08,38.52 187.67,38.52 187.58,38.61 187.58,38.69 187.81,38.92 U712.20
SPI_0_D0_ROM: length 26.6
  TOP w0.069: v6(188.56,35.48) 188.33,35.25 v4(187.92,35.25)
  IN3 w0.061: v4(187.92,35.25) 188.21,35.25 188.3,35.15 188.3,34.99 188.23,34.92 187.29,34.92 187.16,34.79 187.16,34.69 187.24,34.61 188.53,34.61 188.58,34.56 188.58,34.36 188.51,34.29 186.71,34.29 186.61,34.19 186.61,34.07 186.69,33.99 188.09,33.99 188.18,33.9 188.18,33.66 188.1,33.58 186.71,33.58 186.61,33.48 186.61,33.28 186.68,33.21 187.55,33.21 187.64,33.12 187.64,32.99 187.55,32.9 186.04,32.9 185.97,32.82 185.97,32.66 186.04,32.58 187.58,32.58 187.67,32.49 187.67,32.36 187.58,32.27 185.65,32.27 185.56,32.17 185.56,32.07 185.65,31.98 187.2,31.98 187.29,31.88 187.29,31.75 187.2,31.66 186.36,31.66 186.14,31.44 186.14,31.21 186.06,31.13 185.89,31.13 185.74,31.29 185.74,31.72 185.66,31.8 185.49,31.8 185.41,31.72 185.41,31.36 185.34,31.3 184.97,31.3 184.91,31.25 184.91,31.07 v4(184.99,31)
  BOTTOM w0.069: v4(187.92,35.25) 187.87,35.3 187.87,35.76 RH23.1 ; UH8.5 184.22,29.67 184.39,29.85 184.39,30.24 184.99,30.84 v4(184.99,31)
SPI_0_D0_TPM: length 25.6
  BOTTOM w0.069: U712.21 187.36,39.14 187.36,37.97 187.43,37.91 187.43,37.51 187.4,37.48 187.29,37.48 187.21,37.4 187.21,37.29 187.29,37.21 187.4,37.21 187.48,37.13 187.48,37.02 187.42,36.95 187.06,36.95 187.01,36.9 187.01,36.85 186.94,36.78 186.78,36.78 186.75,36.81 186.75,36.95 186.7,37 186.52,37 186.44,36.92 186.44,36.72 186.36,36.64 186.24,36.64 186.16,36.72 186.16,36.92 186.08,37 185.94,37 185.87,36.93 185.87,36.42 185.68,36.23 183.25,36.23 183.12,36.09 183.12,35.98 183.21,35.88 v1(183.99,35.88) 185.46,35.88 185.54,35.81 185.54,35.62 185.46,35.54 183.17,35.54 183.1,35.47 183.1,35.27 183.22,35.14 183.42,35.14 183.52,35.04 183.52,34.25 183.61,34.15 183.75,34.15 183.84,34.25 183.84,35.04 183.94,35.14 184.07,35.14 184.16,35.04 184.16,34.14 184.26,34.04 184.39,34.04 184.49,34.14 184.49,35.09 184.58,35.19 184.69,35.19 184.77,35.11 184.77,34.39 184.85,34.31 184.97,34.31 185.05,34.39 185.05,35.11 185.13,35.19 185.23,35.19 185.28,35.14 185.64,35.14 185.71,35.21 185.71,35.54 185.79,35.62 185.9,35.62 185.98,35.54 185.98,35.26 186.06,35.18 186.16,35.18 186.24,35.26 186.24,35.8 186.32,35.88 186.43,35.88 186.51,35.8 186.51,35.32 186.61,35.22 186.86,35.22 186.91,35.27 R700.2
SPI_0_D1_ROM: length 26.1
  TOP w0.069: v3(188.23,32.62) v6(187.73,32.62)
  IN3 w0.061: v4(189.17,33.98) 189.17,34 189.18,34 189.18,34.26 189.29,34.37 189.36,34.37 189.41,34.32 189.41,33.38 189.19,33.17 189.04,33.17 188.94,33.07 188.94,32.75 187.33,31.13 186.42,31.13 186.32,31.23 186.32,31.36 186.43,31.47 187.27,31.47 187.9,32.1 187.9,32.51 188,32.62 v3(188.23,32.62) 188.4,32.62 188.56,32.77 188.56,32.93 188.5,32.98 188,32.98 187.9,33.09 187.9,33.24 188,33.34 188.58,33.34 188.65,33.42 188.65,33.77 188.63,33.8 188.39,33.8 188.37,33.83 188.37,33.95 188.44,34.03 188.59,34.03 188.74,34.18 188.74,34.26 188.84,34.36 v4(188.96,34.36)
  BOTTOM w0.069: RH25.1 190.06,37.05 190.06,36.49 189.95,36.38 189.7,36.38 189.6,36.48 189.6,36.75 189.42,36.93 189.12,36.93 188.94,36.75 188.92,36.75 188.86,36.7 188.86,34.68 188.44,34.26 188.05,34.26 187.95,34.16 187.95,34.03 188.05,33.93 188.76,33.93 189.03,34.19 189.03,34.3 v4(188.96,34.36) ; UH8.2 191.64,32.34 191.64,32.65 191.3,32.99 190.01,32.99 189.68,33.32 189.68,33.77 189.78,33.87 190.36,33.87 190.46,33.98 190.46,34.08 190.36,34.18 189.61,34.18 189.57,34.22 189.57,34.4 189.53,34.44 189.34,34.44 189.23,34.34 189.23,34.11 189.17,34.05 v4(189.17,33.98)
SPI_0_D1_TPM: length 25.4
  IN3 w0.061: v4(189.29,36.42) 189.29,36.14 189.19,36.03 189.19,35.91 189.16,35.88 188.9,35.88 188.64,36.14 188.64,36.26 188.71,36.32 188.78,36.32 188.98,36.12 189.02,36.12 189.11,36.21 189.11,36.27 188.93,36.46 188.93,36.51 188.97,36.55 188.97,36.69 188.88,36.78 188.75,36.78 188.65,36.67 188.59,36.67 188.44,36.82 188.44,36.9 188.59,37.05 188.59,37.36 188.53,37.42 188.2,37.42 188.13,37.34 188.13,37.15 187.99,37.02 187.37,37.02 187.26,37.13 187.26,37.55 187.15,37.67 186.98,37.67 186.89,37.58 186.89,37.12 186.8,37.03 186.66,37.03 186.57,37.12 186.57,37.58 186.48,37.67 186.36,37.67 186.27,37.58 186.27,36.17 186.18,36.08 186.09,36.08 185.98,36.19 185.98,37.08 185.94,37.12 185.77,37.12 185.71,37.18 185.71,37.31 185.75,37.36 185.84,37.36 185.91,37.42 185.91,37.58 185.81,37.67 185.58,37.67 185.48,37.57 185.48,37.4 185.41,37.33 185.31,37.33 185.26,37.38 185.26,37.54 185.19,37.61 185.03,37.61 184.95,37.54 184.95,37.41 184.93,37.38 184.52,37.38 184.49,37.35 184.49,37.27 184.46,37.25 184.36,37.25 184.26,37.35 184.26,37.96 v4(183.65,38.57)
  BOTTOM w0.069: v4(189.29,36.42) 189.29,36.43 189.23,36.49 189.16,36.49 189.06,36.4 189.06,35.99 189.11,35.94 189.14,35.94 189.28,36.08 189.4,36.08 189.42,36.1 189.42,36.18 189.45,36.22 189.6,36.22 189.64,36.18 189.64,36.1 189.66,36.08 189.87,36.08 189.96,36.16 190.06,36.16 190.39,36.49 R701.2 ; v4(183.65,38.57) 183.62,38.55 183.33,38.55 183.2,38.68 183.2,38.83 183.25,38.88 183.76,38.88 183.91,38.73 183.91,38.57 183.96,38.52 184.09,38.52 184.14,38.57 184.14,38.95 184.2,39.01 184.3,39.01 184.37,38.94 184.37,38.53 184.43,38.47 184.61,38.47 184.66,38.53 184.66,38.89 184.75,38.98 184.86,38.98 184.95,38.89 184.95,38.54 185.05,38.45 185.15,38.45 185.2,38.49 185.2,39.01 185.3,39.11 185.43,39.11 185.51,39.03 185.51,38.58 185.61,38.47 185.99,38.47 186.07,38.55 186.07,38.6 185.97,38.7 185.89,38.7 185.81,38.78 U712.24
SPI_0_D2_ROM: length 25.9
  BOTTOM w0.069: RH26.1 191.8,28.05 191.91,27.93 191.91,27.74 192.06,27.6 192.12,27.6 192.18,27.65 192.18,29.18 192.07,29.29 191.94,29.29 191.86,29.21 191.86,28.45 191.78,28.37 191.63,28.37 191.55,28.45 191.55,29.13 191.47,29.21 191.36,29.21 191.28,29.13 191.28,28.45 191.2,28.37 191.09,28.37 191.01,28.45 191.01,29.14 190.93,29.22 190.77,29.22 190.69,29.15 190.69,28.75 190.64,28.7 190.49,28.7 190.44,28.75 190.44,29.09 190.37,29.16 190.03,29.16 189.98,29.21 189.98,29.41 189.89,29.51 189.44,29.51 189.35,29.59 189.35,29.79 189.43,29.86 190.48,29.86 190.55,29.94 190.55,30.07 190.48,30.14 189.42,30.14 189.35,30.21 189.35,30.36 189.43,30.44 190.38,30.44 190.46,30.52 190.46,30.63 190.38,30.71 189.43,30.71 189.35,30.79 189.35,31.74 189.41,31.8 189.65,31.8 189.75,31.69 189.75,31.03 189.82,30.97 190.01,30.97 190.08,31.04 190.08,31.47 190.13,31.52 190.32,31.52 190.4,31.45 190.4,31.01 190.45,30.95 190.64,30.95 190.7,31.02 190.7,31.44 190.79,31.52 190.93,31.52 191.06,31.4 191.2,31.4 191.32,31.52 191.53,31.52 191.64,31.41 191.83,31.41 191.94,31.52 192.13,31.52 192.18,31.47 192.18,30.64 192.09,30.55 191.93,30.55 191.85,30.47 191.85,30.4 191.93,30.32 192.16,30.32 192.54,29.93 192.54,29.68 192.33,29.47 192.23,29.47 192.15,29.55 192.15,29.87 191.87,30.14 191.71,30.14 191.52,30.33 UH8.3
SPI_0_D3_ROM: length 25.8
  IN3 w0.061: v4(190.27,28.2) 190.27,28.33 190.51,28.57 190.64,28.57 190.87,28.34 190.87,28.34 190.95,28.34 191.07,28.45 191.07,28.56 190.87,28.75 190.87,28.85 190.94,28.92 191.05,28.92 191.32,28.64 191.43,28.64 191.5,28.71 191.5,28.81 191.17,29.14 191.17,29.25 191.24,29.32 191.34,29.32 191.67,28.99 191.77,28.99 191.84,29.06 191.84,29.16 191.29,29.71 191.29,29.82 191.36,29.89 191.46,29.89 192.01,29.33 192.12,29.33 192.19,29.4 192.19,29.5 191.63,30.06 191.63,30.16 191.7,30.23 191.8,30.23 192.15,29.89 192.26,29.89 192.36,29.98 192.36,30.1 192.04,30.42 192.04,30.55 192.14,30.65 192.27,30.65 192.62,30.29 192.74,30.29 192.77,30.33 192.77,30.52 192.7,30.6 192.7,30.73 v4(192.86,30.89)
  BOTTOM w0.069: v4(190.27,28.2) 190.3,28.23 190.3,28.33 189.63,29.01 189.4,29.01 189.25,28.85 189.11,28.85 188.95,29.01 188.85,29.01 188.7,28.85 188.56,28.85 188.4,29.01 188.3,29.01 188.15,28.85 188.01,28.85 187.86,29.01 187.76,29.01 187.6,28.85 187.46,28.85 187.31,29.01 186.59,29.01 186.51,28.93 186.51,28.76 186.43,28.68 186.32,28.68 186.24,28.76 186.24,28.93 186.16,29.01 186.07,29.01 185.94,28.87 185.81,28.87 185.44,29.24 185.44,31.43 185.19,31.68 185.11,31.68 185.03,31.6 185.03,31.34 184.95,31.26 184.84,31.26 184.76,31.34 184.76,31.65 184.67,31.74 184.55,31.74 184.5,31.69 184.5,31.45 184.47,31.42 184.27,31.42 184.23,31.46 184.23,31.88 183.89,32.21 UH8.7 ; RH27.1 192.48,30.88 192.48,30.27 192.71,30.04 v1(192.83,30.04) 192.84,30.03 193.07,30.03 193.17,30.13 193.17,30.18 193.14,30.21 193.07,30.21 193.02,30.26 193.02,30.36 193.05,30.4 193.31,30.4 193.38,30.47 193.38,30.56 193.31,30.63 192.87,30.63 192.81,30.7 192.81,30.84 v4(192.86,30.89)
SPK1_DET#: length 172.5
  IN1 w0.061: v4(18.35,36.19) 18.39,36.23 19.64,36.23 22.06,33.8 22.06,32.54 21.8,32.28 21.8,30.22 25.19,26.83 28.82,26.83 31.34,24.31 31.34,22.58 33.08,20.83 33.84,20.83 35.22,19.45 38.24,19.45 47.48,10.22 69.54,10.22 70.39,11.07 75.71,11.07 91.67,27.03 105.06,27.03 105.95,27.92 107.29,27.92 v3(108.22,28.85)
  IN2 w0.051: v3(156.17,36.01) 155.36,35.2 155.36,34.82 151.3,30.75 113.77,30.75 111.96,28.95 109.74,28.95 109.36,28.57 108.5,28.57 v3(108.22,28.85)
  IN3 w0.061: v4(154.35,36.31) 154.53,36.13 155.1,36.13 155.21,36.24 155.51,36.24 155.74,36.01 v3(156.17,36.01)
  BOTTOM w0.069: JSPK1.3 18.66,34.2 18.35,34.51 v4(18.35,36.19) ; v4(154.35,36.31) 154.4,36.26 154.4,35.58 UC1.CF49 153.97,35.28 151.9,33.22 RH745.1
SPK2_DET#: length 147.6
  IN2 w0.051: v3(163.89,30.35) 164.36,30.35 165,30.98 168.93,30.98 171.2,28.71 173.32,28.71 173.98,28.04 175.9,28.04 176.29,27.65 177.85,27.65 178.64,26.87 179.65,26.87 182.09,24.43 185.31,24.43 185.97,23.77 187.17,23.77 187.63,23.31 187.63,22.11 188.51,21.23 188.51,18.14 189.62,17.04 195.31,17.04 201.79,10.56 210.14,10.56 210.86,9.83 216.21,9.83 216.69,9.35 222.19,9.35 222.4,9.57 223.66,9.57 224.47,10.38 233.39,10.38 233.7,10.69 240.89,10.69 246.09,15.89 246.09,15.89 246.84,16.64 v3(247.11,16.64)
  IN3 w0.061: v4(266.32,30.87) 265.77,30.87 259.15,24.24 255.65,24.24 254.59,23.19 254.59,23.08 253.51,21.99 253.4,21.99 253.02,21.62 253.02,21.23 252.59,20.8 251.87,20.8 248.08,17.01 247.48,17.01 v3(247.11,16.64) ; v3(163.89,30.35) 163.87,30.32 163.35,30.32 161.86,31.82 159.43,31.82 157.95,33.29 157.95,34.16 156.87,35.25 155.71,35.25 155.44,35.52 154.63,35.52 154.26,35.9 153.54,35.9 153.2,36.24 v4(153.2,36.52)
  BOTTOM w0.069: RH746.1 150.44,33.96 151.92,33.96 153.07,35.11 153.07,35.7 UC1.CC48 152.84,36.15 v4(153.2,36.52) ; v4(266.32,30.87) 269.46,30.87 269.79,31.2 JSPK2.3
SPK_L+: length 11.7
  TOP w0.152: UA2.5 23.38,25.42 23.1,25.7 22.06,25.7 18.81,28.95 18.81,30.73 17.06,32.48 17.06,32.76 17.16,32.86 17.41,32.86 v5(17.69,32.58)
  vias: v1(20.23,30.45) v5(18.25,32.58)
SPK_L+_R: length 1
  TOP w0.152: 23.99,27.37 23.99,28.31 v1(23.94,28.36)
SPK_L-: length 12.4
  TOP w0.152: v5(17.69,33.6) 17.39,33.29 16.85,33.29 16.65,33.09 16.65,32.25 18.4,30.5 18.4,28.77 21.68,25.49 21.68,24.99 21.93,24.74 UA2.6
  vias: v1(21.38,33.19) v5(18.25,33.6)
SPK_L-_R:
  vias: v1(26.61,25.32)
SPK_R+: length 9
  TOP w0.152: v3(268.68,30.05) 268.72,30.01 269.06,30.01 269.23,30.18 269.23,30.57 269.38,30.73 UA3.5 ; v1(264.83,30.37) 265.34,30.37 265.99,29.72 CA111.1
  IN2 w0.152: v4(268.95,32.96) v4(268.44,32.96) 268.31,33.09 267.68,33.09 267.25,32.66 267.25,31.45 267.87,30.83 268.54,30.83 268.87,30.5 268.87,30.14 268.78,30.05 v3(268.68,30.05)
  vias: v2(266.87,29.61) v2(267.17,29.91) v3(266.87,29.61) v3(267.17,29.91)
SPK_R+_R: length 1.5
  TOP w0.152: LA22.1 266.43,30.5 v1(266.31,30.5)
SPK_R-: length 9.3
  TOP w0.152: v1(270.75,40.3) 269.79,40.3 269.56,40.07 ; v3(268.63,29.54) 268.65,29.53 269.31,29.53 269.68,29.16 269.85,29.16 270.05,29.36 UA3.6
  IN2 w0.152: v4(268.7,32.2) v4(268.19,32.2) 268.19,32.53 268.06,32.66 267.86,32.66 267.65,32.45 267.65,31.62 268.03,31.23 268.71,31.23 269.28,30.67 269.28,29.97 268.85,29.54 v3(268.63,29.54)
  vias: v2(269.1,39.31) v2(269.58,39.31) v3(269.1,39.31) v3(269.58,39.31)
SPK_R-_R:
  vias: v1(269.53,36.06)
SPKR: length 167
  TOP w0.069: v2(155.56,36.9) 155.4,37.06 RH667.1
  IN1 w0.061: v3(155.72,36.54) 155.72,36.75 v2(155.56,36.9)
  IN2 w0.051: v3(155.72,36.54) 156.3,37.13 157.19,37.13 157.7,36.62 157.7,36.11 157.9,35.91 157.9,35.27 158.15,35.02 158.15,32.96 158.92,32.2 164.25,32.2 164.71,31.74 169.25,31.74 171.52,29.47 174.62,29.47 175.17,28.92 177.97,28.92 178.45,28.44 178.45,27.93 178.91,27.48 179.91,27.48 182.34,25.04 185.56,25.04 186.22,24.38 187.42,24.38 188.92,22.88 188.92,21.7 189.22,21.4 189.22,18.81 189.5,18.53 189.5,18.05 189.9,17.65 195.57,17.65 202.04,11.17 210.39,11.17 211.11,10.44 216.46,10.44 216.94,9.96 221.92,9.96 222.13,10.18 223.4,10.18 224.22,10.99 233.14,10.99 233.64,11.49 235.67,11.49 236.65,12.47 241.81,12.47 245.48,16.14 245.48,16.14 248.88,19.55 248.88,22.51 251.3,24.92 251.3,26.13 252.82,27.65 252.82,28.33 v3(252.94,28.45)
  IN3 w0.061: v3(155.72,36.54) 155.38,36.54 v4(155.34,36.59) ; v4(261.33,62.43) 260.52,62.43 258.59,60.5 258.19,60.5 255.86,58.17 255.86,53.31 257.06,52.11 257.06,47.95 255.49,46.38 255.49,35.11 257.19,33.41 257.19,31.24 255.69,29.74 254.12,29.74 254.12,29.74 252.94,28.56 v3(252.94,28.45)
SRTCRST#: length 12.6
  IN3 w0.061: v4(170.99,34.95) 170.6,35.34 169.48,35.34 168.94,35.88 168.57,35.88 168.29,35.6 167.7,35.6 167.27,36.03 167.27,36.75 167.11,36.91 v4(165.97,36.91)
  BOTTOM w0.069: v4(170.99,34.95) 170.99,34.26 172.44,32.81 173.38,32.81 173.83,32.36 173.83,32.07 CH46.1 174.46,31.69 174.46,32.12 RH572.2
SSD_DEVSLP: length 61.8
  IN1 w0.061: v3(164.1,36.16) 164.65,36.16 166.24,34.57 170.34,34.57 171.36,33.55 171.36,33.02 173.23,31.15 173.23,29.33 174.13,28.43 174.13,28.38 v4(174.13,28.37)
  IN2 w0.051: v3(164.1,36.16) 163.95,36.16 163.6,36.51 162.77,36.51 162.54,36.28 161.75,36.28 161.71,36.31 161.71,36.78 161.52,36.97 160.69,36.97 160.21,37.46 160.21,40.3 161.38,41.47 161.38,42.84 161.69,43.15 163.37,43.15 164.81,44.59 164.81,44.95 165.95,46.09 166.47,46.09 168.72,48.34 168.72,49.47 168.16,50.03 168.16,51.69 v3(168.92,52.45)
  IN3 w0.061: v4(169.51,53.85) 169.58,53.92 170.17,53.92 170.4,53.69 170.4,53.23 170.17,53 169.48,53 v3(168.92,52.45)
  BOTTOM w0.069: RS380.1 174.13,28.49 174.13,28.38 v4(174.13,28.37) 174.27,28.23 174.39,28.23 175.78,26.84 176.7,26.84 180.38,23.16 182.61,23.16 182.97,22.8 182.97,18.1 182.02,17.15 JNGFF1.38
SSD_IFDET: length 41.9
  IN2 w0.051: v3(158.03,37.23) 158.79,36.47 158.79,33.84 159.36,33.27 159.53,33.27 160.06,32.73 164.38,32.73 164.91,32.2 169.44,32.2 171.71,29.93 174.14,29.93 174.51,30.29 175.16,30.29 175.93,29.53 179.72,29.53 180.87,28.38 184.06,28.38 185.02,27.42 186.53,27.42 187.64,26.31 188.22,26.31 189.35,25.18 189.37,25.18 189.59,24.96 v4(190.39,24.96)
  IN3 w0.061: v3(158.03,37.23) 158.47,37.67 v4(158.47,38.96)
  BOTTOM w0.069: v4(190.39,24.96) 190.77,24.58 RS384.1
SSD_PWR_EN: length 45.3
  TOP w0.069: v2(170.14,14.17) 169.66,13.68 169.66,12.59 170.42,11.83 170.42,11.02 v1(171.21,10.23) 171.21,10.1 172.63,8.68 172.63,3.71 172.77,3.57 174.21,3.57 174.31,3.68 R81.1
  IN1 w0.061: v3(163.46,30.75) 163.26,30.55 163.26,29.89 164.57,28.58 166.6,28.58 170.53,24.65 170.53,22.2 170.39,22.06 170.39,21.08 170.35,21.04 170.35,14.37 v2(170.14,14.17)
  IN3 w0.061: v4(155.34,35.93) 155.6,35.93 155.88,35.65 157.01,35.65 158.28,34.38 158.28,34.03 160.33,31.98 161.93,31.98 163.15,30.75 v3(163.46,30.75)
SSD_SCP#: length 13.7
  TOP w0.069: RE522.1 181.16,8.06 181.17,8.07 RE426.1 ; RE522.1 180.07,7.5 180.07,7.49 179.87,7.28 RS379.2 ; RE522.1 180.35,8.35 180.35,9.14 v2(180.68,9.47) ; UE1.H5 179.93,17.03 v5(179.54,17.42)
  IN1 w0.061: v3(180.21,9.16) 180.52,9.47 v2(180.68,9.47)
  IN3 w0.061: v3(180.21,9.16) v4(179.97,9.39)
  BOTTOM w0.069: v5(179.54,17.42) 179.54,16.07 180.2,15.41 180.2,9.62 v4(179.97,9.39)
SSD_SCP_PWR_EN: length 16.6
  TOP w0.069: UZ6.2 173.26,5.61 173.83,5.61 v2(173.85,5.63) 173.85,4.75 RE525.2 ; v2(180.3,14.11) 180.3,13.71 180.73,13.28 UE1.N6
  IN1 w0.061: v2(180.3,14.11) 179.44,13.25 178.97,13.25 176.83,11.11 176.74,11.11 176.21,10.59 176.21,6.38 175.46,5.63 v2(173.85,5.63)
SUS_ON_EC: length 30.8
  TOP w0.069: RE95.2 173.67,20.81 176.16,20.81 176.43,20.54 176.82,20.54 177.17,20.19 v2(177.53,20.19)
  IN1 w0.061: v2(177.53,20.19) 176.7,21.02 176.7,22.67 177.13,23.11 177.13,23.79 v3(177.66,24.33)
  IN3 w0.061: v4(186.37,24.72) 186.19,24.54 182.79,24.54 182.63,24.39 177.72,24.39 v3(177.66,24.33)
  BOTTOM w0.069: v4(186.37,24.72) 186.41,24.72 187.14,25.44 187.14,26.15 187.69,26.71 189.62,26.71 189.75,26.59 189.75,26.1 190.03,25.82 v1(190.46,25.82) 190.83,25.82 192.41,24.25 193.56,24.25 193.78,24.03 UC5.2 193.78,23.11 193.86,23.03 RE22.1
SUS_ON_P: length 80
  TOP w0.069: R6229.1 v2(167.78,2.85) ; v2(171.29,3.57) 171.29,3.58 UC23.4 171.29,4.04 171.72,4.47 v3(171.72,6.79) 171.72,7.43 v1(171.59,7.56)
  IN1 w0.061: v2(171.29,3.57) 171.11,3.57 170.76,3.23 167.91,3.23 167.78,3.1 v2(167.78,2.85)
  IN2 w0.051: v4(186.58,7.89) 186.28,7.89 185.89,8.28 181.72,8.28 180.36,6.91 178.16,6.91 177.53,6.29 173.48,6.29 172.97,6.79 171.73,6.79 v3(171.72,6.79)
  IN3 w0.061: v4(211.93,19.42) 212.48,19.42 213.17,18.74 218.98,18.74 v4(220.2,19.96)
  BOTTOM w0.069: v4(186.58,7.89) 186.15,8.31 186.15,11.56 185.77,11.94 185.77,20.6 188.05,22.88 191.48,22.88 RC695.2 191.86,22.55 192.34,22.55 192.52,22.73 193.59,22.73 194.43,21.88 UC5.4 194.77,21.74 194.79,21.76 RC736.1 195.42,21.79 195.42,21.96 195.29,22.09 RE22.2 RE21.1 195.95,22.45 196.51,23 197.56,23 197.73,22.84 197.73,22.22 198.01,21.94 198.01,20.79 199.66,19.14 199.66,18.63 200.8,17.49 202.53,17.49 203.16,18.13 207.13,18.13 207.23,18.23 208.83,18.23 209.74,19.14 210.94,19.14 211.21,19.42 v4(211.93,19.42)
SUS_ON_P_R: length 2.6
  TOP w0.069: UT3.3 166.55,3.05 166.83,2.77 167.23,2.77 167.43,2.96 167.43,3.45 R6229.2
SUSCLK: length 109.4
  TOP w0.069: RW8.2 v2(253.75,20.15)
  IN1 w0.061: v3(242.61,14.17) 242.64,14.17 243.83,15.36 247.01,15.36 247.67,16.02 249.5,16.02 253.63,20.15 v2(253.75,20.15)
  IN2 w0.051: v4(178.93,29.02) 179.74,28.21 180.21,28.21 182.65,25.77 185.86,25.77 186.52,25.11 187.73,25.11 189.66,23.19 189.66,22.01 189.96,21.71 189.96,19.12 190.23,18.84 190.23,18.48 190.64,18.08 195.75,18.08 202.22,11.6 210.57,11.6 211.29,10.88 216.64,10.88 217.12,10.4 220.79,10.4 221.59,11.19 223.38,11.19 223.63,11.45 232.98,11.45 234.91,13.37 239.39,13.37 240.31,14.29 242.48,14.29 v3(242.61,14.17)
  IN3 w0.061: v4(163.31,33.2) 165.46,33.2 166.73,31.93 168.84,31.93 171.55,29.21 174.39,29.21 174.53,29.08 178.5,29.08 178.55,29.02 v4(178.93,29.02)
  BOTTOM w0.069: UC1.DF49 164.11,34.17 163.48,33.54 163.48,33.34 163.34,33.2 v4(163.31,33.2)
SUSCLK_R: length 2.8
  TOP w0.069: v4(253.81,19.44) 253.88,19.44 254,19.56 RW8.1
  BOTTOM w0.069: v4(253.81,19.44) 253.75,19.51 UWL1.A25 UWL1.27
SVID_ALERT#: length 12.7
  IN3 w0.061: v4(107.76,57.78) 107.95,57.97 113.78,57.97 113.92,57.83 v4(113.98,57.83)
  BOTTOM w0.069: RC601.1 114.42,58.11 114.14,57.83 v4(113.98,57.83) 113.7,58.11 RC602.2 ; v4(107.76,57.78) 106.95,56.96 v1(105.83,56.96) 104.41,56.96 PR1127.2 PR1130.2
SVID_ALERT#_VR: length 3.4
  BOTTOM w0.203: PU1100.14 100.5,59.71 100.72,59.49 100.72,58.72 v1(101.36,58.08) 101.69,57.75 101.97,57.75 PR1130.1
SVID_CLK: length 13.6
  IN3 w0.061: v4(107.79,58.56) 107.92,58.43 v4(114.02,58.43)
  BOTTOM w0.069: v4(107.79,58.56) 107.38,58.97 v1(106.03,58.97) 104.43,58.97 PR1129.2 PR1132.2 ; C4195.1 113.37,59.31 113.58,59.11 RC606.2 113.7,58.74 v4(114.02,58.43) 114.34,58.74 RC605.1
SVID_CLK_VR: length 2.4
  BOTTOM w0.203: PR1132.1 101.24,60.51 PU1100.12
SVID_DAT: length 12
  IN3 w0.061: v4(108.2,57.71) 108.39,57.52 113.53,57.52 v4(113.58,57.47)
  BOTTOM w0.069: RC603.1 114.37,57.32 113.74,57.32 v4(113.58,57.47) ; PR1131.2 PR1128.2 104.41,57.98 107.02,57.98 107.15,58.11 v1(107.2,58.11) 107.8,58.11 v4(108.2,57.71)
SVID_DAT_VR: length 2.8
  BOTTOM w0.203: PU1100.13 100.92,60.11 101.31,59.72 v1(101.31,59.5) 101.31,59.48 102.25,58.54 PR1131.1
SW_USB20_1_N4: length 8.4
  BOTTOM w0.081: ML16.1 277.79,64.61 277.69,64.71 277.69,64.84 277.62,64.91 277.41,64.91 277.25,64.75 v7(277.25,62.53) 277.25,61.06 278.83,59.49 278.83,58.9 279.02,58.7 UM2.2
SW_USB20_1_N4_R: length 4.2
  BOTTOM w0.081: JUSBC2.A7 282.58,65.15 282.43,65.3 282.02,65.3 281.53,64.81 280.71,64.81 D416.2 280.3,64.76 279.81,64.76 279.67,64.61 ML16.2
SW_USB20_1_N8: length 19.8
  TOP w0.081: UM1.2 31.31,68.37 31.41,68.47 31.41,68.75 31.2,68.95 v7(29.42,68.95) 21.76,68.95 21.45,68.65 16.6,68.65 16.27,68.98 16.27,69.25 v5(16.1,69.41)
  BOTTOM w0.081: v5(16.1,69.41) 16.1,69.14 16.19,69.05 16.4,69.05 16.49,68.97 16.49,68.49 16.24,68.24 15.23,68.24 15.08,68.39 ML6.1
SW_USB20_1_N8_R: length 11.8
  BOTTOM w0.081: JUSBC1.A7 10.15,77.08 10.29,76.94 10.6,76.94 11.95,75.58 v7(11.95,75.18) 11.95,73.3 11.96,73.29 11.96,72.81 11.95,72.8 11.95,68.45 12.13,68.27 12.34,68.27 D408.2 12.87,68.46 12.94,68.39 ML6.2
SW_USB20_1_P4: length 8.5
  BOTTOM w0.081: ML16.4 277.32,65.11 277.05,64.84 277.05,60.98 v7(277.28,60.75) 278.62,59.41 UM2.1
SW_USB20_1_P4_R: length 4.3
  BOTTOM w0.081: JUSBC2.A6 282.58,65.65 282.43,65.5 281.93,65.5 v7(281.68,65.25) 281.45,65.02 280.72,65.02 D415.1 280.18,64.96 279.85,64.96 279.7,65.11 ML16.3
SW_USB20_1_P8: length 19.9
  TOP w0.081: v5(16.69,69.41) 16.47,69.19 16.47,69.06 16.68,68.85 21.37,68.85 21.67,69.16 31.28,69.16 31.61,68.83 31.61,68.45 31.71,68.35 UM1.1
  BOTTOM w0.081: v5(16.69,69.41) 16.69,68.41 16.32,68.04 15.23,68.04 15.08,67.89 ML6.4
SW_USB20_1_P8_R: length 11.9
  BOTTOM w0.081: ML6.3 12.96,67.89 12.87,67.8 D407.1 12.27,68.06 12.05,68.06 11.75,68.36 11.75,72.88 11.75,72.89 11.75,72.95 v7(11.75,72.96) 11.75,74.85 11.74,74.85 11.74,75.5 10.51,76.73 10.28,76.73 10.13,76.59 JUSBC1.A6
SW_USB20_2_N4: length 10.4
  TOP w0.081: ML17.1 278.92,65.15 278.77,65.01 278.31,65.01 277.99,64.69 277.99,61.12 278.86,60.25 v5(280.32,60.25)
  BOTTOM w0.081: UM2.4 279.82,58.84 279.72,58.94 v7(279.72,59.32) 279.72,60.3 279.87,60.44 280.13,60.44 v5(280.32,60.25)
SW_USB20_2_N4_R: length 5.2
  TOP w0.081: ML17.2 280.6,65.15 280.73,65.02 281.09,65.02 D418.2 281.55,65.07 281.84,65.07 282.64,65.87 283.9,65.87 v5(284.06,66.03)
  BOTTOM w0.081: v5(284.06,66.03) 284.19,65.9 JUSBC2.B7
SW_USB20_2_N8: length 21.9
  IN1 w0.076: v2(30.51,67.97) 30.61,68.07 30.61,68.38 29.95,69.03 19.3,69.03 18.64,68.37 15.2,68.37 11.9,71.67 11.9,72.29 v2(11.75,72.44)
SW_USB20_2_N8_R: length 7
  TOP w0.081: v5(8.88,76.42) 9.21,76.42 9.28,76.5 9.28,76.7 9.39,76.8 9.59,76.8 10.3,76.09 10.77,76.09 D410.2 11.31,76.14 11.51,76.14 11.9,75.75 11.9,74.06 11.75,73.91 ML7.2
  BOTTOM w0.081: v5(8.88,76.42) 8.79,76.33 JUSBC1.B7
SW_USB20_2_P4: length 10.3
  TOP w0.081: v5(280.32,60.84) 280.02,60.84 279.95,60.76 279.95,60.55 279.86,60.46 278.94,60.46 278.19,61.21 278.19,64.6 278.4,64.8 278.76,64.8 278.91,64.65 ML17.4
  BOTTOM w0.081: UM2.3 279.42,58.84 279.52,58.94 279.52,60.38 279.79,60.65 280.13,60.65 v5(280.32,60.84)
SW_USB20_2_P4_R: length 5.2
  TOP w0.081: v5(284.06,65.45) 283.85,65.66 282.73,65.66 281.93,64.86 281.62,64.86 D417.1 281.12,64.81 280.71,64.81 280.55,64.65 ML17.3
  BOTTOM w0.081: JUSBC2.B6 284.14,65.4 284.11,65.42 284.09,65.42 v5(284.06,65.45)
SW_USB20_2_P8: length 21.9
  IN1 w0.076: v2(12.25,72.44) 12.1,72.29 12.1,71.75 15.28,68.57 18.55,68.57 19.22,69.23 30.04,69.23 30.81,68.46 30.81,68.07 v2(30.91,67.97)
SW_USB20_2_P8_R: length 7.1
  TOP w0.081: ML7.3 12.25,73.91 12.1,74.06 v7(12.1,75.46) 12.1,75.84 11.6,76.34 11.25,76.34 D409.1 10.72,76.29 10.39,76.29 9.67,77.01 v5(8.85,77.01)
  BOTTOM w0.081: JUSBC1.B6 8.68,76.83 v5(8.85,77.01)
SWD_CLK_MCU: length 26.1
  TOP w0.069: UW1.1 262.73,9.91 261.91,9.09 261.91,8.65 261.18,7.92 261.18,6.6 v1(260.78,6.2) 258.84,4.26 258.52,4.26 v5(257.73,3.47)
  BOTTOM w0.069: v5(257.73,3.47) 257.29,3.9 254.33,3.9 251.97,1.54 242.99,1.54 RW127.2
SWD_DAT_MCU: length 28.7
  TOP w0.069: v5(257.09,3.5) 257.14,3.5 260.95,7.31 v1(260.95,8.65) 260.95,10.86 261.17,11.09 UW1.24
  BOTTOM w0.069: RW126.2 240.63,1.36 252.03,1.36 253.68,3.01 256.6,3.01 v5(257.09,3.5)
SYNC: length 30.3
  TOP w0.508: v2(95.21,45.56) 95.49,45.28 v1(96.1,45.28) 96.86,45.28 97.45,45.86 97.45,54.2 97.96,54.7 97.96,58.04 97.93,58.06 v4(97.9,58.06)
  IN1 w0.254: v4(94.62,46.11) 94.67,46.11 v2(95.21,45.56)
  IN1 w0.508: v2(95.21,45.56) 95.7,45.08 95.7,43.32 94.68,42.31 94.68,39.67 95.59,38.75 96.31,38.75 96.56,38.5 96.56,37.64 96.08,37.15 v3(95.95,37.15)
  IN3 w0.254: v4(94.58,36.47) 94.81,36.47 95.26,36.92 95.72,36.92 v3(95.95,37.15)
  BOTTOM w0.203: v4(94.62,46.11) 94.54,46.03 PU1201.10
  BOTTOM w0.254: PU1200.10 94.54,36.38 94.58,36.42 v4(94.58,36.47) ; PU1100.19 v4(97.9,58.06)
SYS_CFG: length 2.9
  TOP w0.069: v1(265.42,9.09) 265.38,9.05 RW227.2 RW226.1 263.87,9.52 263.73,9.65 UW1.3
SYS_PRES#: length 102.6
  TOP w0.069: v2(111.11,3.14) 111.11,2.1 111.38,1.83 PU600.5 113.17,1.83 PR605.1
  IN1 w0.061: v2(111.11,3.14) 103.11,3.14 102.38,3.88 v2(102.07,3.88) 100.42,3.88 100.07,3.53 95.48,3.53 92.76,6.25 80.54,6.25 80.06,6.73 74.93,6.73 74.4,6.2 45.76,6.2 45.19,6.76 42.32,6.76 41.57,6.01 41.57,5.8 41.14,5.37 40.37,5.37 39.82,4.82 39.26,4.82 38.79,4.35 38.32,4.35 37.84,3.86 37.45,3.86 37.22,4.08 37.22,5.11 36.56,5.77 36.56,7.21 37.28,7.92 37.4,7.92 v3(37.5,8.02)
  IN3 w0.061: v3(37.5,8.02) 37.56,7.97 39.56,7.97 v4(39.61,7.92)
  BOTTOM w0.069: v4(39.61,7.92) 40.35,7.92 41.05,8.62 41.05,11.24 41.49,11.68 41.49,15.99 JBATT1.7 37.67,19.82 PR110.2
SYS_PWROK: length 149.6
  TOP w0.069: v1(170.7,50.36) 170.14,50.36 v3(169.99,50.21) 169.7,50.21 RH594.2 ; RE157.2 171.55,16.88 172.02,17.35 v3(172.02,18.05)
  IN1 w0.061: v2(179.13,17.79) 178.99,17.65 v3(178.99,17.46) ; v3(161.25,39.4) 161.17,39.4 160.44,38.68 160.44,37.38 160.82,37 162.2,37 162.83,36.36 162.83,35.85 163.71,34.97 163.91,34.97 165.4,33.47 167.71,33.47 170.21,30.96 170.21,30.73 170.85,30.1 170.85,28.78 171.39,28.23 171.39,27.33 170.94,26.88 170.94,26.09 170.66,25.81 170.66,25.56 171.26,24.96 171.26,22.11 171.95,21.42 171.95,20.62 172.27,20.29 172.27,19.04 172.02,18.79 v3(172.02,18.05)
  IN2 w0.051: v3(99.15,74.4) 99.15,69.24 101.39,67.01 101.39,65.08 102.71,63.76 102.71,63.24 107.32,58.62 111.45,58.62 111.87,58.21 118.74,58.21 121.62,61.09 128.3,61.09 128.97,60.42 129.55,60.42 130.04,60.9 134.79,60.9 135.39,60.3 135.69,60.3 136.12,60.72 138.44,60.72 138.85,60.32 142.61,60.32 142.91,60.62 147.19,60.62 148.59,59.23 153.07,59.23 153.77,58.53 156.2,58.53 158.84,55.9 160.45,55.9 161.99,57.43 163.13,57.43 164.75,55.82 168.51,55.82 168.76,56.07 169.34,56.07 170.68,54.72 170.68,50.9 v3(169.99,50.21) 169.99,49.91 169.18,49.1 169.18,48.27 166.57,45.66 166.06,45.66 165.13,44.72 165.13,44.37 163.76,43 161.8,43 161.59,42.79 161.59,39.82 161.25,39.48 v3(161.25,39.4) ; v3(172.02,18.05) 172.38,17.7 174.69,17.7 174.72,17.72 178.73,17.72 v3(178.99,17.46)
SYS_PWROK_R: length 3.3
  TOP w0.069: v4(167.68,50.23) 167.82,50.37 RH594.1 169.76,51.18 v6(169.76,51.55)
  BOTTOM w0.069: v4(167.68,50.23) 167.92,49.99 UC1.DP19
SYS_RESET#: length 56.2
  TOP w0.069: JAPS1.13 192.78,27.35 v6(191.78,28.34) 191,29.13 191,32.28 192.24,33.52 192.24,34.27 192.26,34.29 v3(192.26,34.38) ; RC244.1 RC432.1 174.84,55.61 174.84,54.68 176.98,52.54 v4(176.98,51.05)
  IN2 w0.051: v3(192.26,34.38) 192.05,34.59 187.13,34.59 185.73,35.98 185.01,35.98 184.77,36.22 184.77,37.22 183.78,38.22 183.78,38.95 181.91,40.82 181.68,40.82 181.32,41.18 181.32,41.72 180.96,42.08 180.96,42.53 179.54,43.95 179.54,45.81 179.8,46.07 179.8,48.23 v4(176.98,51.05)
  IN3 w0.061: v4(171.77,50.92) 174.41,50.92 174.66,50.67 176.7,50.67 177,50.97 177,51.02 v4(176.98,51.05)
  BOTTOM w0.069: v4(176.98,51.05) 176.77,51.25 CC651.1 ; v4(171.77,50.92) 168.72,50.92 168.39,50.59 166.68,50.59 UC1.DK19
SYS_RESET#_R: length 2
  TOP w0.069: RC432.2 173.15,56.06 RC430.2 172.99,56.02 172.31,56.71 UC29.4
SYSPWR_PRES: length 6.3
  TOP w0.069: UE1.B1 176.55,21.61 171.86,21.61 RE154.2 RE152.2
TACH_FAN1: length 115.6
  IN1 w0.061: v2(178.33,19.39) 177.86,18.93 177.86,16.81 176.37,15.31 176.37,13.95 v3(176.29,13.88)
  IN2 w0.051: v4(73.5,8.58) 73.52,8.6 80.61,8.6 81.12,8.09 93.63,8.09 94.95,6.77 104.28,6.77 107.25,9.75 122.95,9.75 123,9.8 136.13,9.8 136.63,10.3 140.84,10.3 141.12,10.03 165.75,10.03 168.14,12.41 170.99,12.41 171.72,13.15 175.56,13.15 v3(176.29,13.88)
  BOTTOM w0.069: D132.2 73.58,6.61 73.41,6.78 73.41,6.92 73.46,6.97 R37.1 73.46,7.6 73.5,7.63 v4(73.5,8.58)
TACH_FAN2: length 66.5
  IN1 w0.061: v2(176.73,20.19) 176.73,19.87 176.8,19.8 176.8,19.82 v3(176.8,19.82)
  IN3 w0.061: v4(230.15,6.7) 229.49,7.35 225.98,7.35 225.01,6.38 223.79,6.38 223.59,6.57 219.33,6.57 219.1,6.8 207.02,6.8 206.83,6.61 198.7,6.61 198.54,6.45 197.72,6.45 197.67,6.4 196.92,6.4 196.54,6.02 195.88,6.02 195.77,5.91 193.73,5.91 193.24,6.4 191.2,6.4 190.71,6.88 190.23,6.88 188.01,9.1 188.01,9.67 187.21,10.48 185.86,10.48 184.35,11.99 183.39,11.99 181.6,13.77 181.6,15.46 182.03,15.89 182.03,18.13 181.73,18.43 178.75,18.43 178.21,18.97 177.65,18.97 176.8,19.81 v3(176.8,19.82)
  BOTTOM w0.069: v1(229.96,8.25) 230.11,8.09 230.11,8.04 230.19,7.97 R40.1 230.19,6.93 230.15,6.89 v4(230.15,6.7) 230.15,6.16 D12.2
TAP_FW_RDY#: length 53
  TOP w0.069: UE1.M10 183.62,13.48 183.62,12.83 183.8,12.65 184.07,12.65 185.6,11.12 185.6,10.02 185.35,9.77 v2(185.23,9.77) ; v2(185.23,8.33) 185.23,8.32 185.08,8.17 183.15,8.17 183.05,8.27 182.13,8.27 181.8,7.93 RE493.1
  IN1 w0.061: v2(185.23,9.77) v2(185.23,8.33) 185.23,8.33 185.23,7.39 v3(185.26,7.37) ; v3(196.1,7.23) v2(196.64,7.23)
  IN2 w0.051: v3(185.26,7.37) 185.63,7.37 186.17,6.82 187.64,6.82 188.05,7.23 v3(196.1,7.23) 197.05,7.23 197.81,6.47 198.43,6.47 198.63,6.67 222.96,6.67 223.16,6.88 v4(223.99,6.88)
  BOTTOM w0.069: v4(223.99,6.88) 224.15,7.03 224.15,8.07 JIO1.31
TAP_RESET#: length 54.7
  IN1 w0.061: v3(219.75,11.83) 219.09,11.83 v2(219.03,11.89) ; v3(185.94,8.96) 185.74,8.96 185.51,9.19 185.51,10.15 184.73,10.93 v2(184.73,13.79)
  IN3 w0.061: v4(222.64,6.15) 219.06,6.15 218.73,6.48 207.38,6.48 207.03,6.12 197.85,6.12 197.8,6.07 197.05,6.07 196.56,5.59 193.6,5.59 193.14,6.04 189.98,6.04 189,7.02 189,7.2 187.8,8.39 186.16,8.39 185.94,8.6 v3(185.94,8.96) ; v3(219.75,11.83) 220.19,11.39 220.61,11.39 220.9,11.68 v4(223.25,11.68)
  BOTTOM w0.069: v4(223.25,11.68) JIO1.28 223.25,10.51 222.64,9.91 v4(222.64,6.15)

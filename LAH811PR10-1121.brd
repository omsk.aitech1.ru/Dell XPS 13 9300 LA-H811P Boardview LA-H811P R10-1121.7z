# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B+_FLAG_R: length 24.8
  TOP w0.069: R6222.1 119.72,4.01 PD602.2 118.53,4.01 PD601.2 117.34,4.01 PD600.2 117.34,5 116.17,6.16 v1(114.95,6.16) 106.52,6.16 105.14,4.79 105.14,2.96 105.45,2.66 PQ600.1 105.96,2.14 106.41,1.69 107.66,1.69 107.91,1.95 107.91,2.25 PR600.2 108.04,2.34 PU600.3
BAT1_LED#: length 46.8
  TOP w0.069: v3(190.32,22.8) 189.66,22.14 187.44,22.14 186.61,21.31 185.41,21.31 185.13,21.03 185.13,20.86 184.95,20.68 184.42,20.68 UE1.D10
  IN2 w0.051: v3(190.32,22.8) 190.32,22.13 190.72,21.73 191.73,21.73 191.75,21.72 194.03,21.72 202.79,12.96 206.61,12.96 207.89,14.24 210.11,14.24 211.33,13.02 219.14,13.02 220.31,11.85 v4(220.31,11.78)
  BOTTOM w0.069: JIO1.18 220.25,11.59 220.31,11.65 ; QZ20.3 220.86,13.29 220.31,12.74 220.31,11.65 ; 220.31,11.65 v4(220.31,11.78)
BAT1_LED#_Q: length 3
  BOTTOM w0.069: QZ20.2 222,14.59 QE25.1 222.37,16.1 v1(222.04,16.1)
BAT2_LED#: length 6.8
  TOP w0.069: UE1.D11 185.21,19.71 187.42,19.71 187.86,20.15 187.87,20.15 188.03,20.32 188.03,20.32 188.2,20.49 189.75,20.49 189.88,20.62 RE101.2 RE492.1
BAT2_W_LED#: length 35.2
  IN2 w0.051: v3(190.92,21.27) 191.44,20.74 194.55,20.74 202.64,12.65 206.99,12.65 v3(207.29,12.96) 207.53,12.72 217.23,12.72 218.12,11.83 v4(218.12,11.62)
  BOTTOM w0.069: v4(218.12,11.62) 218.15,11.59 218.15,9.36 217.55,8.76 JIO1.9
BATBTN#: length 161.1
  TOP w0.069: PD602.1 119.73,3.09 120.25,3.62 120.25,5.13 119.34,6.04 117.06,6.04 116.63,6.47 v1(110.73,6.47) 108.04,6.47 107.66,6.85 v3(107.61,6.85) ; RE137.1 180.47,24.22 v3(180.07,23.82) 179.61,23.35 179.61,22.11 UE1.B5
  IN2 w0.051: v3(193.16,12.2) 193.16,12.2 192.53,12.2 191.58,13.15 186.2,13.15 184.5,11.45 177.4,11.45 175.83,9.87 170.16,9.87 168.94,8.66 167.78,8.66 167.39,8.27 112.16,8.27 111.55,7.66 108.36,7.66 107.61,6.92 v3(107.61,6.85)
  IN3 w0.061: v4(219.98,12.97) 219.9,12.97 219.75,12.82 213.65,12.82 212.67,11.84 195.42,11.84 194.46,12.79 193.52,12.79 193.16,12.44 v3(193.16,12.2) 192.92,12.2 188.69,16.44 188.69,17.52 188.28,17.92 188.28,20.21 185.83,22.66 181.15,22.66 180.07,23.74 v3(180.07,23.82)
  BOTTOM w0.069: JIO1.17 219.95,12.94 v4(219.98,12.97)
BATT_LED#_LV1: length 38.6
  TOP w0.069: v2(190.35,19.37) 189.89,19.83 188.24,19.83 187.31,18.9 185.94,18.9 185.63,18.59 UE1.F12
  IN1 w0.061: v2(190.35,19.37) 190.72,19.37 v3(190.77,19.42)
  IN2 w0.051: v3(190.77,19.42) v3(193.03,19.42) 195.44,19.42 202.53,12.34 216.22,12.34 217.43,11.13 219.21,11.13 v3(219.47,11.39)
  IN3 w0.061: v3(219.47,11.39) 219.65,11.21 v4(219.65,11.11)
BATT_LED#_LV2: length 42.4
  TOP w0.069: UE1.G10 184.25,17.47 187.54,17.47 187.87,17.8 v1(188.38,17.8) 188.54,17.64 190.03,17.64 v2(190.35,17.32)
  IN1 w0.061: v2(190.35,17.32) 190.35,18.9 190.03,19.22 190.03,19.5 190.18,19.65 190.49,19.65 v3(190.87,20.03)
  IN2 w0.051: v3(218.94,11.46) 218.76,11.29 217.49,11.29 216.29,12.49 202.59,12.49 195.33,19.75 191.15,19.75 v3(190.87,20.03)
  IN3 w0.061: v4(219.05,11.11) 219.05,11.35 v3(218.94,11.46)
BATT_LED#_LV3: length 47.9
  TOP w0.069: UE1.C6 181.07,21.33 181.5,21.33 181.64,21.47 184.92,21.47 185.15,21.71 185.15,21.94 185.36,22.14 185.85,22.14 185.99,22.28 186.79,22.28 187.08,22.57 187.08,23.07 188.57,24.55 v1(189.07,24.55) 190.08,24.55 v2(190.31,24.33)
  IN1 w0.061: v3(191.5,21.4) 191.5,22.22 190.49,23.23 190.49,24.15 v2(190.31,24.33)
  IN2 w0.051: v3(218.58,11.83) 218.4,11.83 217.36,12.87 211.26,12.87 210.04,14.09 207.96,14.09 206.67,12.81 202.73,12.81 194.18,21.35 191.56,21.35 v3(191.5,21.4)
  IN3 w0.061: v3(218.58,11.83) 218.58,11.4 218.45,11.26 v4(218.45,11.11)
BATT_LED#_LV4: length 61.6
  TOP w0.069: v1(196.46,3.98) 196.1,4.34 v3(195.72,4.34) ; v2(174.46,14.93) 174.61,15.08 177.69,15.08 177.86,15.26 177.86,15.66 177.53,16 UE1.J2
  IN1 w0.061: v2(174.46,14.93) 174.61,14.93 174.64,14.9 174.64,13.99 v3(174.53,13.89)
  IN3 w0.061: v3(174.53,13.89) 174.53,13.82 174.92,13.43 175.57,13.43 177.21,11.79 180.89,11.79 182.84,9.85 183.54,9.85 186.29,7.1 187.64,7.1 188.82,5.92 188.82,4.75 189.27,4.31 190.88,4.31 191.38,4.81 192.03,4.81 192.31,4.53 193.57,4.53 193.96,4.14 195.53,4.14 v3(195.72,4.34) 196.25,4.34 197.01,5.09 197.36,5.09 198.06,5.8 207.16,5.8 207.52,6.15 216.78,6.15 217,5.93 217.5,5.93 v4(217.77,6.2)
  BOTTOM w0.069: v4(217.77,6.2) 217.77,6.33 217.26,6.85 217.26,9.18 217.84,9.77 217.84,11.11 JIO1.10
BATT_LED#_LV5: length 46.8
  TOP w0.069: UE1.M13 188.14,11.98 v2(188.64,11.98) ; v3(187.75,7.51) 187.77,7.54 v2(187.77,8.88)
  IN1 w0.061: v2(188.64,11.98) 188.44,11.77 188.44,10.55 188,10.11 188,9.5 187.77,9.28 v2(187.77,8.88)
  IN3 w0.061: v3(187.75,7.51) 187.75,7.31 188.99,6.07 188.99,5 189.26,4.73 190.17,4.73 190.56,5.11 191.96,5.11 192.38,4.69 193.61,4.69 193.83,4.9 196.58,4.9 196.87,5.19 196.87,5.66 197.12,5.91 197.87,5.91 197.92,5.96 207.1,5.96 207.45,6.32 217.08,6.32 v4(217.21,6.19)
  BOTTOM w0.069: v4(217.21,6.19) 216.65,6.75 216.65,9.42 217.25,10.01 JIO1.8 217.25,11.49 v5(217.56,11.8)
BC_CLK_ECE1117: length 47.6
  IN1 w0.061: v2(186.33,20.19) v3(186.33,20.54)
  IN3 w0.061: v4(224.27,10.16) 224.27,10.46 223.76,10.97 221.84,10.97 v3(221.53,10.66) 221.53,10.66 216.75,10.66 216.54,10.86 195.97,10.86 195.51,10.4 193.72,10.4 193.27,10.85 192.63,10.85 192.38,11.11 192.38,11.6 187.87,16.1 187.87,17.07 187.2,17.74 187.2,19.67 v3(186.33,20.54)
  BOTTOM w0.069: v4(224.27,10.16) 223.55,9.44 JIO1.29
BC_DAT_ECE1117: length 47.3
  TOP w0.069: UE1.D12 185.84,19.88 187.19,19.88 187.97,20.67 189.52,20.67 189.7,20.85 189.7,21.28 RE130.2 190.34,22.01 v3(190.69,22.37)
  IN2 w0.051: v4(224.32,12.51) 223.99,12.18 223.32,12.18 223.15,12.01 221.39,12.01 220.11,13.29 211.28,13.29 210.17,14.39 207.17,14.39 206.44,13.67 v3(205.65,13.67) 205.27,13.29 202.68,13.29 194.09,21.87 191.81,21.87 191.8,21.89 191.17,21.89 v3(190.69,22.37)
  BOTTOM w0.069: JIO1.30 223.85,11.46 224.25,11.85 224.25,12.41 224.32,12.49 v4(224.32,12.51)
BC_INT#_ECE1117: length 56.7
  IN1 w0.061: v2(192.06,9.26) 192.33,9.53 v3(192.33,9.8) ; v2(177.53,19.39) 177.53,19.61 v3(177.33,19.8)
  IN3 w0.061: v4(223.63,10.15) 223.3,9.82 216.67,9.82 216.27,10.21 196.98,10.21 196.52,9.75 194.35,9.75 193.45,9.75 193.07,10.13 192.65,10.13 v3(192.33,9.8) 192.27,9.86 192.05,9.86 191,10.91 191,11.18 189.16,13.03 188.26,13.03 186.72,14.57 186.72,15.44 186.19,15.96 186.19,18.3 185.1,19.4 182.61,19.4 182.51,19.3 177.99,19.3 177.48,19.8 v3(177.33,19.8)
  BOTTOM w0.069: JIO1.27 222.95,9.47 v4(223.63,10.15)
BEEP: length 133.7
  IN1 w0.061: v3(185.13,14.75) 185.18,14.79 185.18,15.74 184.73,16.19 v2(184.73,16.99)
  IN2 w0.051: v3(253.49,28.45) 253.44,28.4 253.44,27.77 251.63,25.95 251.63,24.81 249.62,22.8 249.62,20.32 v3(249.63,20.3)
  IN3 w0.061: v3(249.63,20.3) 249.67,20.26 249.67,19.51 247.89,17.72 246.63,17.72 245.89,16.98 245.89,14.29 246.34,13.84 246.34,11.9 245.81,11.37 245.81,10.94 245.07,10.2 243.42,10.2 242.53,11.09 241.03,11.09 239.22,9.28 228.61,9.28 227.61,8.29 225.54,8.29 225.07,7.82 220.65,7.82 220.33,8.15 216.1,8.15 215.77,8.48 214.91,8.48 214.2,7.77 206.13,7.77 205.4,8.5 202.08,8.5 201.73,8.14 200.47,8.14 199.98,8.63 198.08,8.63 197.02,7.57 195.01,7.57 194.68,7.9 192.04,7.9 192.02,7.92 191.33,7.92 187.81,11.44 186.31,11.44 185.13,12.62 v3(185.13,14.75) ; v4(261.33,59.89) 258.03,59.89 256.18,58.03 256.18,53.44 257.38,52.24 257.38,47.82 255.81,46.25 255.81,35.24 257.51,33.54 257.51,31.11 255.82,29.43 254.31,29.43 253.48,28.59 253.48,28.47 v3(253.49,28.45)
  BOTTOM w0.069: v4(261.33,59.89) 261.28,59.94 v1(260.41,59.94)
BGPO0: length 6.6
  TOP w0.069: UE1.D6 180.41,20.51 180.41,22.91 181.35,23.85 181.35,25.76 TP58.1
BIA_PWM: length 105.7
  TOP w0.069: LV1.1 135.74,64.48 v3(136.23,64.97)
  IN2 w0.051: v3(136.23,64.97) 136.41,65.14 140.4,65.14 140.68,65.42 143.15,65.42 143.66,65.93 145.28,65.93 145.66,65.55 148.36,65.55 149.04,64.86 154.19,64.86 154.97,65.65 157.32,65.65 157.7,65.27 159.37,65.27 159.54,65.43 162.53,65.43 163.16,64.8 166.92,64.8 174.74,56.98 174.74,52.57 175.68,51.63 175.68,49.07 175.5,48.89 175.5,48.07 174.82,47.39 174.82,46.08 175.12,45.78 175.12,44.16 178.62,40.66 179.87,40.66 180.2,40.66 182.85,38 183.5,37.35 183.5,36.16 184.44,35.22 185.42,35.22 186.95,33.69 188.26,33.69 188.81,33.14 191.49,33.14 191.85,32.78 194.23,32.78 195.19,31.82 195.19,31.07 199.66,26.6 199.66,23.59 v4(203.6,19.65)
  BOTTOM w0.069: v1(204.26,22.83) 203.93,22.83 203.29,22.19 C750.1 ; D3.1 202.53,22.93 C750.1 ; C750.1 204.26,21.2 204.26,20.72 R32.1 203.6,20.06 v4(203.6,19.65)
BIA_PWM_EC: length 43.7
  TOP w0.069: v2(175.68,13.23) 175.92,12.99 UE1.N1
  IN1 w0.061: v3(176.87,24.71) 176.87,24.25 176.38,23.75 176.38,23.32 176.46,23.24 176.46,16.32 175.93,15.78 175.93,13.48 v2(175.68,13.23)
  IN3 w0.061: v4(193.08,29.2) 192.84,29.2 191.37,27.73 190.69,27.73 189.98,27.02 189.43,27.02 189.04,26.63 188.83,26.63 188.13,25.93 187.78,25.93 186.84,24.98 186.25,24.98 185.98,24.7 182.72,24.7 182.62,24.61 178.3,24.61 178.19,24.71 v3(176.87,24.71)
  BOTTOM w0.069: D3.2 200.79,25.28 200.79,27.4 198.96,29.23 197.99,29.23 196.68,30.54 194.45,30.54 193.12,29.2 v4(193.08,29.2)
BIA_PWM_R: length 2.5
  TOP w0.069: v3(135.07,63.72) 134.89,63.89 LV1.2 135.04,64.43 TP120.1
  IN3 w0.061: v4(134.7,64.34) 134.7,64.28 135.07,63.91 v3(135.07,63.72)
BL_PWR_MONITOR: length 1.7
  BOTTOM w0.203: QV19.2 111.51,69.85 111.22,69.56 110.45,69.56 110.33,69.44 R627.1
BOARD_ID: length 3.6
  TOP w0.069: RE194.2 189.26,15.4 C4240.1 189.04,16.19 UE1.J13
BST_0.6V:
  vias: v1(201.79,43.76)
BT_RADIO_DIS#: length 107.6
  TOP w0.069: v2(172.76,21.12) 173.08,21.43 175.7,21.43 175.73,21.4 177.11,21.4 UE1.C2 ; RH751.1 163.01,31.31 163.41,30.9 168.62,30.9 168.97,30.55 168.97,29.18 169.67,28.49 169.67,26.77 169.9,26.54 170.7,26.54 170.99,26.25 170.99,25.78 170.92,25.71 v2(170.92,25.68)
  IN1 w0.061: v3(172.81,18.08) 172.96,18.23 172.96,20.92 v2(172.76,21.12) 172.76,21.72 172.63,21.85 171.8,21.85 171.56,22.09 171.56,25.04 v2(170.92,25.68)
  IN3 w0.061: v3(172.81,18.08) 172.81,16.88 176.57,13.12 181.06,13.12 183.03,11.15 184.23,11.15 186.27,9.1 187.14,9.1 187.67,8.57 187.85,8.57 189.16,7.26 189.16,7.09 189.93,6.32 190.89,6.32 190.98,6.24 193.18,6.24 193.66,5.75 195.84,5.75 195.95,5.86 196.6,5.86 196.98,6.24 197.74,6.24 197.79,6.29 206.97,6.29 207.32,6.64 218.8,6.64 219.03,6.41 223.52,6.41 223.72,6.22 225.3,6.22 226.19,7.1 229.15,7.1 229.7,6.55 230.45,5.8 239.67,5.8 242.83,8.96 v4(243.09,8.96)
  BOTTOM w0.069: DZ3.1 v4(243.09,8.96)
BT_RADIO_DIS#_R: length 21.6
  IN1 w0.061: v3(247.21,9.52) 247.46,9.52 248.1,10.15 258,10.15 258.28,10.43 258.66,10.43 258.81,10.28 261.79,10.28 v4(261.91,10.41)
  IN3 w0.061: v4(246.89,9.02) 246.97,9.02 247.26,9.31 247.26,9.47 v3(247.21,9.52)
  BOTTOM w0.069: v4(261.91,10.41) 262.1,10.59 262.1,12.55 262.56,13.01 UWL1.63 ; DZ3.2 246.7,8.96 246.72,8.93 246.8,8.93 v4(246.89,9.02) 246.89,9.33 247.54,9.97 247.54,10.47 RW55.2
CAM_DET#: length 76.9
  TOP w0.069: UE1.L6 180.73,14.73 180.38,15.08 180.38,16.2 179.95,16.63 178.95,16.63 178.82,16.76 178.82,18.1 178.65,18.27 178.65,18.88 178.63,18.9 178.15,18.9 177.85,19.19 177.85,20.36 177.63,20.58 v2(177.63,20.6) ; v2(162.09,47.19) 162.88,47.97 163.28,47.97 v1(163.78,48.47) 163.78,51.09 164.53,51.84 164.53,56.02 164.1,56.45 164.1,56.45 163.41,57.13 163.41,59.91 162.44,60.88 161.53,60.88 161.33,61.08 v5(161.33,61.49)
  IN1 w0.061: v2(177.63,20.6) 177.63,20.65 v3(177.26,21.02) ; v3(163.17,31.22) 163.17,31.95 163.59,32.37 164.33,32.37 164.71,31.99 164.71,29.02 164.82,28.91 167.28,28.91 169.2,26.99 v3(169.36,26.99) ; v2(162.09,47.19) 162.09,45.61 160.24,43.76 160.24,40.48 160.03,40.28 160.03,39.11 158.61,37.68 158.61,36.03 v3(158.26,35.68)
  IN2 w0.051: v3(169.36,26.99) 169.23,26.87 169.23,26.3 171.06,24.47 171.06,22.16 171.87,21.35 171.87,21.02 172.17,20.73 176.96,20.73 v3(177.26,21.02)
  IN3 w0.061: v3(163.17,31.22) 162.92,31.48 162.74,31.48 162.08,32.14 160.47,32.14 158.94,33.67 158.94,34.31 v4(159.25,34.61) 159.25,34.69 v3(158.26,35.68)
  BOTTOM w0.069: RH747.2 158.29,61.04 R6208.1 158.33,61.07 158.64,60.75 160.87,60.75 161.33,61.21 v5(161.33,61.49) ; v4(159.25,34.61) 159.1,34.75 UC1.CT49
CAM_DET#_R: length 3.7
  BOTTOM w0.069: 158.33,61.67 158.33,62.12 158.38,62.17 158.38,63.87 158.2,64.06 JUFC1.41 ; 158.33,61.67 R6208.2 ; 158.33,61.67 158.27,61.61 TP145.1
CBN: length 2.6
  TOP w0.203: UA1.24 263.94,63.64 264.25,63.95 264.25,64.83 264.83,65.41 264.87,65.41 CA21.2
CBP: length 2.2
  TOP w0.203: CA21.1 264.84,63.91 264.17,63.24 UA1.23
CD_WAKE#: length 3.4
  BOTTOM w0.069: RR11.2 10.93,37.38 10.89,37.42 10.88,37.42 10.68,37.62 10.68,37.77 10.69,37.79 RR12.2 10.63,38.11 10.35,38.4 10.35,39.58 UCR1.32
CFG_RCOM: length 1
  TOP w0.069: v1(133.85,57.24) 133.51,56.91 v4(133.51,56.34)
CHG_ACIN: length 9.3
  TOP w0.127: PR204.1 37.82,5.53 37.66,5.53 v1(37,6.19)
  TOP w0.508: PR204.1 38.17,4.92 38.78,4.31 PR201.2 39.36,4.03 PC211.1
  IN3 w0.508: v4(34.19,5.91) 34.96,5.91 36.06,4.82 37.45,4.82 37.83,5.2 v3(38.19,5.2)
CHG_ADP: length 36.1
  TOP w0.508: v2(33.19,16.2) 33.01,16.38 v1(33.01,19.55) 33.01,19.96 34.63,21.58 34.63,21.58 35.88,22.83 35.88,23.94 35.69,24.13 35.69,26.7 31.33,31.06 PR206.2
  IN1 w0.508: v3(37.35,6.04) 37.35,6.37 38.52,7.54 38.52,8.76 38.25,9.02 37.31,9.02 35.88,10.46 35.88,11.5 33.62,13.76 33.62,15.77 v2(33.19,16.2)
  IN3 w0.508: v3(37.35,6.04) 37.35,5.91 36.95,5.51 v4(36.58,5.51)
  BOTTOM w0.203: PC226.1 37.61,5.22 37.32,5.51 v4(36.58,5.51) 36.43,5.51 36.03,5.91 36.03,6.23 35.8,6.46 PU200.16
CHG_AMON: length 2.5
  TOP w0.069: v1(32.89,8.48) 32.68,8.27 32.33,8.27 32.26,8.2 v2(31.87,8.2)
  IN1 w0.061: v3(31.18,7.87) 31.51,8.2 v2(31.87,8.2)
  IN3 w0.061: v3(31.18,7.87) 31.37,8.06 v4(31.64,8.06)
CHG_BGATE: length 40.1
  IN3 w0.203: v4(31.76,10.71) 31.92,10.87 31.92,13.07 32.07,13.23 32.07,15.94 32.34,16.22 33.87,16.22 34.39,15.69 37.74,15.69 43.02,10.41 55.88,10.41 57.17,11.7 v4(62.29,11.7)
  BOTTOM w0.203: v4(31.76,10.71) 31.64,10.6 PU200.32
CHG_CLK: length 2.8
  TOP w0.069: PR214.2 33.13,5.84 v2(33.11,5.86) 32.88,6.09 v1(32.78,6.09)
  IN1 w0.061: v2(33.11,5.86) 32.83,5.58 v3(32.83,5.55)
  IN3 w0.061: v4(32.91,5.12) 32.91,5.48 v3(32.83,5.55)
  BOTTOM w0.069: PU200.22 32.99,5.21 v4(32.91,5.12)
CHG_CMIN: length 3.5
  TOP w0.069: v1(35.45,5.24) v2(34.59,5.24)
  IN1 w0.061: v2(34.59,5.24) 34.91,4.92 v3(35.09,4.92)
  IN3 w0.061: v3(35.09,4.92) 34.79,5.22 v4(34.23,5.22)
  BOTTOM w0.069: PU200.20 33.79,5.45 34.02,5.22 v4(34.23,5.22)
CHG_CSIN: length 9.9
  IN3 w0.254: v4(39.08,5.33) 39.08,5.84 38.05,6.88 36.92,6.88 v4(36.77,7.03)
  BOTTOM w0.254: v4(39.08,5.33) 39.08,4.69 37.91,3.52 36.44,3.52 36.21,3.29 PR203.2 PC213.1 ; PU200.14 36.13,7.26 36.36,7.03 v4(36.77,7.03)
CHG_CSIP: length 9.9
  IN3 w0.254: v4(38.72,5.17) 38.72,5.68 37.88,6.52 37.05,6.52 36.77,6.24 v4(36.77,6.11)
  BOTTOM w0.254: PC212.1 PR202.2 35.42,3.04 36.26,3.88 37.73,3.88 38.72,4.87 v4(38.72,5.17) ; PU200.15 35.94,6.86 36.69,6.11 v4(36.77,6.11)
CHG_CSON: length 9.4
  IN3 w0.203: v4(32.19,10.48) 33.01,11.3 33.01,15.5 32.76,15.75 v4(32.76,15.81)
  BOTTOM w0.203: PR222.2 33.36,18.03 33.36,17.2 PC240.1 32.76,16.6 v4(32.76,15.81)
  BOTTOM w0.254: v4(32.19,10.48) PU200.1
CHG_CSOP: length 9.4
  IN3 w0.203: v4(32.61,10.38) 33.39,11.16 33.39,15.46 33.68,15.75 v4(33.68,15.81)
  BOTTOM w0.203: v4(33.68,15.81) 33.68,16.43 PC238.2 34.51,17.26 PR221.2
  BOTTOM w0.254: PU200.2 32.59,10.32 32.61,10.34 v4(32.61,10.38)
CHG_DAT: length 2.8
  TOP w0.069: v1(34.3,6.07) 34.3,5.57 v2(33.91,5.18)
  IN1 w0.061: v3(33.98,4.86) 33.91,4.93 v2(33.91,5.18)
  IN3 w0.061: v3(33.98,4.86) 33.83,4.86 v4(33.53,5.16)
  BOTTOM w0.069: v4(33.53,5.16) 33.39,5.3 PU200.21
CHG_DCIN: length 4.5
  TOP w0.127: v1(35.98,4.06) 35.73,3.8 v5(35.32,3.8)
  TOP w0.457: PR208.2 35.32,3 v5(35.32,3.8)
  BOTTOM w0.254: PC227.2 34.99,4.76 PU200.17
  BOTTOM w0.381: v5(35.32,3.8) 35.32,4.44 PC227.2
CHG_LG1: length 50.5
  IN3 w1.016: 84.16,14.17 82.01,12.01 79.56,12.01 77.48,9.92 63.36,9.92 63,9.57 58.59,9.57 58.31,9.29 42.55,9.29 39.76,12.08 38.52,12.08 37.3,10.86
  vias: v4(84.8,14.8) v4(85.18,14.8) v5(37.05,10.1) v5(37.66,10.15)
CHG_LG2: length 57.8
  TOP w1.016: 92.67,14.29 90.16,11.78 38.11,11.78 37.53,11.19 36.51,11.19 36.29,10.97
  vias: v5(35.24,10.69) v5(35.27,11.24) v5(93.56,15.44) v5(93.59,14.88)
CHG_LX1: length 38.2
  TOP w1.016: 42.33,9.24 80.53,9.24
  vias: v5(39.92,8.96) v5(40.53,8.93) v5(81.47,9.72) v5(82.11,9.72)
CHG_LX2: length 56.6
  IN2 w1.016: 36.14,11.41 37.72,11.41 38.44,12.13 39.69,12.13 41.76,10.05 47.47,10.05 47.8,10.38 69.86,10.38 70.14,10.66 76.16,10.66 77.89,12.39 87.21,12.39 89.63,14.8
  vias: v5(34.53,10.79) v5(34.68,11.35) v5(89.81,18.36) v5(89.81,17.3) v5(89.81,16.24) v5(90.54,18.36) v5(90.54,17.3) v5(90.54,16.24) v5(91.27,18.36) v5(91.27,17.3) v5(91.27,16.24)
CHG_PROCHOT#: length 80.2
  TOP w0.069: v2(32.35,5.18) 32.35,6.16 32.56,6.38 35.38,6.38 v1(35.55,6.55) 35.72,6.38 36.07,6.38 36.96,5.49 v2(37.21,5.49) ; v5(102.2,10.13) PR102.2 PR105.2
  IN1 w0.061: v3(31.74,4.67) 32.25,5.18 v2(32.35,5.18) ; v2(37.21,5.49) 37.92,5.49 38.29,5.86 39.4,5.86 39.59,6.06 v3(39.59,6.72)
  IN2 w0.051: v5(102.2,10.13) 102.2,8.29 101.8,7.89 94.48,7.89 93.82,8.55 81.31,8.55 80.6,9.26 70.71,9.26 70.43,8.98 48.38,8.98 48.05,8.66 41.71,8.66 41.56,8.51 41.21,8.51 39.59,6.89 v3(39.59,6.72)
  IN3 w0.061: v3(31.74,4.67) 31.79,4.62 32.25,4.62 v4(32.53,4.89)
  BOTTOM w0.069: PU200.23 32.59,4.96 v4(32.53,4.89)
CHG_PSYS: length 4.9
  TOP w0.127: v1(32.35,11.14) 32.22,11.27 v2(31.66,11.27)
  TOP w0.203: PR229.1 31.52,11.27 v2(31.66,11.27)
  IN1 w0.203: v2(31.66,11.27) 31.66,10.76 31,10.1 31,9.26 31.18,9.09 v3(31.26,9.09)
  IN3 w0.254: v4(31.64,8.46) 31.26,8.85 v3(31.26,9.09)
CHG_UG1: length 59.7
  TOP w1.016: 38.67,7.71 62.47,7.71 63.01,7.18 75.93,7.18 76.47,7.71 84.77,7.71 v3(86.3,9.24) v3(87.19,9.24)
  IN3 w1.016: 80.99,15.82 81.75,16.58 84.57,16.58 86.41,14.74 86.41,11.07
  vias: v4(79.96,15.45) v4(79.96,15.07) v5(36.44,8.3) v5(37.02,8.3)
CHG_UG2: length 58
  IN2 w1.016: 86.58,14.67 85.94,14.04 77.31,14.04 75.45,12.18 69.14,12.18 68.86,11.9 42.53,11.9 38.52,15.92 34.61,15.92 33.49,14.8 33.49,13.15
  vias: v3(87.47,15.44) v3(87.47,14.93) v4(87.47,15.44) v4(87.47,14.93) v5(33.9,10.76) v5(34.1,11.3)
CHG_VBAT1: length 4.5
  BOTTOM w0.069: v1(31.41,10.86) 30.63,10.86 30.43,10.66
  BOTTOM w0.203: 30.43,10.66 PC245.1 29.58,10.66 PR236.1
  BOTTOM w0.254: PC245.1 30.98,10.08 30.98,9.11 31.23,8.86 PU200.31
CHG_VDDP:
  vias: v1(36.26,9.95) v2(35.27,9.83) v2(35.68,9.01) v3(34.76,10) v4(35.68,10.1) v4(35.9,9.67)
CHG_VIN_20V: length 43
  TOP w0.254: v2(39.33,6.16) 39.08,5.91 PR201.1
  IN1 w0.254: v2(39.33,6.16) 39.33,6.2 v3(38.81,6.72)
  IN2 w0.254: v4(78.65,9.95) 78.22,9.52 70.61,9.52 70.33,9.24 48.27,9.24 47.94,8.91 41.6,8.91 41.46,8.77 41.11,8.77 39.48,7.14 39.4,7.14 38.98,6.72 v3(38.81,6.72)
CLK_BIASREF: length 4.9
  BOTTOM w0.069: RH475.1 172.73,57.09 171.92,56.28 169.71,56.28 UC1.DU6
CLK_CNV_CRX_DTX_N: length 126.8
  IN1 w0.076: v3(246.98,4.45) 246.75,4.67 246.55,4.67 246.44,4.56 246.44,4.3 245.87,3.73 234.9,3.73 233.94,4.69 232.08,4.69 231.66,5.11 215.38,5.11 214.15,6.34 210.89,6.34 210.72,6.51 204.78,6.51 200.15,11.13 200,11.13 199.8,10.94 199.48,10.94 199.25,11.17 199.25,11.49 199.45,11.68 199.45,11.84 199.33,11.95 199.18,11.95 198.98,11.76 198.66,11.76 198.43,11.99 198.43,12.31 198.63,12.5 198.63,12.66 194.2,17.08 194.2,21.45 193.77,21.88 193.77,23.46 192.8,24.43 192.8,26.03 192.27,26.56 191.86,26.56 190.43,27.99 189.02,27.99 186.4,30.61 185.2,30.61 184.62,31.19 178.7,31.19 174.08,35.81 173.5,35.81 171.66,37.64 170.57,37.64 169.71,38.5 169.2,38.5 168.42,39.29 167.07,39.29 166.74,38.96 166.74,38.4 166.59,38.24 166.11,38.24 165.85,37.99 165.85,37.81 165.93,37.74 v4(166.08,37.74)
  IN3 w0.076: v4(260.6,18.86) 260.6,18.97 260.52,19.05 259.62,19.05 259.37,18.79 257.65,18.79 255.67,16.81 255.67,14.1 248.89,7.32 248.89,6.66 247.84,5.6 247.84,5.27 247.31,4.75 247.14,4.75 246.98,4.59 v3(246.98,4.45)
  BOTTOM w0.081: v4(260.6,18.86) 260.75,19.01 UWL1.A33 ; UC1.DK44 v4(166.08,37.74)
CLK_CNV_CRX_DTX_P: length 126.9
  IN1 w0.076: v4(165.43,37.74) 165.66,37.96 165.66,38.08 166.02,38.44 166.5,38.44 166.54,38.48 166.54,39.04 166.99,39.48 168.5,39.48 169.28,38.7 169.79,38.7 170.65,37.84 171.74,37.84 173.58,36 174.16,36 178.78,31.39 184.7,31.39 185.28,30.81 186.48,30.81 189.1,28.19 190.51,28.19 191.95,26.75 192.35,26.75 193,26.11 193,24.51 193.97,23.54 193.97,21.96 194.4,21.53 194.4,17.17 198.82,12.74 198.82,12.42 198.63,12.23 198.63,12.07 198.74,11.96 198.9,11.96 199.09,12.15 199.42,12.15 199.64,11.92 199.64,11.6 199.45,11.41 199.45,11.25 199.56,11.14 199.72,11.14 199.91,11.33 200.24,11.33 204.86,6.71 210.8,6.71 210.97,6.54 214.24,6.54 215.46,5.31 231.74,5.31 232.16,4.89 234.02,4.89 234.98,3.93 245.78,3.93 246.24,4.39 246.24,4.64 246.47,4.87 246.71,4.87 v3(246.98,5.13)
  IN3 w0.076: v3(246.98,5.13) 246.98,5.02 247.05,4.95 247.23,4.95 247.64,5.35 247.64,5.68 248.7,6.74 248.7,7.41 255.47,14.18 255.47,16.89 257.57,18.99 259.29,18.99 259.54,19.25 260.49,19.25 v4(260.6,19.36)
  BOTTOM w0.081: UC1.DJ44 v4(165.43,37.74) ; UWL1.A32 260.91,19.36 v4(260.6,19.36)
CLK_CNV_CTX_DRX_N: length 118.7
  IN1 w0.076: v3(184.99,33.67) 185.06,33.67 185.21,33.53 185.21,33.06 185.92,32.35 187.12,32.35 188.08,31.39 189.54,31.39 192.64,28.29 193.24,28.29 194.96,26.57 194.96,26.33 194.73,26.1 194.73,25.78 194.95,25.55 195.27,25.55 195.64,25.92 195.8,25.92 195.94,25.79 195.94,25.63 195.58,25.27 195.58,24.91 195.95,24.54 195.95,17.79 205.5,8.25 211.54,8.25 211.67,8.13 215.81,8.13 216.03,7.9 216.03,7.55 216.34,7.24 232.04,7.24 232.5,6.77 232.95,6.77 233.28,7.1 233.99,7.1 235.02,6.07 235.67,6.07 235.82,6.22 245.28,6.22 246.2,7.13 247.33,7.13 247.39,7.07 247.39,6.58 247.33,6.52 v3(247.25,6.52)
  IN3 w0.076: v4(253.36,17.01) 253.21,16.86 252.99,16.86 249.89,13.76 249.89,10.41 250.12,10.18 250.27,10.18 250.38,10.07 250.38,9.91 250.27,9.8 250.12,9.8 249.89,9.57 249.89,9.42 247.42,6.95 247.42,6.69 v3(247.25,6.52) ; v3(184.99,33.67) 185.13,33.53 185.13,33.37 184.97,33.21 184.83,33.21 183.41,31.79 176.75,31.79 173.85,34.69 172.94,34.69 171.29,36.34 169.76,36.34 168.97,37.13 168.11,37.13 167.43,37.81 167.2,37.81 166.51,38.51 166.51,38.6 166.56,38.65 v4(166.71,38.65)
  BOTTOM w0.081: v4(166.71,38.65) 166.65,38.88 UC1.DL42
CLK_CNV_CTX_DRX_P: length 118.8
  IN1 w0.076: v3(185.52,33.67) 185.52,33.62 185.41,33.51 185.41,33.14 186,32.55 187.2,32.55 188.16,31.59 189.63,31.59 192.72,28.49 193.32,28.49 195.16,26.65 195.16,26.25 194.92,26.02 194.92,25.86 195.03,25.75 195.19,25.75 195.56,26.12 195.88,26.12 196.13,25.87 196.13,25.55 195.77,25.19 195.77,24.99 196.15,24.62 196.15,17.88 205.58,8.45 211.63,8.45 211.75,8.32 215.89,8.32 216.23,7.99 216.23,7.63 216.42,7.43 232.12,7.43 232.58,6.97 232.87,6.97 233.2,7.3 234.07,7.3 235.1,6.27 235.59,6.27 235.74,6.41 245.19,6.41 246.11,7.33 247.41,7.33 247.59,7.16 247.59,6.71 v3(247.78,6.52)
  IN3 w0.076: v3(185.52,33.67) 185.52,33.62 185.33,33.44 185.33,33.29 185.05,33.01 184.91,33.01 183.5,31.6 176.66,31.6 173.77,34.49 172.85,34.49 171.2,36.14 169.68,36.14 168.89,36.93 168.03,36.93 167.34,37.61 167.12,37.61 166.31,38.42 166.31,38.54 v4(166.17,38.68) ; v3(247.78,6.52) 247.61,6.69 247.61,6.86 250.09,9.34 250.09,9.49 250.2,9.6 250.35,9.6 250.58,9.83 250.58,10.15 250.35,10.38 250.2,10.38 250.09,10.49 250.09,13.68 253.07,16.66 253.21,16.66 v4(253.36,16.51)
  BOTTOM w0.081: UC1.DK42 v4(166.17,38.68)
CLK_PCIE_N0: length 137.1
  TOP w0.081: RW7.1 254.59,17.05 254.59,16.77 254.74,16.62 254.74,16.49 v2(254.57,16.33)
  IN1 w0.076: v3(156.06,57.38) 156.17,57.27 156.17,57.07 156.12,57.02 155.94,57.02 155.87,57.09 155.66,57.09 155.6,57.04 155.6,56.87 155.82,56.66 157.6,56.66 157.91,56.35 161.77,56.35 162.9,55.21 162.9,53.15 164.88,51.18 166.24,51.18 166.48,51.43 172.53,51.43 173.72,50.23 173.72,49.93 174.28,49.37 174.61,49.37 174.92,49.07 177.1,49.07 177.22,48.95 179.15,48.95 179.27,48.83 181.12,48.83 182.11,47.84 182.32,47.84 182.84,47.31 182.84,45.69 183.51,45.02 184.32,45.02 184.82,44.52 184.82,43.43 186.93,41.32 189.12,41.32 193.08,37.36 193.56,37.36 195.62,35.29 196.54,35.29 198.18,33.65 198.18,31.74 197.91,31.47 197.91,28.56 198.18,28.29 198.18,18.87 205.69,11.36 211.89,11.36 213.06,10.19 216.92,10.19 217.5,9.6 221.92,9.6 222.29,9.97 226.23,9.97 226.23,9.98 236.68,9.98 237.38,9.28 239.73,9.28 241.3,10.85 243.63,10.85 245.08,12.3 250.29,12.3 253.84,15.84 254.55,15.84 254.76,16.05 254.76,16.15 254.73,16.17 254.73,16.17 v2(254.57,16.33)
  IN3 w0.076: v3(156.06,57.38) 155.75,57.7 v4(155.75,57.71)
CLK_PCIE_N0_R: length 5.2
  TOP w0.081: RW7.2 254.59,18.24 254.59,18.73 254.7,18.84 254.7,21.67 v4(254.47,21.91)
  BOTTOM w0.081: v4(254.47,21.91) 254.61,21.76 254.61,21.38 254.46,21.23 UWL1.33
CLK_PCIE_N1: length 99.9
  IN3 w0.076: v4(202.44,15.82) 202.56,15.93 202.56,16.44 202.46,16.55 202.46,19.99 204.45,21.98 204.45,26.98 205.15,27.68 205.15,35.7 204.34,36.51 204.34,38.62 201.25,41.7 200.7,41.7 193.95,48.45 192.4,48.45 182.54,58.31 181.55,58.31 180.3,59.56 176.06,59.56 171.79,63.82 162.29,63.82 161.99,63.52 160.11,63.52 157.36,60.77 157.36,59.54 157.44,59.45 157.44,59.12 157.32,59 157.11,59 157.04,58.92 157.04,58.78 v4(157.16,58.65)
  BOTTOM w0.081: RS207.1 191.75,21 191.89,21 192.01,20.87 192.01,20.11 192.75,19.37 v7(196.18,19.37) 197.22,19.37 198.92,17.67 199.65,17.67 200.51,16.81 201.93,16.81 202.56,16.18 202.56,15.93 v4(202.44,15.82) ; UC1.CL2 v4(157.16,58.65)
CLK_PCIE_N1_R: length 2.3
  BOTTOM w0.081: RS207.2 190.68,21.02 189.84,21.02 189.72,20.9 JNGFF1.53
CLK_PCIE_N4: length 217.9
  IN3 w0.076: v4(155.75,58.37) 155.56,58.37 155.21,58.71 155.21,59.47 153.96,60.72 151.27,60.72 150.51,61.48 150.51,63.57 148.89,65.19 145.86,65.19 144.89,64.22 143.5,64.22 142.9,64.82 141.56,64.82 140.16,66.22 137.52,66.22 137.04,66.7 116.6,66.7 116.11,66.89 115.62,67.09 115.59,67.12 114.13,68.58 109.84,68.58 109.34,69.09 106.89,69.09 106.17,69.81 104.62,69.81 103.77,70.66 94.2,70.66 91.3,67.75 91.3,59.46 93.64,57.11 93.64,53.33 89.36,49.05 89.36,29.55 81.86,22.04 81.2,22.04 74.25,15.1 46.27,15.1 35.88,25.49 35.88,26.68 35.01,27.56 31.94,27.56 31,28.5 22.64,28.5 20.28,30.85 20.28,31.82 19.86,32.25 19.86,34.71 18.99,35.58 13.13,35.58 6.62,42.09 6.62,42.38 6.82,42.59 7,42.59 7.15,42.74 v4(7.18,42.74)
  BOTTOM w0.081: R6090.1 7.18,42.78 v4(7.18,42.74)
CLK_PCIE_N4_R: length 2.2
  BOTTOM w0.081: R6090.2 8.35,42.72 8.59,42.72 8.75,42.56 9.21,42.56 9.38,42.39 9.62,42.39 9.72,42.49 UCR1.6
CLK_PCIE_P0: length 137.1
  TOP w0.081: v2(255.1,16.33) 254.94,16.49 254.94,16.64 255.09,16.79 255.09,17.04 RW6.1
  IN1 w0.076: v2(255.1,16.33) 254.95,16.18 254.95,15.97 254.63,15.64 253.92,15.64 250.38,12.1 245.16,12.1 243.71,10.65 241.38,10.65 239.82,9.08 237.3,9.08 236.6,9.78 226.32,9.78 226.31,9.78 222.37,9.78 222,9.41 217.42,9.41 216.84,9.99 212.97,9.99 211.8,11.16 205.61,11.16 197.98,18.78 197.98,28.21 197.71,28.48 197.71,31.55 197.98,31.82 197.98,33.57 196.46,35.1 195.54,35.1 193.48,37.16 193,37.16 189.03,41.12 186.85,41.12 184.62,43.35 184.62,44.44 184.24,44.82 183.43,44.82 182.65,45.6 182.65,47.23 182.23,47.64 182.03,47.64 181.04,48.63 179.19,48.63 179.07,48.75 177.14,48.75 177.02,48.87 174.84,48.87 174.53,49.17 174.2,49.17 173.53,49.85 173.53,50.15 172.45,51.23 166.57,51.23 166.32,50.98 164.79,50.98 162.71,53.07 162.71,55.13 161.68,56.15 157.82,56.15 157.51,56.46 155.74,56.46 155.41,56.79 v3(155.41,57.38)
  IN3 w0.076: v3(155.41,57.38) 155.72,57.06 v4(155.75,57.06)
CLK_PCIE_P0_R: length 5.2
  TOP w0.081: RW6.2 255.09,18.25 255.09,18.73 254.9,18.91 254.9,21.89 254.94,21.93 254.98,21.93 v4(255,21.91)
  BOTTOM w0.081: UWL1.34 254.96,21.23 254.81,21.38 254.81,21.72 v4(255,21.91)
CLK_PCIE_P1: length 99.8
  IN3 w0.076: v4(157.16,59.3) 157.16,60.85 160.03,63.72 161.91,63.72 162.21,64.02 171.88,64.02 176.14,59.76 180.38,59.76 181.63,58.51 182.62,58.51 192.48,48.65 194.03,48.65 200.78,41.9 201.34,41.9 204.54,38.7 204.54,36.59 205.35,35.78 205.35,27.6 204.65,26.9 204.65,21.9 202.66,19.9 202.66,16.63 202.76,16.53 202.76,15.88 v4(202.82,15.82)
  BOTTOM w0.081: v4(202.82,15.82) 202.76,15.88 202.76,16.26 202.02,17.01 200.6,17.01 199.73,17.87 199.01,17.87 197.3,19.58 192.83,19.58 v7(192.51,19.9) 192.22,20.19 192.22,20.96 191.97,21.2 191.72,21.2 RS208.1 ; UC1.CL1 v4(157.16,59.3)
CLK_PCIE_P1_R: length 2.3
  BOTTOM w0.081: RS208.2 190.76,21.23 189.89,21.23 189.72,21.4 JNGFF1.55
CLK_PCIE_P4: length 217.9
  IN3 w0.076: v4(155.75,59.02) 155.88,59.02 156,58.9 156,58.74 155.92,58.67 155.54,58.67 155.41,58.79 155.41,59.56 154.04,60.92 151.35,60.92 150.71,61.57 150.71,63.65 148.97,65.39 145.78,65.39 144.81,64.42 143.58,64.42 142.98,65.02 141.65,65.02 140.24,66.42 137.6,66.42 137.12,66.9 116.64,66.9 115.73,67.26 114.21,68.78 109.92,68.78 109.42,69.28 106.97,69.28 106.25,70.01 104.7,70.01 103.85,70.85 94.12,70.85 91.1,67.83 91.1,59.37 93.44,57.03 93.44,53.41 89.16,49.14 89.16,29.63 81.78,22.24 81.12,22.24 74.17,15.29 46.36,15.29 36.08,25.57 36.08,26.76 35.09,27.75 32.02,27.75 31.08,28.69 22.72,28.69 20.48,30.94 20.48,31.9 20.05,32.33 20.05,34.79 19.07,35.78 13.22,35.78 6.82,42.18 6.82,42.3 6.9,42.39 6.97,42.39 7.15,42.21 v4(7.18,42.21)
  BOTTOM w0.081: R6089.1 7.28,42.11 v4(7.18,42.21)
CLK_PCIE_P4_R: length 2.2
  BOTTOM w0.081: UCR1.5 9.65,42.09 9.55,42.19 9.29,42.19 9.12,42.36 8.75,42.36 8.62,42.22 8.36,42.22 R6089.2
CLK_SMB: length 2.8
  BOTTOM w0.069: PR195.1 39.15,21.65 39.15,21.65 39.27,21.53 39.64,21.53 39.77,21.66 40.32,21.66 40.45,21.53 41.26,21.53 JBATT1.4
CLK_TP_SIO_I2C_DAT: length 5.6
  TOP w0.069: UE1.E10 184.29,19.75 184.29,20.29 184.5,20.5 187.01,20.5 187.51,21 RE467.2
CLKREQ_CNV#: length 130.3
  IN2 w0.051: v3(159.72,36.46) 160.43,36.46 161.36,35.52 163.76,35.52 164.5,34.79 175.25,34.79 177.28,32.76 181.06,32.76 181.66,32.15 186.12,32.15 187.01,31.27 188.55,31.27 189.31,30.51 190.71,30.51 193.82,27.4 196.43,27.4 198.13,25.7 198.13,21.18 201.47,17.85 203.99,17.85 205.08,16.76 211.15,16.76 212.26,15.65 224.45,15.65 225.39,14.71 226.39,14.71 227.08,15.4 238.55,15.4 239.47,16.32 241.82,16.32 242.18,16.69 243.31,16.69 246.95,20.33 246.95,20.57 246.84,20.68 v3(246.84,20.68)
  IN3 w0.061: v4(249.52,23.16) 249.36,23 249.26,23 246.92,20.66 246.86,20.66 v3(246.84,20.68) ; v3(159.72,36.46) 159.59,36.59 v4(159.1,36.59)
  BOTTOM w0.069: RW17.1 RH728.1 265.01,21.38 264.66,21.73 263.69,21.73 263.23,22.19 263.23,22.4 262.9,22.73 259.69,22.73 259.16,23.25 259.16,24.73 v1(257.59,26.3) 257.38,26.51 251.09,26.51 249.65,25.06 249.65,23.29 v4(249.52,23.16)
CLKREQ_CNV#_R: length 9.3
  TOP w0.069: v3(261.93,14.77) 260.9,14.77 DR16.2
  IN3 w0.061: v4(262.81,15.01) 262.16,15.01 v3(261.93,14.77)
  BOTTOM w0.069: RW17.2 263.79,15.59 263.21,15.01 v4(262.81,15.01) 262.58,15.01 261.58,14.01 UWL1.A43
CLKREQ_PCIE#0: length 109
  TOP w0.069: v3(177.2,43.55) 177.2,43.53 177.31,43.43 177.31,43.27 RH40.2
  IN2 w0.051: v3(243.79,19.52) 241.49,19.52 240.07,18.1 238.59,18.1 237.05,16.57 228.05,16.57 226.7,17.93 212.5,17.93 211.89,18.53 207.05,18.53 201.13,24.46 201.13,27.61 198.36,30.38 198.36,31.22 197.71,31.87 v3(197.55,31.87)
  IN3 w0.061: v4(250.46,22.61) 249.61,22.61 247.03,20.03 244.47,20.03 243.97,19.52 v3(243.79,19.52) ; v3(197.55,31.87) 197.82,32.14 197.82,33.54 196.62,34.74 196.62,34.95 194.6,36.97 194.6,37.53 191.54,40.6 190.7,40.6 189.3,42 188.48,42 187.41,43.07 183.13,43.07 182.94,43.26 181.53,43.26 181.11,43.68 178.57,43.68 178.34,43.44 177.31,43.44 v3(177.2,43.55) 177.07,43.43 174.05,43.43 173.81,43.18 v4(171.26,43.18)
  BOTTOM w0.069: v4(171.26,43.18) 171.26,41.95 171.07,41.76 168.42,41.76 167.95,42.23 167.23,42.23 167.02,42.44 167.02,42.78 166.72,43.07 166.6,43.07 UC1.DK33 ; v4(250.46,22.61) 250.46,22.18 251.29,21.35 252.65,21.35 252.96,21.04 UWL1.30
CLKREQ_PCIE#1: length 39.5
  TOP w0.069: v1(176.77,29) 176.77,28.26 v3(176.65,28.14)
  IN1 w0.061: v4(167.23,42.97) 167.12,42.87 167.12,41.17 166.1,40.15 164.68,40.15 163.74,39.21 163.74,38.75 163.21,38.22 163.21,37.82 163.43,37.6 163.87,37.6 166.44,35.03 170.81,35.03 174.65,31.2 175.07,31.2 176.65,29.63 v3(176.65,28.14)
  IN3 w0.061: v4(177.13,26.03) 177.28,26.18 177.28,27.5 v3(176.65,28.14)
  BOTTOM w0.069: v4(177.13,26.03) 177.13,25.52 179.97,22.67 182.06,22.67 182.39,22.34 182.39,20.77 182.27,20.65 JNGFF1.52 ; v4(167.23,42.97) 167.38,42.82 UC1.DN34
CLKREQ_PCIE#4: length 242.5
  TOP w0.069: RH39.2 175.86,40.63 v3(175.86,41.17)
  IN1 w0.061: v4(166.76,41.34) 166.66,41.45 162.6,41.45 161.86,40.71 161.86,38.3 162.14,38.02 162.14,37.96 163.46,36.64 163.46,36.11 163.94,35.63 164.13,35.63 165.67,34.1 168.93,34.1 171.33,31.7 171.33,31.2 171.97,30.56 171.97,29.26 172.86,28.37 172.86,27.63 172.99,27.5 173.1,27.5 173.65,26.95 173.65,26.78 174.33,26.11 174.33,22.83 174.62,22.53 174.62,20.29 174.18,19.84 174.18,17.66 173.51,17 173.51,15.6 172.66,14.75 172.66,12.59 169.73,9.67 169.31,9.67 168.35,8.71 167.23,8.71 166.75,8.23 146.37,8.23 145.56,7.42 129.59,7.42 128.56,6.4 120.9,6.4 120.51,6.01 119.54,6.01 118.48,4.95 115.58,4.95 114.44,6.09 106.31,6.09 104.76,4.54 103.65,4.54 103.24,4.95 100.02,4.95 99.67,4.6 95.87,4.6 93.19,7.28 80.97,7.28 80.48,7.76 74.5,7.76 73.97,7.23 46.19,7.23 42.81,10.61 42.81,11.3 35.75,18.36 34.03,18.36 30.24,22.14 30.24,23.88 28.37,25.75 23.69,25.75 19.9,29.53 19.9,34.33 19.14,35.1 15.19,35.1 10.62,39.66 10.35,39.66 9.87,40.14 v3(9.87,40.45)
  IN3 w0.061: v3(175.86,41.17) 175.63,41.17 175.29,40.83 174.76,40.83 174.71,40.78 173.21,40.78 172.9,41.09 171.71,41.09 171.52,41.28 170.6,41.28 170.53,41.22 169.12,41.22 168.88,41.46 166.88,41.46 v4(166.76,41.34) ; v4(9.41,40.68) 9.64,40.45 v3(9.87,40.45)
  BOTTOM w0.069: v4(166.76,41.34) 166.41,40.99 166.41,40.51 166.62,40.29 167.02,40.29 UC1.DN40
  BOTTOM w0.081: v4(9.41,40.68) 9.62,40.89 UCR1.2
CNV_BRI_CRX_DTX: length 116.3
  TOP w0.069: RH724.1 256.39,11.47 RW28.2 256.66,10.55 256.66,9.36 v2(256.05,8.76)
  IN1 w0.061: v2(256.05,8.76) 255.92,8.63 255.03,8.63 254.88,8.48 248.9,8.48 248.58,8.16 244.66,8.16 244.54,8.04 242.88,8.04 242.03,7.19 235.5,7.19 233.86,8.82 228.2,8.82 227.56,8.19 223.47,8.19 223.16,8.49 216.91,8.49 216.33,9.08 212.06,9.08 210.95,10.19 204.87,10.19 196.9,18.16 196.9,26.49 195.84,27.54 195.84,29.13 193.07,31.91 193.07,32.24 191.09,34.22 191.09,35.37 190.42,36.04 190.23,36.04 189.77,36.49 189.09,36.49 188.12,37.46 187.6,37.46 187.34,37.72 184.85,37.72 183.7,38.86 182.44,38.86 181.82,39.48 181.82,39.64 180.95,40.51 180.92,40.51 180.72,40.71 179.66,40.71 178.58,41.79 177.69,41.79 177,42.49 173.78,42.49 173.47,42.8 172.11,42.8 170.52,44.38 167.49,44.38 v4(166.91,44.96)
  BOTTOM w0.069: UC1.DL29 v4(166.91,44.96)
CNV_BRI_CRX_R_DTX: length 12.4
  TOP w0.069: v2(254.72,11.68) v1(255.28,11.68) 255.58,11.68 255.8,11.46 RW28.1
  IN1 w0.061: v4(261.06,16.01) 260.58,15.52 258.11,15.52 254.72,12.13 v2(254.72,11.68)
  BOTTOM w0.069: v4(261.06,16.01) 261.52,16.01 262.52,17.01 UWL1.55
CNV_BRI_CTX_DRX: length 116.8
  TOP w0.069: RC504.1 256.85,10.67 256.85,9.15 v1(256.71,9.01) 256.1,8.4 v2(256.05,8.4)
  IN1 w0.061: v4(166.37,44.98) 166.41,44.98 166.79,44.59 167.01,44.59 167.41,44.19 170.45,44.19 172.03,42.61 173.39,42.61 173.7,42.3 176.92,42.3 177.62,41.6 178.5,41.6 179.6,40.51 180.66,40.51 180.84,40.32 180.87,40.32 181.58,39.61 181.58,39.45 182.36,38.67 183.62,38.67 184.77,37.53 187.26,37.53 187.52,37.27 188.05,37.27 188.83,36.49 188.83,36.41 189.49,35.75 190.44,35.75 190.9,35.3 190.9,34.14 192.88,32.16 192.88,31.83 195.66,29.05 195.66,27.46 196.71,26.41 196.71,18.08 204.79,10 210.87,10 211.98,8.89 216.24,8.89 216.82,8.3 223.09,8.3 223.39,8 227.64,8 228.27,8.63 233.79,8.63 235.42,7 242.11,7 242.96,7.85 244.61,7.85 244.73,7.97 248.66,7.97 248.97,8.29 254.96,8.29 255.07,8.4 v2(256.05,8.4)
  BOTTOM w0.069: UC1.DL31 166.37,44.86 v4(166.37,44.98)
CNV_BRI_CTX_R_DRX: length 12.5
  TOP w0.069: v1(257.75,9.92) 257.58,10.09 RC504.2 RW33.1 v2(257.58,12.08)
  IN1 w0.061: v3(258.03,12.39) 257.72,12.08 v2(257.58,12.08)
  IN3 w0.061: v3(258.03,12.39) 258.15,12.52 258.15,16.32 258.26,16.43 261.5,16.43 v4(261.58,16.51)
  BOTTOM w0.069: UWL1.A38 v4(261.58,16.51) 261.59,16.51 262.59,17.51 UWL1.54
CNV_CRX_DTX_N0: length 126.7
  IN1 w0.076: v3(248.8,5.14) 248.93,5 248.93,4.9 248.85,4.81 248.24,4.81 246.77,3.35 234.75,3.35 233.79,4.31 231.93,4.31 231.5,4.73 215.22,4.73 214,5.96 210.71,5.96 210.54,6.13 204.62,6.13 203.01,7.74 202.02,7.74 201.82,7.94 201.82,8.93 201.41,9.34 200.5,9.34 200.34,9.5 200.34,9.69 200.51,9.86 200.51,10.21 200.26,10.47 199.91,10.47 199.73,10.29 199.54,10.29 197.79,12.05 197.79,12.23 197.94,12.38 197.94,12.74 197.69,12.99 197.33,12.99 197.19,12.84 197,12.84 196.86,12.97 196.86,13.16 197.01,13.31 197.01,13.66 196.76,13.91 196.41,13.91 196.26,13.77 196.07,13.77 194.24,15.59 194.24,16.43 193.71,16.96 193.71,21.28 193.36,21.63 193.36,23.33 192.37,24.32 192.37,25.88 192.07,26.17 191.64,26.17 190.21,27.6 188.87,27.6 186.24,30.23 185.04,30.23 184.52,30.75 178.58,30.75 173.93,35.4 173.35,35.4 171.49,37.25 170.27,37.25 169.43,38.09 168.95,38.09 168.82,38.22 168.19,38.22 168.06,38.09 167.89,38.09 167.73,38.25 167.73,38.5 167.83,38.61 167.92,38.61 v3(168.03,38.5)
  IN3 w0.076: v3(168.03,38.5) 167.93,38.4 167.93,38.2 v4(168.03,38.1) ; v3(248.8,5.14) 248.89,5.04 248.89,4.98 248.75,4.84 248.53,4.84 248.42,4.95 248.42,5.35 249.47,6.4 249.47,7.08 256.25,13.86 256.25,16.37 257.98,18.1 260.42,18.1 v4(260.59,17.93)
  BOTTOM w0.081: UWL1.A35 261.02,18.05 260.71,18.05 v4(260.59,17.93)
CNV_CRX_DTX_N1: length 127.2
  IN1 w0.076: v3(249.8,4.5) 249.62,4.67 249.52,4.67 249.41,4.56 249.41,4.23 247.36,2.17 234.82,2.17 233.46,3.53 231.6,3.53 231.18,3.95 214.9,3.95 213.67,5.18 210.22,5.18 210.05,5.35 202.96,5.35 200.4,7.92 200.4,8.09 199.53,8.96 199.53,9.16 193.21,15.49 193.21,16.27 192.27,17.21 192.27,22.59 191.43,23.43 191.43,25.14 189.74,26.83 188.39,26.83 186.66,28.56 186.33,28.56 185.44,29.45 184.72,29.45 184.2,29.97 178.21,29.97 173.57,34.61 173.04,34.61 171.23,36.42 169.58,36.42 169.03,36.97 165.37,36.97 164.64,37.7 164.64,38.41 v4(164.48,38.57)
  IN3 w0.076: v3(249.8,4.5) 249.91,4.61 250.14,4.61 250.41,4.87 250.41,5.25 250.05,5.61 250.05,6.84 256.83,13.62 256.83,16.09 257.9,17.16 260.91,17.16 v4(261.06,17.01)
  BOTTOM w0.081: UC1.DG42 v4(164.48,38.57)
CNV_CRX_DTX_P0: length 126.8
  IN1 w0.076: v3(167.38,38.5) 167.53,38.35 167.53,38.17 167.8,37.89 168.14,37.89 168.27,38.02 168.74,38.02 168.87,37.89 169.35,37.89 170.19,37.06 171.41,37.06 173.27,35.2 173.85,35.2 178.49,30.55 184.44,30.55 184.96,30.03 186.16,30.03 188.78,27.41 190.12,27.41 191.55,25.98 191.99,25.98 192.17,25.79 192.17,24.24 193.16,23.25 193.16,21.55 193.52,21.2 193.52,16.88 194.04,16.35 194.04,15.51 195.99,13.57 196.34,13.57 196.49,13.72 196.68,13.72 196.81,13.58 196.81,13.39 196.66,13.24 196.66,12.89 196.91,12.64 197.27,12.64 197.42,12.79 197.6,12.79 197.74,12.65 197.74,12.46 197.59,12.32 197.59,11.96 199.46,10.09 199.82,10.09 199.99,10.27 200.18,10.27 200.31,10.13 200.31,9.94 200.14,9.77 200.14,9.42 200.41,9.14 201.33,9.14 201.62,8.85 201.62,7.86 201.94,7.54 202.93,7.54 204.54,5.93 210.46,5.93 210.63,5.76 213.91,5.76 215.14,4.53 231.42,4.53 231.84,4.11 233.7,4.11 234.66,3.15 246.86,3.15 248.33,4.62 248.63,4.62 v3(248.8,4.45)
  IN3 w0.076: v4(260.59,18.43) 260.46,18.3 257.9,18.3 256.05,16.46 256.05,13.94 249.27,7.17 249.27,6.48 248.22,5.43 248.22,4.87 248.45,4.64 248.61,4.64 v3(248.8,4.45) ; v4(167.38,38.1) 167.46,38.1 167.55,38.19 167.55,38.33 v3(167.38,38.5)
  BOTTOM w0.081: v4(260.59,18.43) 260.64,18.38 260.94,18.38 UWL1.A34
CNV_CRX_DTX_P1: length 127.1
  IN1 w0.076: v4(165.04,38.57) 164.91,38.57 164.86,38.52 164.86,37.76 165.46,37.17 169.11,37.17 169.67,36.61 171.31,36.61 173.12,34.81 173.65,34.81 178.29,30.17 184.28,30.17 184.8,29.65 185.52,29.65 186.41,28.76 186.74,28.76 188.47,27.03 189.82,27.03 191.63,25.22 191.63,23.52 192.46,22.68 192.46,17.29 193.4,16.36 193.4,15.57 199.73,9.24 199.73,9.04 200.59,8.17 200.59,8 203.04,5.55 210.13,5.55 210.3,5.38 213.75,5.38 214.98,4.15 231.26,4.15 231.68,3.73 233.55,3.73 234.9,2.37 247.28,2.37 249.21,4.31 249.21,4.64 249.44,4.87 249.64,4.87 v3(249.8,5.03)
  IN3 w0.076: v4(261.06,17.51) 261.06,17.4 261.01,17.36 257.81,17.36 256.63,16.17 256.63,13.7 249.85,6.93 249.85,5.52 250.21,5.17 250.21,4.95 250.06,4.8 249.95,4.8 249.8,4.96 v3(249.8,5.03)
  BOTTOM w0.081: v4(165.04,38.57) UC1.DG44
CNV_CTX_DRX_N0: length 119.7
  IN1 w0.076: v3(246.36,5.96) 246.5,6.1 246.5,6.26 246.44,6.32 246.22,6.32 245.54,5.64 241.3,5.64 241.17,5.5 241.17,5.2 240.92,4.95 240.57,4.95 240.32,5.2 240.32,5.5 240.18,5.64 239.99,5.64 239.86,5.5 239.86,5.2 239.61,4.95 239.26,4.95 239.01,5.2 239.01,5.5 238.87,5.64 238.68,5.64 238.55,5.5 238.55,5.2 238.3,4.95 237.95,4.95 237.7,5.2 237.7,5.5 237.56,5.64 237.37,5.64 237.24,5.5 237.24,5.2 236.99,4.95 236.64,4.95 236.39,5.2 236.39,5.5 236.25,5.64 236.06,5.64 235.93,5.5 235.93,5.2 235.68,4.95 235.32,4.95 233.77,6.5 233.5,6.5 233.12,6.12 232.32,6.12 232.14,6.3 231.8,6.3 231.45,6.65 231.26,6.65 230.88,6.27 230.52,6.27 230.14,6.65 229.95,6.65 229.57,6.27 229.21,6.27 228.83,6.65 228.64,6.65 228.25,6.27 227.9,6.27 227.51,6.66 225.48,6.66 225.09,6.27 223.5,6.27 223.15,6.62 222.73,6.62 222.4,6.29 221.99,6.29 221.66,6.62 221.42,6.62 221.09,6.29 220.68,6.29 220.35,6.62 220.11,6.62 219.78,6.29 219.37,6.29 219.04,6.62 218.8,6.62 218.47,6.29 218.06,6.29 217.73,6.62 215.55,6.62 214.67,7.5 211.46,7.5 211.29,7.67 205.26,7.67 195.37,17.55 195.37,22.29 194.94,22.72 194.94,23.93 194.35,24.52 194.35,25 194.15,25.2 194.15,26.41 192.84,27.71 192.38,27.71 189.37,30.73 187.92,30.73 186.88,31.77 185.68,31.77 185.02,32.43 184.29,32.43 184.1,32.62 184.1,33.48 v3(183.91,33.67)
  IN3 w0.076: v3(183.91,33.67) 184.09,33.49 184.09,33.4 183.07,32.37 177.01,32.37 174.11,35.27 173.19,35.27 171.54,36.92 170.04,36.92 169.89,37.08 169.89,37.35 169.97,37.43 170.1,37.43 170.18,37.34 v4(170.18,37.21) ; v3(246.36,5.96) 246.53,6.13 246.53,6.88 249.31,9.66 249.31,14 253.15,17.84 253.25,17.84 253.36,17.96 v4(253.36,18.01)
CNV_CTX_DRX_N1: length 119.2
  IN1 w0.076: v3(245.85,4.55) 245.68,4.72 245.3,4.72 244.97,5.05 244.71,5.05 244.58,4.92 244.58,4.56 244.33,4.31 243.97,4.31 243.72,4.56 243.72,4.92 243.59,5.05 243.4,5.05 243.26,4.92 243.26,4.56 243.02,4.31 242.66,4.31 242.41,4.56 242.41,4.92 242.28,5.05 242.09,5.05 241.95,4.92 241.95,4.56 241.7,4.31 235.14,4.31 234.18,5.27 232.32,5.27 231.9,5.69 215.66,5.69 214.43,6.92 211.17,6.92 211,7.09 205.02,7.09 194.79,17.32 194.79,21.76 194.35,22.19 194.35,23.69 193.77,24.28 193.77,24.76 193.51,25.02 193.51,26.18 192.56,27.13 192.12,27.13 189.21,30.05 187.78,30.05 186.64,31.19 185.44,31.19 184.8,31.83 183.87,31.83 183.62,32.08 183.43,32.08 183.15,31.79 182.79,31.79 182.61,31.97 182.61,32.33 183,32.71 183,33.5 v3(182.83,33.67)
  IN3 w0.076: v4(252.69,18.41) 252.67,18.41 252.61,18.35 252.24,17.98 252.24,17.75 248.71,14.22 248.71,9.88 245,6.17 245,5.02 245.28,4.74 245.65,4.74 v3(245.85,4.55) ; v4(169.51,38.12) 169.63,38 170.38,38 170.83,37.56 171.74,37.56 173.42,35.88 174.34,35.88 177.26,32.96 180.48,32.96 181.16,33.64 182.19,33.64 182.7,33.13 182.76,33.13 183.02,33.39 183.02,33.48 v3(182.83,33.67)
  BOTTOM w0.081: v4(252.69,18.41) 252.69,18.43 253.27,19.01 UWL1.A24
CNV_CTX_DRX_P0: length 119.6
  IN1 w0.076: v3(246.89,5.96) 246.7,6.15 246.7,6.34 246.52,6.52 246.14,6.52 245.45,5.83 241.22,5.83 240.97,5.58 240.97,5.28 240.84,5.14 240.65,5.14 240.52,5.28 240.52,5.58 240.27,5.83 239.91,5.83 239.66,5.58 239.66,5.28 239.53,5.14 239.34,5.14 239.2,5.28 239.2,5.58 238.96,5.83 238.6,5.83 238.35,5.58 238.35,5.28 238.22,5.14 238.03,5.14 237.89,5.28 237.89,5.58 237.64,5.83 237.29,5.83 237.04,5.58 237.04,5.28 236.91,5.14 236.72,5.14 236.58,5.28 236.58,5.58 236.33,5.83 235.98,5.83 235.73,5.58 235.73,5.28 235.6,5.14 235.41,5.14 233.85,6.7 233.41,6.7 233.03,6.32 232.4,6.32 232.22,6.49 231.89,6.49 231.53,6.85 231.17,6.85 230.79,6.47 230.6,6.47 230.22,6.85 229.86,6.85 229.48,6.47 229.29,6.47 228.91,6.85 228.55,6.85 228.17,6.47 227.98,6.47 227.59,6.86 225.39,6.86 225.01,6.47 223.58,6.47 223.23,6.82 222.65,6.82 222.32,6.49 222.07,6.49 221.74,6.82 221.34,6.82 221.01,6.49 220.76,6.49 220.43,6.82 220.03,6.82 219.7,6.49 219.45,6.49 219.12,6.82 218.72,6.82 218.39,6.49 218.14,6.49 217.81,6.82 215.63,6.82 214.75,7.69 211.54,7.69 211.37,7.87 205.34,7.87 195.57,17.64 195.57,22.37 195.14,22.8 195.14,24.01 194.55,24.6 194.55,25.08 194.34,25.28 194.34,26.49 192.92,27.91 192.46,27.91 189.45,30.93 188,30.93 186.96,31.97 185.76,31.97 185.1,32.63 184.37,32.63 184.3,32.7 184.3,33.53 v3(184.44,33.67)
  IN3 w0.076: v4(169.58,37.47) 169.69,37.36 169.69,37 169.96,36.73 171.46,36.73 173.11,35.07 174.02,35.07 176.92,32.17 183.15,32.17 184.29,33.32 184.29,33.52 v3(184.44,33.67) ; v4(253.36,17.51) 253.27,17.6 253.19,17.6 249.51,13.92 249.51,9.58 246.72,6.79 246.72,6.13 v3(246.89,5.96)
CNV_CTX_DRX_P1: length 119.3
  IN1 w0.076: v3(245.85,5.23) 245.53,4.91 245.38,4.91 245.05,5.25 244.63,5.25 244.38,5 244.38,4.64 244.24,4.51 244.05,4.51 243.92,4.64 243.92,5 243.67,5.25 243.32,5.25 243.07,5 243.07,4.64 242.93,4.51 242.74,4.51 242.61,4.64 242.61,5 242.36,5.25 242.01,5.25 241.76,5 241.76,4.64 241.62,4.51 235.22,4.51 234.26,5.47 232.4,5.47 231.98,5.89 215.74,5.89 214.51,7.11 211.26,7.11 211.08,7.29 205.1,7.29 194.98,17.4 194.98,21.84 194.55,22.27 194.55,23.78 193.97,24.36 193.97,24.84 193.71,25.1 193.71,26.26 192.64,27.33 192.21,27.33 189.3,30.24 187.86,30.24 186.72,31.39 185.52,31.39 184.88,32.03 183.95,32.03 183.71,32.28 183.35,32.28 183.06,31.99 182.88,31.99 182.81,32.05 182.81,32.25 183.19,32.63 183.19,33.5 v3(183.36,33.67)
  IN3 w0.076: v4(168.86,38.12) 169.13,37.86 169.5,37.86 169.55,37.81 170.3,37.81 170.75,37.36 171.66,37.36 173.34,35.68 174.25,35.68 177.17,32.76 180.56,32.76 181.24,33.44 182.11,33.44 182.61,32.94 182.84,32.94 183.22,33.31 183.22,33.53 v3(183.36,33.67) ; v4(252.69,18.03) 252.57,18.03 252.44,17.9 252.44,17.67 248.91,14.14 248.91,9.8 245.2,6.09 245.2,5.1 245.36,4.94 245.55,4.94 v3(245.85,5.23)
  BOTTOM w0.081: UWL1.A23 253.17,18.51 v4(252.69,18.03)
CNV_DET#_EC: length 4
  TOP w0.069: RE471.2 188.26,13.25 186.55,14.95 185.89,14.95 UE1.L12
CNV_RF_RESET#: length 134.7
  TOP w0.069: DR17.2 258.61,13.71 RH114.1 v2(259.53,13.99)
  IN1 w0.061: v4(262.81,15.51) 262.16,15.51 261.53,14.88 261.53,14.42 261.1,13.99 v2(259.53,13.99) 258.85,14.66 258.11,14.66 255.89,12.45 255.89,12.26 254.6,10.97 247.82,10.97 247.26,11.52 245.45,11.52 243.97,10.05 241.94,10.05 241.57,9.68 241.57,8.71 241.28,8.42 236.98,8.42 v3(236.45,8.95)
  IN2 w0.051: v4(232.37,13.84) 231.43,13.84 230.77,14.5 225.39,14.5 224.39,15.5 212.19,15.5 211.09,16.6 205.63,16.6 205.09,16.06 203.03,16.06 197.98,21.11 197.98,25.63 196.37,27.25 193.76,27.25 190.64,30.36 189.24,30.36 188.49,31.12 186.94,31.12 186.06,32 181.6,32 180.99,32.61 177.22,32.61 175.19,34.64 164.43,34.64 163.7,35.37 161.28,35.37 160.77,35.88 159.77,35.88 v3(159.7,35.95)
  IN3 w0.061: v4(230.71,8.97) 230.73,8.95 v3(236.45,8.95) ; v4(159.1,35.93) 159.12,35.95 v3(159.7,35.95)
  BOTTOM w0.069: v4(262.81,15.51) 263.25,15.51 263.44,15.69 263.44,19.27 263.52,19.35 QW1.2 ; v4(232.37,13.84) 232.37,11.47 230.71,9.81 v4(230.71,8.97)
CNV_RF_RESET#_R: length 1.8
  TOP w0.069: v2(259.96,14.44) 259.83,14.57 RW13.2
  IN1 w0.061: v4(261.06,14.51) 260.8,14.24 260.16,14.24 v2(259.96,14.44)
CNV_RF_RST: length 87
  IN1 w0.061: v3(188.81,14.28) 188.81,13.66 v2(189.22,13.25)
  IN2 w0.051: v3(188.81,14.28) 188.95,14.42 192.43,14.42 193.03,13.83 193.03,13.61 193.21,13.42 195.56,13.42 196.12,12.87 198.83,12.87 201.6,10.1 205.91,10.1 207,9.01 210.01,9.01 210.53,9.53 216.08,9.53 216.56,9.05 222.31,9.05 222.53,9.26 223.78,9.26 224.6,10.08 233.52,10.08 233.82,10.38 241.02,10.38 244.52,13.89 246.57,13.89 v3(247.99,15.31)
  IN3 w0.061: v3(247.99,15.31) 248.52,15.84 249.4,15.84 250.51,16.95 250.51,17.71 251.89,19.09 252.67,19.09 253.43,19.86 256.53,19.86 256.76,19.63 259.07,19.63 260.24,20.79 264.25,20.79 v4(264.55,21.1)
  BOTTOM w0.069: v4(264.55,21.1) 264.55,20.48 RW19.1 264.58,20.43 QW1.1
CNV_RGI_CRX_DTX: length 113.4
  TOP w0.069: v2(254.1,9.18) 254.08,9.2 v1(254.08,9.89) 254.08,10.63 RW31.2 254.24,10.83 RH725.1
  IN1 w0.061: v2(254.1,9.18) 253.99,9.07 253.99,8.82 253.83,8.66 248.82,8.66 248.5,8.35 244.55,8.35 244.43,8.23 242.8,8.23 241.95,7.38 235.58,7.38 233.94,9.01 228.12,9.01 227.48,8.37 225.24,8.37 224.65,8.96 222.77,8.96 222.49,8.68 217.07,8.68 216.48,9.26 212.34,9.26 211.23,10.38 204.95,10.38 197.08,18.24 197.08,26.57 196.03,27.62 196.03,29.27 193.3,32 193.3,32.27 191.37,34.2 191.37,35.36 190.5,36.23 190.3,36.23 189.85,36.68 189.17,36.68 188.2,37.65 187.67,37.65 187.41,37.9 184.92,37.9 183.11,39.72 182.01,39.72 181.03,40.7 181,40.7 180.76,40.94 179.7,40.94 178.66,41.98 177.77,41.98 177.08,42.67 173.85,42.67 173.54,42.98 172.19,42.98 170.6,44.57 167.91,44.57 167.5,44.98 v4(167.43,44.98)
  BOTTOM w0.069: UC1.DN29 v4(167.43,44.98)
CNV_RGI_CRX_R_DTX: length 10.6
  TOP w0.069: v2(255.44,11.3) 254.96,10.81 RW31.1
  IN1 w0.061: v2(255.44,11.3) 256.5,11.3 v3(256.83,11.63)
  IN2 w0.051: v3(256.83,11.63) 258.15,11.63 258.41,11.88 258.41,12.51 260.49,14.6 v3(260.49,14.72)
  IN3 w0.061: v3(260.49,14.72) 260.64,14.72 260.93,15.01 v4(261.06,15.01)
  BOTTOM w0.069: v4(261.06,15.01) 261.38,15.01 262.38,16.01 UWL1.57
CNV_RGI_CTX_DRX: length 111.9
  TOP w0.069: v2(253.71,9.19) 253.79,9.27 253.79,10.67 RC503.1
  IN1 w0.061: v2(253.71,9.19) 253.79,9.11 253.79,8.88 253.75,8.85 248.74,8.85 248.43,8.54 244.47,8.54 244.35,8.42 242.72,8.42 241.87,7.57 235.65,7.57 234.01,9.21 228.05,9.21 227.4,8.56 225.32,8.56 224.73,9.15 222.69,9.15 222.41,8.87 217.14,8.87 216.56,9.45 212.42,9.45 211.31,10.57 205.03,10.57 197.27,18.32 197.27,26.64 196.22,27.7 196.22,29.35 193.49,32.08 193.49,32.35 191.55,34.28 191.55,35.44 190.58,36.42 190.38,36.42 189.93,36.87 189.24,36.87 188.28,37.83 187.75,37.83 187.49,38.09 185,38.09 183.19,39.9 182.09,39.9 181.11,40.89 181.08,40.89 180.83,41.14 179.77,41.14 178.74,42.17 177.85,42.17 177.15,42.86 173.93,42.86 173.62,43.17 172.27,43.17 170.68,44.76 168.07,44.76 168.03,44.8 v4(168.03,44.98)
  BOTTOM w0.069: UC1.DP31 v4(168.03,44.98)
CNV_RGI_CTX_R_DRX: length 14.7
  TOP w0.069: RW29.1 RW30.1 257.46,14.77 257.37,14.85 v2(257.37,15.15)
  IN1 w0.061: v3(261.56,15.84) 261.56,16.1 261.31,16.34 260.92,16.34 260.29,15.71 258.04,15.71 257.48,15.15 v2(257.37,15.15) 256.82,15.15 253.63,11.96 v2(253.63,11.41)
  IN3 w0.061: v4(261.06,15.51) 261.32,15.51 261.56,15.74 v3(261.56,15.84)
  BOTTOM w0.069: UWL1.56 262.35,16.51 261.35,15.51 v4(261.06,15.51)

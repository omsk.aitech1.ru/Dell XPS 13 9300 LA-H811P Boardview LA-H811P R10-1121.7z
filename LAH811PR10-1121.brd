# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_C_D3_6: length 20.4
  IN1 w0.094: v3(133.06,38.75) 133.06,38.65 131.81,37.4 131.81,36.39 131.27,35.84 131.27,35.03 130.74,34.5 130.74,31.86 125.19,26.3 125.19,25.57 125.3,25.46 125.52,25.46 125.63,25.35 125.63,25.2 125.52,25.09 125.3,25.09 125.19,24.98 125.19,23.82 125.52,23.49 125.92,23.49 v2(126.03,23.37)
  IN3 w0.094: v4(133.51,38.96) 133.3,38.75 v3(133.06,38.75)
DDR_C_D3_7: length 20
  IN1 w0.094: v3(133.97,38.75) 133.97,38.63 134.48,38.12 134.48,37.48 132.86,35.86 132.86,30.28 127.95,25.38 127.95,25.17 128.06,25.06 128.48,25.06 128.59,24.95 128.59,24.8 128.48,24.69 128.06,24.69 127.95,24.58 127.95,23.7 v2(127.63,23.37)
  IN3 w0.094: v4(134.43,38.96) 134.22,38.75 v3(133.97,38.75)
DDR_C_DQS0: length 35.8
  IN1 w0.097: v3(127.3,13.29) 127.14,13.44 127.01,13.44 126.86,13.3 126.86,13 v2(126.83,12.97)
  IN3 w0.097: v4(135.96,36.26) 136.05,36.17 136.05,34.96 135.72,34.63 135.72,29.14 136.14,28.71 136.14,14.6 134.23,12.69 133.41,12.69 133.08,12.36 132.12,12.36 131.76,12.01 128.5,12.01 128.15,11.66 127.1,11.66 126.92,11.84 126.92,13.51 127.02,13.6 127.19,13.6 127.3,13.49 v3(127.3,13.29)
DDR_C_DQS1: length 30.8
  IN1 w0.097: v3(136.72,39.52) 136.35,39.15 136.35,36.87 135.63,36.14 135.63,21.45 136.34,20.74 136.34,14.59 134.77,13.02 133.21,13.02 133.15,13.08 132.54,13.08 v2(132.43,12.97)
  IN3 w0.097: v4(137.17,39.61) v3(136.72,39.52)
DDR_C_DQS2: length 15.7
  IN1 w0.097: v3(132.07,22.84) 132.32,22.84 v2(132.43,22.72)
  IN3 w0.097: v4(133.45,36.91) 133.45,36.63 133.79,36.29 133.79,34.76 133.42,34.38 133.21,34.38 132.89,34.06 132.89,25.75 132.22,25.08 132.22,24.83 131.81,24.43 131.81,22.95 131.93,22.84 v3(132.07,22.84)
DDR_C_DQS3: length 21.2
  IN1 w0.097: v3(133.06,39.52) 133.41,39.17 133.41,37.44 131.89,35.93 131.89,31.48 126.56,26.14 126.56,25.14 126.31,24.89 126.31,23.55 126.65,23.2 126.65,23.07 126.56,22.98 126.4,22.98 126.34,22.92 126.34,22.78 126.41,22.71 126.81,22.71 v2(126.83,22.72)
  IN3 w0.097: v4(133.51,39.61) v3(133.06,39.52)
DDR_C_DQS#0: length 35.9
  IN1 w0.097: v2(126.83,13.62) 126.83,13.6 v3(126.53,13.3)
  IN3 w0.097: v4(135.96,36.91) 136.25,36.34 136.25,34.87 135.92,34.54 135.92,29.22 136.34,28.8 136.34,14.52 134.31,12.49 133.5,12.49 133.16,12.16 132.2,12.16 131.85,11.81 128.59,11.81 128.24,11.46 127.02,11.46 126.72,11.75 126.72,13.11 v3(126.53,13.3)
DDR_C_DQS#1: length 30.6
  IN1 w0.097: v2(132.43,13.62) 132.43,13.42 132.57,13.29 133.24,13.29 133.3,13.23 134.69,13.23 136.13,14.67 136.13,20.66 135.42,21.37 135.42,36.23 136.15,36.95 136.15,39.17 v3(135.81,39.52)
  IN3 w0.097: v4(136.26,39.61) v3(135.81,39.52)
DDR_C_DQS#2: length 15.6
  IN1 w0.097: v2(132.43,22.07) 132.38,22.2 v3(132.07,22.32)
  IN3 w0.097: v3(132.07,22.32) 132.07,22.32 132.07,22.32 132,22.32 131.61,22.71 131.61,24.51 132.01,24.91 132.01,25.17 132.68,25.84 132.68,34.14 133.13,34.59 133.34,34.59 133.59,34.84 133.59,36.12 v4(133.45,36.26)
DDR_C_DQS#3: length 21.3
  IN1 w0.097: v2(126.83,22.07) 127.09,22.61 127.09,23.06 126.51,23.64 126.51,24.8 126.76,25.05 126.76,26.06 132.09,31.39 132.09,35.84 133.61,37.36 133.61,39.15 v3(133.98,39.52)
  IN3 w0.097: v4(134.43,39.61) v3(133.98,39.52)
DDR_C_ODTA: length 3.9
  TOP w0.069: UD3.G2 125.79,20.77 125.46,21.1 124.93,21.1 124.63,20.79 123.24,20.79 RD33.1 RD34.1
DDR_C_ODTB: length 3.7
  TOP w0.069: UD3.T2 125.77,14.92 125.46,15.23 123.32,15.23 RD35.1 RD36.1
DDR_CHA_EN: length 6.4
  TOP w0.069: RH738.1 153.63,32.79 153.05,32.79 RH740.1 152.23,33.62 152.23,35.75 v1(152.58,36.1) v2(153.13,36.64)
  IN1 w0.061: v3(152.92,36.97) 152.92,36.85 v2(153.13,36.64)
  IN3 w0.061: v4(152.84,36.59) 152.92,36.67 v3(152.92,36.97)
DDR_CHB_EN: length 7.7
  TOP w0.069: RH739.1 153.62,33.44 153.06,33.44 RH741.1 v1(152.74,34.66) 152.74,35.59 v2(154.98,37.84)
  IN1 w0.061: v2(154.98,37.84) 154.98,37.76 v3(154.75,37.53)
  IN3 w0.061: v4(154.1,37.24) 154.45,37.24 v3(154.75,37.53)
DDR_COMP_0: length 3.8
  BOTTOM w0.127: 124.67,34.84 124.67,35.89 124.52,36.04 124.15,36.04 UC1.D47
  BOTTOM w0.305: 124.67,34.84 124.67,33.88 RC12.1
DDR_COMP_1: length 4.9
  BOTTOM w0.127: 125.44,34.99 125.44,36.12 125.3,36.26 125.07,36.26 124.87,36.45 124.87,36.58 124.68,36.77 124.21,36.77 UC1.E46
  BOTTOM w0.305: 125.44,34.99 125.44,34.49 125.94,33.99 RC13.1
DDR_COMP_2: length 8.4
  BOTTOM w0.089: 123.49,35.46 123.49,34.98 ; 123.01,36.37 123.01,35.64
  BOTTOM w0.102: 123.01,35.64 122.87,35.5 122.87,35.1 123.53,34.43 123.69,34.59 123.69,34.79 123.49,34.98 ; 123.01,36.37 123.31,36.67 UC1.C47 123.36,36.64 123.53,36.47 123.53,36.24 123.79,35.98 123.79,35.76 123.49,35.46
  BOTTOM w0.127: RC14.1 v1(123.53,31.41)
  BOTTOM w0.305: 123.53,34.43 RC14.1
DDR_D_CA0: length 40.3
  IN1 w0.094: v3(131.34,39.37) 131.06,39.37 130.04,38.35 130.04,37.93 129.02,36.91 129.02,35.78 125.11,31.87 125.11,29.3 122.34,26.52 122.34,20.71 120.11,18.49 118.86,18.49 118.47,18.1 118.47,17.74 117.81,17.07 114.85,17.07 114.57,17.35 113.6,17.35 113.33,17.62 112.57,17.62 112.32,17.87 v3(112.23,17.87)
  IN3 w0.094: v3(131.34,39.37) 131.35,39.43 v4(131.68,39.61) ; v3(112.44,15.57) 112.43,15.58 112.43,15.94 112.26,16.11 112.26,16.87 111.95,17.19 111.95,17.59 v3(112.23,17.87) 112.44,18.08 112.44,18.24 112.36,18.32 112.31,18.32 112.18,18.45 112.18,18.61 112.44,18.87 v3(112.44,20.12)
DDR_D_CA1: length 39.6
  IN1 w0.094: v2(112.44,19.47) 112.47,19.47 v3(112.81,19.14) ; v3(131.36,38.78) 131.28,38.78 130.85,38.35 130.85,37.74 130.45,37.34 129.71,37.34 129.27,36.91 129.27,35.67 125.36,31.76 125.36,30.64 125.52,30.48 125.52,30.27 125.36,30.1 125.36,29.19 122.59,26.42 122.59,20.61 120.23,18.25 118.89,18.25 118.66,18.03 118.66,17.67 117.84,16.85 114.8,16.85 114.49,17.17 113.53,17.17 113.41,17.28 112.88,17.28 v3(112.79,17.2) ; v2(112.44,16.22) 112.5,16.28 112.65,16.28 112.7,16.23 112.78,16.23 112.9,16.11 112.9,15.95 v3(112.9,15.95)
  IN3 w0.094: v3(112.9,15.95) 112.9,15.95 112.9,15.94 112.69,15.94 112.45,16.19 112.45,16.97 112.67,17.2 v3(112.79,17.2) 112.65,18.03 112.62,18.17 112.62,18.29 112.62,18.3 112.62,18.57 112.62,18.57 112.62,18.6 v3(112.81,19.14) ; v3(131.36,38.78) 131.37,38.8 v4(131.68,38.96)
DDR_D_CA2: length 38.7
  IN1 w0.094: v3(130.31,39.3) 130.31,38.95 129.83,38.47 129.83,37.99 128.79,36.95 128.79,35.9 124.86,31.98 124.86,29.4 124.66,29.19 124.5,29.19 123.88,29.82 123.72,29.82 123.61,29.71 123.61,29.55 124.24,28.92 124.24,28.77 124.13,28.66 123.97,28.66 123.34,29.28 123.19,29.28 123.08,29.17 123.08,29.02 123.7,28.39 123.7,28.24 123.59,28.13 123.44,28.13 122.81,28.75 122.66,28.75 122.55,28.64 122.55,28.49 123.17,27.86 123.17,27.71 122.09,26.62 122.09,20.81 120.02,18.75 118.82,18.75 118.12,18.05 v3(118.12,17.87)
  IN3 w0.094: v3(118.04,20.12) 118.37,19.79 118.37,18.98 118.26,18.87 118.26,18.58 118.37,18.46 118.37,18.12 v3(118.12,17.87) 118.43,17.57 118.43,15.96 v3(118.04,15.57) ; v3(130.31,39.3) v4(130.77,39.61)
DDR_D_CA3: length 39
  IN1 w0.094: v3(119.01,17.87) 119.17,18.03 120.46,18.03 120.62,18.19 121.72,18.19 121.84,18.31 121.84,18.46 121.59,18.71 121.59,18.87 121.71,18.98 121.86,18.98 122.11,18.73 122.26,18.73 122.83,19.3 122.83,26.23 126.95,30.35 126.95,30.5 125.81,31.64 125.81,31.8 125.92,31.91 126.08,31.91 127.22,30.77 127.37,30.77 127.48,30.88 127.48,31.13 126.38,32.23 126.38,32.43 126.53,32.58 126.69,32.58 127.12,32.15 127.27,32.15 127.38,32.26 127.38,32.41 126.95,32.84 126.95,33 127.06,33.11 127.22,33.11 127.65,32.68 127.8,32.68 127.91,32.79 127.91,32.94 127.49,33.37 127.49,33.53 127.63,33.67 127.78,33.67 127.91,33.54 128.07,33.54 128.18,33.65 128.18,33.81 128.05,33.94 128.05,34.09 129.58,35.62 129.58,36.09 129.83,36.34 130.39,36.34 v3(130.63,36.58)
  IN3 w0.081: v3(130.63,36.58) v4(130.95,36.26)
  IN3 w0.094: v3(118.84,15.57) 118.89,15.62 118.89,17.75 v3(119.01,17.87) 118.78,18.1 118.78,20.07 v3(118.84,20.12)
DDR_D_CA4: length 37.2
  TOP w0.107: UD4.H11 v3(119.93,19.84)
  IN1 w0.094: v3(120.36,17.44) 121.81,17.44 123.33,18.96 123.33,26.03 129.34,32.04 129.34,34.67 130.67,36 130.67,36.14 131.08,36.54 131.08,37.54 131.73,38.19 131.73,40.87 131.51,41.09 130.75,41.09 v3(130.32,40.65)
  IN3 w0.094: v3(119.64,15.57) 119.98,15.92 119.98,16.51 120.06,16.58 120.27,16.58 120.4,16.46 120.6,16.46 120.69,16.55 120.69,16.81 120.55,16.95 120.45,16.95 120.38,17.01 120.38,17.42 v3(120.36,17.44) 120.36,19.41 v3(119.93,19.84) ; v3(130.32,40.65) v4(129.85,40.91)
DDR_D_CA5: length 34.5
  IN1 w0.094: v3(119.29,19.52) 119.33,19.47 v2(119.64,19.47) ; v3(119.7,17.67) 119.83,17.8 121.68,17.8 123.08,19.2 123.08,26.13 127.88,30.93 127.88,31.08 127.31,31.64 127.31,31.8 127.43,31.91 127.58,31.91 128.14,31.35 128.3,31.35 128.41,31.46 128.41,31.61 127.85,32.18 127.85,32.33 127.96,32.44 128.11,32.44 128.68,31.88 128.83,31.88 129.09,32.14 129.09,32.34 128.98,32.45 128.75,32.45 128.64,32.56 128.64,32.71 128.75,32.82 128.98,32.82 129.09,32.93 129.09,33.09 128.98,33.2 128.49,33.2 128.38,33.31 128.38,33.47 128.49,33.58 128.98,33.58 129.09,33.69 129.09,33.84 128.98,33.95 128.75,33.95 128.64,34.06 128.64,34.22 128.75,34.33 128.98,34.33 129.09,34.44 129.09,34.78 129.88,35.57 129.88,35.6 129.97,35.69 v3(129.97,35.93)
  IN3 w0.094: v3(119.64,16.22) 119.8,16.38 119.8,16.72 119.69,16.83 119.5,16.83 119.41,16.92 119.41,17.08 119.6,17.26 119.85,17.26 119.95,17.36 119.95,17.5 119.77,17.67 v3(119.7,17.67) 119.7,18.52 v3(119.29,19.52) ; v4(130.32,35.93) 130.1,35.93 130.1,35.93 v3(129.97,35.93)
DDR_D_CKE0: length 36
  IN1 w0.094: v3(127.65,39.98) 127.28,39.61 127.28,38.83 127.01,38.57 127.01,37.37 127.16,37.22 127.16,36.86 118.91,28.61 118.91,28.45 119.29,28.08 119.29,27.93 119.18,27.82 119.02,27.82 118.65,28.19 118.49,28.19 118.38,28.08 118.38,27.92 118.76,27.55 118.76,27.39 118.64,27.28 118.49,27.28 118.12,27.66 117.96,27.66 117.85,27.55 117.85,27.39 118.22,27.02 118.22,26.86 118.11,26.75 117.96,26.75 117.58,27.13 117.43,27.13 115.88,25.57 115.88,18.68 115.38,18.18 115.24,18.18 114.96,17.9 v3(114.42,17.9)
  IN3 w0.094: v3(114.04,16.22) 114.04,17.53 v3(114.42,17.9) 114.39,17.93 114.39,18.44 114.26,18.57 114.12,18.57 114,18.69 114,19.43 v3(114.04,19.47) ; v3(127.65,39.98) v4(128.02,39.61)
DDR_D_CKE1: length 39
  IN1 w0.094: v2(114.84,19.47) 115.01,19.47 v3(115.21,19.28) ; v3(115.79,17.7) 116.02,17.47 116.95,17.47 118.61,19.12 119.7,19.12 121.53,20.95 121.53,26.5 121.42,26.61 121.08,26.61 120.97,26.72 120.97,26.88 121.08,26.99 121.42,26.99 121.53,27.1 121.53,27.25 121.42,27.36 121.08,27.36 120.97,27.47 120.97,27.63 121.08,27.74 121.42,27.74 121.53,27.85 121.53,29.51 121.85,29.83 122,29.83 122.37,29.46 122.53,29.46 122.64,29.57 122.64,29.73 122.27,30.1 122.27,30.25 122.38,30.36 122.54,30.36 122.9,29.99 123.06,29.99 123.17,30.11 123.17,30.26 122.8,30.63 122.8,30.78 122.91,30.89 123.07,30.89 123.43,30.53 123.59,30.53 123.7,30.64 123.7,30.79 123.33,31.16 123.33,31.31 123.44,31.43 123.6,31.43 123.97,31.06 124.12,31.06 124.23,31.17 124.23,31.32 123.86,31.69 123.86,31.85 128.31,36.29 128.31,37.18 128.47,37.34 v3(128.47,38.21) ; v2(114.84,16.22) 115.06,16.22 v3(115.25,16.42)
  IN3 w0.094: v3(115.21,19.28) 115.57,18.92 115.57,17.92 v3(115.79,17.7) 115.87,17.61 115.87,16.69 115.6,16.42 v3(115.25,16.42) ; v3(128.47,38.21) v4(128.94,38.31)
DDR_D_CLK: length 33.5
  IN1 w0.097: v3(127.72,38.81) 127.34,38.21 127.34,37.62 127.67,37.29 127.67,36.66 120.17,29.16 120.17,26.66 119.83,26.32 119.58,26.32 119.33,26.56 118.91,26.56 118.62,26.27 118.62,25.85 118.86,25.6 118.86,25.35 118.56,25.04 116.7,25.04 116.27,24.62 116.27,19.17 116.59,18.86 116.59,18.11 v3(116.46,17.98)
  IN3 w0.097: v3(117.24,16.22) 117.56,16.54 117.56,16.84 117.4,17.01 117.11,17.01 116.62,17.49 116.62,17.82 v3(116.46,17.98) 116.61,18.12 116.61,18.7 116.95,19.04 117.46,19.04 117.56,19.14 117.56,19.35 117.43,19.48 117.25,19.48 v3(117.24,19.47) ; v3(127.72,38.81) v4(128.02,38.96)
DDR_D_CLK#: length 33.6
  IN1 w0.097: v3(116.98,17.98) 116.79,18.17 116.79,18.94 116.48,19.25 116.48,24.53 116.78,24.84 118.64,24.84 119.07,25.27 119.07,25.68 118.82,25.93 118.82,26.18 119,26.36 119.25,26.36 119.5,26.11 119.91,26.11 120.37,26.57 120.37,29.07 127.87,36.57 127.87,37.38 127.55,37.7 127.55,37.98 v3(127.67,38.11)
  IN3 w0.097: v4(128.02,38.31) 128.02,38.38 127.92,38.48 127.53,38.48 127.46,38.41 127.46,38.2 127.56,38.11 v3(127.67,38.11) ; v3(118.04,16.22) 117.76,16.5 117.76,16.93 117.48,17.21 117.19,17.21 116.82,17.58 116.82,17.81 v3(116.98,17.98) 116.81,18.15 116.81,18.61 117.03,18.84 117.55,18.84 117.76,19.06 117.76,19.38 117.85,19.47 v3(118.04,19.47)
DDR_D_CS#0: length 40.1
  IN1 w0.094: v2(114.04,20.12) 113.98,20.12 113.69,20.41 v3(113.67,20.41) ; v3(131.36,40.07) 131.15,40.07 130.94,40.29 130.02,40.29 129.88,40.43 129.88,40.81 129.62,41.06 128.28,41.06 127.6,40.38 127.4,40.38 127.07,40.05 127.07,38.91 126.81,38.66 126.81,37.25 126.91,37.15 126.91,36.96 115.56,25.61 115.56,25.1 115.45,24.99 115.06,24.99 114.95,24.88 114.95,24.73 115.06,24.62 115.45,24.62 115.62,24.45 115.62,19.08 v3(115.2,18.66)
  IN3 w0.094: v3(113.67,20.41) 113.67,20.26 113.8,20.13 114.78,20.13 114.87,20.04 114.87,18.99 v3(115.2,18.66) 115.2,18.44 114.85,17.58 114.85,16.38 v3(114.04,15.57) ; v3(131.36,40.07) v4(131.68,40.26)
DDR_D_CS#1: length 37.9
  IN1 w0.094: v3(113.69,17.78) 113.91,17.56 114.66,17.56 114.94,17.28 117.03,17.28 118.68,18.93 119.86,18.93 121.78,20.85 121.78,28.3 124.54,31.06 124.54,32.01 128.56,36.03 128.56,37.05 129.17,37.66 129.17,37.99 128.97,38.19 128.97,39.66 129.31,40 v3(129.4,40)
  IN3 w0.094: v3(113.24,20.12) 113.27,20.09 113.27,18.43 113.69,18.01 v3(113.69,17.78) 113.64,17.73 113.64,15.75 113.47,15.57 v3(113.24,15.57) ; v3(129.4,40) v4(129.85,40.26)
DDR_D_D0_0: length 30.1
  IN1 w0.094: v2(118.04,12.32) 117.9,12.32 v3(117.64,12.06)
  IN3 w0.094: v3(117.64,12.06) 117.84,12.26 118.96,12.26 119.01,12.31 120.31,12.31 120.38,12.24 121.12,12.24 123.17,14.29 123.17,29.19 125.38,31.39 125.38,34.79 125.88,35.29 125.88,35.46 126.36,35.93 v4(126.46,35.93)
DDR_D_D0_1: length 32.4
  IN3 w0.094: v4(126.46,37.24) 126.94,36.75 126.94,35.43 126.48,34.97 126.48,34.51 126.12,34.15 126.12,31.08 123.91,28.88 123.91,13.99 120.89,10.97 119.09,10.97 119.03,11.02 118.3,11.02 118.04,11.28 v3(118.04,11.67)
DDR_D_D0_2: length 27.4
  IN1 w0.094: v2(119.64,12.32) 119.66,12.32 v3(120,11.98)
  IN3 w0.094: v3(120,11.98) 120.03,11.96 121.19,11.96 123.42,14.19 123.42,29.08 125.62,31.29 125.62,34.78 v4(126.13,35.29)
  BOTTOM w0.089: v4(126.13,35.29) 126.13,35.28 UC1.J49
DDR_D_D0_3: length 26.4
  IN3 w0.094: v4(125.19,36.59) 124.82,36.21 124.32,36.21 123.43,35.32 123.43,32.4 121.23,30.2 121.23,20.39 120.92,20.09 120.92,15.72 120.16,14.95 119.87,14.95 119.29,14.38 118.15,14.38 v3(118.04,14.27)
DDR_D_D0_4: length 29.3
  IN1 w0.094: v2(119.64,11.67) 119.68,11.67 v3(119.95,11.4)
  IN3 w0.094: v3(119.95,11.4) 120.08,11.27 120.85,11.27 123.67,14.09 123.67,28.98 125.87,31.19 125.87,34.26 126.25,34.64 126.25,35.05 126.75,35.55 126.75,36.29 v4(126.46,36.59)
DDR_D_D0_5: length 26.9
  IN1 w0.094: v2(119.64,13.62) 119.66,13.62 v3(119.96,13.33)
  IN3 w0.094: v4(125.19,37.24) 125.44,36.98 125.44,35.88 125.16,35.6 125.16,35.39 124.17,34.39 124.17,32.09 121.97,29.89 121.97,20.08 121.66,19.78 121.66,14.64 120.9,13.89 120.71,13.89 120.26,13.43 120.06,13.43 v3(119.96,13.33)
DDR_D_D0_6: length 24.7
  IN1 w0.094: v3(120.06,14.34) 119.71,14.34 v2(119.64,14.27)
  IN3 w0.094: v4(125.13,35.93) 125.13,35.91 124.82,35.59 124.82,35.39 123.92,34.49 123.92,32.2 121.72,30 121.72,20.19 121.41,19.88 121.41,14.75 121.01,14.34 v3(120.06,14.34)
DDR_D_D0_7: length 26.1
  IN3 w0.094: v3(118.04,13.62) 118.1,13.68 119.34,13.68 119.57,13.91 119.57,14.34 119.9,14.67 120.87,14.67 121.17,14.97 121.17,19.98 121.47,20.29 121.47,30.1 123.67,32.3 123.67,35.04 124,35.37 v4(124.25,35.37)
  BOTTOM w0.107: UC1.E48 124.37,35.68 v4(124.25,35.37)
DDR_D_D1_0: length 39.6
  IN1 w0.094: v2(114.04,14.27) 113.64,14.67 113.14,14.67 112.98,14.84 112.58,14.84 112.18,15.23 111.49,15.23 111.06,15.67 111.06,20.6 111.36,20.9 111.36,24.17 112.43,25.24 112.69,25.24 112.8,25.12 112.8,25 112.92,24.88 113.08,24.88 113.2,25 113.2,25.12 113.32,25.24 113.57,25.24 113.68,25.12 113.68,25 113.8,24.88 113.97,24.88 114.08,25 114.08,25.12 114.2,25.24 114.34,25.24 123.29,34.19 123.29,34.35 123.08,34.56 123.08,34.71 123.19,34.82 123.35,34.82 123.56,34.61 123.72,34.61 123.83,34.72 123.83,34.88 123.61,35.09 123.61,35.24 123.72,35.36 123.88,35.36 124.09,35.14 124.25,35.14 125.65,36.54 126.15,36.54 126.58,36.97 126.58,38.3 126.33,38.56 126.33,40.31 v3(126.66,40.63)
  IN3 w0.094: v3(126.66,40.63) v4(126.19,40.91)
DDR_D_D1_1: length 41
  IN1 w0.094: v2(112.44,11.67) 112.35,11.58 110.48,11.58 108.58,13.47 108.58,23.55 108.89,23.86 108.89,25.97 110.6,27.68 112.41,27.68 122.59,37.86 122.59,38.28 123.61,39.29 123.61,40.45 124.01,40.85 124.61,40.85 v3(124.83,40.63)
  IN3 w0.094: v4(125.28,40.26) v3(124.83,40.63)
DDR_D_D1_2: length 43.9
  IN1 w0.094: v2(114.04,11.67) 114.04,11.5 113.82,11.27 113.14,11.27 113,11.13 112.42,11.13 112.22,11.33 110.37,11.33 108.33,13.37 108.33,23.66 108.64,23.96 108.64,26.06 110.5,27.92 112.3,27.92 122.31,37.94 122.31,38.35 123.36,39.4 123.36,40.56 123.94,41.14 124.59,41.14 v3(124.83,41.37)
  IN3 w0.094: v4(125.28,40.91) v3(124.83,41.37)
DDR_D_D1_3: length 40.3
  IN1 w0.094: v3(124.83,38.77) 124.79,38.8 123.62,38.8 122.85,38.03 122.85,37.76 112.52,27.43 110.7,27.43 109.14,25.87 109.14,23.75 108.84,23.45 108.84,13.58 110.59,11.83 112.23,11.83 112.43,12.03 113.75,12.03 v2(114.04,12.32)
  IN3 w0.094: v4(125.28,38.96) v3(124.83,38.77)
DDR_D_D1_4: length 40
  IN1 w0.094: v3(125.74,40.63) 126.11,40.27 126.11,38.51 126.38,38.24 126.38,37.13 126.05,36.8 125.52,36.8 124.91,36.19 124.18,36.19 122.53,34.53 122.53,34.38 122.75,34.15 122.75,34 122.64,33.89 122.48,33.89 122.26,34.11 122.11,34.11 121.99,34 121.99,33.84 122.22,33.62 122.22,33.47 122.11,33.36 121.95,33.36 121.73,33.58 121.57,33.58 121.46,33.47 121.46,33.31 121.69,33.09 121.69,32.93 121.58,32.82 121.42,32.82 121.2,33.05 121.04,33.05 120.93,32.94 120.93,32.78 121.15,32.56 121.15,32.4 121.04,32.29 120.89,32.29 120.66,32.51 120.51,32.51 120.4,32.4 120.4,32.25 120.62,32.03 120.62,31.87 114.23,25.48 112.33,25.48 111.11,24.27 111.11,21.01 110.81,20.7 110.81,15.34 111.67,14.47 112.24,14.47 v2(112.44,14.27)
  IN3 w0.094: v3(125.74,40.63) v4(126.19,40.26)
DDR_D_D1_5: length 39.7
  IN1 w0.094: v2(114.04,13.62) 114.04,13.65 113.6,14.09 112.71,14.09 112.59,13.96 112.15,13.96 111.95,14.17 111.63,14.17 110.55,15.24 110.55,20.81 110.86,21.11 110.86,23.64 110.86,24.36 112.23,25.73 114.12,25.73 118.03,29.63 118.03,29.79 117.81,30.01 117.81,30.16 117.92,30.27 118.07,30.27 118.29,30.06 118.45,30.06 118.56,30.17 118.56,30.32 118.34,30.54 118.34,30.69 118.45,30.8 118.61,30.8 118.82,30.59 118.98,30.59 119.09,30.7 119.09,30.85 118.87,31.07 118.87,31.23 118.98,31.34 119.14,31.34 119.36,31.12 119.51,31.12 119.62,31.23 119.62,31.39 119.4,31.6 119.4,31.76 119.51,31.87 119.67,31.87 119.89,31.65 120.04,31.65 120.15,31.76 120.15,31.92 119.94,32.13 119.94,32.29 124.57,36.92 125.16,36.92 126.07,37.84 126.07,38.27 125.74,38.6 v3(125.74,38.77)
  IN3 w0.094: v3(125.74,38.77) v4(126.19,38.96)
DDR_D_D1_6: length 37.9
  IN1 w0.094: v3(124.83,38.03) 124.43,38.43 123.6,38.43 123.09,37.93 123.09,37.53 112.75,27.18 110.8,27.18 109.39,25.77 109.39,23.65 109.09,23.34 109.09,13.68 110.7,12.07 112.19,12.07 v2(112.44,12.32)
  IN3 w0.094: v3(124.83,38.03) v4(125.28,38.31)
DDR_D_D1_7: length 38.7
  IN1 w0.094: v2(112.44,13.62) 112.36,13.71 111.91,13.71 111.71,13.91 111.53,13.91 110.3,15.14 110.3,20.91 110.61,21.22 110.61,21.9 110.61,24.46 112.12,25.97 114.02,25.97 114.25,26.21 114.25,26.36 114.06,26.55 114.06,26.7 114.17,26.81 114.33,26.81 114.51,26.63 114.67,26.63 114.78,26.74 114.78,26.89 114.6,27.08 114.6,27.23 114.71,27.34 114.86,27.34 115.05,27.16 115.2,27.16 115.38,27.33 115.38,27.51 115.17,27.72 115.17,27.87 115.28,27.98 115.44,27.98 115.64,27.78 115.8,27.78 115.91,27.89 115.91,28.05 115.7,28.25 115.7,28.41 115.81,28.52 115.97,28.52 116.18,28.31 116.33,28.31 116.44,28.42 116.44,28.58 116.24,28.78 116.24,28.94 116.35,29.05 116.5,29.05 116.71,28.84 116.86,28.84 116.97,28.95 116.97,29.11 116.77,29.31 116.77,29.47 116.88,29.58 117.03,29.58 117.24,29.38 117.39,29.38 117.5,29.49 117.5,29.64 117.3,29.85 117.3,30 124.42,37.13 124.96,37.13 125.74,37.91 v3(125.74,38.12)
  IN3 w0.094: v3(125.74,38.12) 125.95,38.1 v4(126.19,38.31)
DDR_D_D2_0: length 18.3
  IN3 w0.094: v3(119.64,21.42) 119.65,21.43 119.65,29.86 122.54,32.75 122.54,38.25 v4(122.73,38.44)
DDR_D_D2_1: length 18.8
  IN1 w0.094: v2(119.64,22.07) 119.65,22.07 119.89,21.84 v3(120.03,21.84)
  IN3 w0.094: v3(120.03,21.84) 120.1,21.84 120.38,22.12 120.38,29.9 123.08,32.6 123.08,36.82 123.86,37.61 123.86,38.27 v4(124.03,38.44)
DDR_D_D2_2: length 16.4
  IN1 w0.094: v2(119.64,24.02) 119.31,24.35 v3(119.24,24.35)
  IN3 w0.094: v4(122.08,38.44) 122.29,38.24 122.29,32.85 118.8,29.37 118.8,24.76 119.22,24.35 v3(119.24,24.35)
DDR_D_D2_3: length 22.8
  IN3 w0.094: v4(123.38,39.77) 123.14,40.01 123.03,40.01 122.98,40.06 121.99,40.06 121.67,39.75 120.85,39.75 120.56,39.46 120.56,33.55 116.77,29.76 116.77,23.08 117.43,22.42 117.69,22.42 v3(118.04,22.07)
DDR_D_D2_4: length 18.1
  IN1 w0.094: v2(119.64,23.37) 119.7,23.37 v3(120.02,23.05)
  IN3 w0.094: v4(123.38,38.44) 122.83,37.89 122.83,32.7 119.89,29.76 119.89,26.14 120,26.03 120.03,26.03 120.14,25.92 120.14,25.77 120.03,25.66 120,25.66 119.89,25.55 119.89,25.39 120,25.28 120.03,25.28 120.14,25.17 120.14,25.02 120.03,24.91 120,24.91 119.89,24.8 119.89,24.64 120,24.53 120.03,24.53 120.14,24.42 120.14,24.26 120.03,24.15 120,24.15 119.89,24.04 119.89,23.18 v3(120.02,23.05)
DDR_D_D2_5: length 25
  IN3 w0.094: v3(118.04,21.42) 117.65,21.81 116.82,21.81 116.53,22.11 116.53,29.86 120.31,33.65 120.31,39.58 120.71,39.98 121.6,39.98 121.87,40.25 123.26,40.25 123.74,39.77 v4(124.03,39.77)
DDR_D_D2_6: length 19.2
  IN3 w0.094: v3(118.04,24.02) 117.97,24.1 117.46,24.1 117.27,24.29 117.27,29.56 121.05,33.34 121.05,39.11 121.27,39.34 122.06,39.34 122.49,39.77 v4(122.73,39.77)
DDR_D_D2_7: length 19.8
  IN3 w0.094: v4(122.08,39.77) 122.01,39.77 121.8,39.56 121.04,39.56 120.8,39.32 120.8,33.44 117.02,29.66 117.02,23.68 117.32,23.37 v3(118.04,23.37)
DDR_D_D3_0: length 25.6
  IN1 w0.094: v3(112.08,24.3) 112.36,24.02 v2(112.44,24.02)
  IN3 w0.094: v4(122.73,42.36) 122.2,42.89 119.54,42.89 117.77,41.12 117.77,34.76 112.08,29.07 v3(112.08,24.3)
DDR_D_D3_1: length 31.3
  IN3 w0.094: v4(124.03,42.36) 122.99,43.39 119.35,43.39 117.28,41.33 117.28,34.97 111.19,28.88 111.19,22.11 111.9,21.4 112.42,21.4 v3(112.44,21.42)
DDR_D_D3_2: length 25
  IN1 w0.094: v3(112.76,23.67) 112.47,23.37 v2(112.44,23.37)
  IN3 w0.094: v3(112.76,23.67) 112.56,23.87 112.56,29.2 118.02,34.66 118.02,41.02 119.64,42.64 121.5,42.64 121.79,42.36 v4(122.08,42.36)
DDR_D_D3_3: length 25.7
  IN3 w0.094: v3(114.04,21.42) 114.07,21.46 114.67,21.46 115.46,22.24 115.46,29.14 120.07,33.75 120.07,39.82 120.56,40.32 121.63,40.32 121.75,40.44 122.78,40.44 123.08,40.73 123.53,40.73 123.87,41.07 v4(124.03,41.07)
DDR_D_D3_4: length 29.6
  IN3 w0.094: v4(123.38,42.36) 123.38,42.69 122.93,43.14 119.44,43.14 117.53,41.23 117.53,34.86 111.52,28.86 111.52,22.29 111.71,22.1 112.41,22.1 v3(112.44,22.07)
DDR_D_D3_5: length 24.3
  IN3 w0.094: v4(123.38,41.07) 123.28,40.97 123.04,40.97 122.7,40.63 121.65,40.63 121.59,40.57 120.47,40.57 119.82,39.92 119.82,33.85 114.72,28.75 114.72,22.75 v3(114.04,22.07)
DDR_D_D3_6: length 23.4
  TOP w0.107: UD4.C4 v3(114.33,23.12)
  IN3 w0.094: v4(122.73,41.07) 122.48,40.82 120.16,40.82 119.57,40.24 119.57,33.95 114.42,28.8 114.42,28.14 114.31,28.03 114.28,28.03 114.17,27.92 114.17,27.76 114.28,27.65 114.31,27.65 114.42,27.54 114.42,23.2 v3(114.33,23.12)
DDR_D_D3_7: length 22.4
  IN3 w0.094: v4(122.08,41.07) 122.04,41.11 120.1,41.11 119.33,40.34 119.33,34.06 113.93,28.66 113.93,27.42 114.04,27.31 114.05,27.31 114.16,27.2 114.16,27.04 114.05,26.93 114.04,26.93 113.93,26.82 113.93,26.67 114.04,26.56 114.05,26.56 114.16,26.45 114.16,26.29 114.05,26.18 114.04,26.18 113.93,26.07 113.93,25.91 114.04,25.8 114.05,25.8 114.16,25.69 114.16,25.54 114.05,25.43 114.04,25.43 113.93,25.32 113.93,25.16 114.04,25.05 114.05,25.05 114.16,24.94 114.16,24.14 v3(114.04,24.02)
DDR_D_DQS0: length 29.5
  IN1 w0.089: v3(118.42,12.61) 118.78,12.97 v2(118.84,12.97)
  IN3 w0.097: v4(125.81,36.91) 126.1,36.42 126.1,36.19 126.01,36.1 126.01,35.9 125.63,35.52 125.63,35.3 124.87,34.55 124.87,31.73 122.67,29.53 122.67,14.54 121.08,12.95 120.49,12.95 120.29,12.74 118.55,12.74 v3(118.42,12.61)
DDR_D_DQS1: length 39.5
  TOP w0.099: v2(112.97,13.3) 112.96,13.29 112.96,13.26 UD4.W3
  IN1 w0.097: v2(112.97,13.3) 113.09,13.3 113.23,13.17 113.23,13.04 113.13,12.94 112.82,12.94 112.74,13.02 110.95,13.02 109.8,14.18 109.8,23.05 110.1,23.35 110.1,25.48 111.1,26.48 113.04,26.48 124.01,37.45 125,37.45 125.38,37.83 125.38,39.25 125.21,39.42 125.21,39.52 125.29,39.59 125.66,39.59 v3(125.74,39.52)
  IN3 w0.097: v4(126.19,39.61) v3(125.74,39.52)
DDR_D_DQS2: length 20.9
  IN1 w0.097: v3(119.21,22.39) 118.87,22.72 v2(118.84,22.72)
  IN3 w0.097: v3(119.21,22.39) 119.07,22.53 119.07,22.81 118.78,23.1 118.78,24.2 118.3,24.68 118.3,29.58 121.76,33.03 121.76,37.66 121.58,37.84 121.58,38.55 121.73,38.7 123.15,38.7 123.57,39.12 123.71,39.12 v4(123.71,39.11)
DDR_D_DQS3: length 27.2
  IN1 w0.097: v3(112.95,22.44) v2(113.24,22.72)
  IN3 w0.051: 122.71,41.7 122.72,41.69 122.72,41.65 122.9,41.47 123.16,41.47 123.26,41.57 123.26,41.68 123.21,41.73 v4(123.06,41.73)
  IN3 w0.097: v3(112.95,22.44) 113.22,22.7 113.22,29.02 118.52,34.32 118.52,40.81 119.81,42.11 120.77,42.11 121.04,41.83 121.52,41.83 121.73,42.04 122.38,42.04 122.71,41.7
DDR_D_DQS#0: length 29.4
  IN1 w0.089: v3(118.48,13.3) 118.48,13.53 118.57,13.62 v2(118.84,13.62)
  IN3 w0.097: v4(125.81,36.26) 125.81,35.98 125.43,35.6 125.43,35.39 124.67,34.63 124.67,31.82 122.47,29.62 122.47,14.62 120.99,13.15 120.41,13.15 120.21,12.95 118.18,12.95 118.08,13.04 118.08,13.21 118.18,13.3 v3(118.48,13.3)
DDR_D_DQS#1: length 39.5
  TOP w0.099: UD4.V3 113.5,13.36 v2(113.5,13.33)
  IN1 w0.097: v2(113.5,13.33) 113.43,13.26 113.43,12.96 113.21,12.74 112.74,12.74 112.65,12.82 110.87,12.82 109.59,14.1 109.59,23.13 109.9,23.44 109.9,25.57 111.01,26.68 112.95,26.68 123.93,37.65 124.91,37.65 125.18,37.92 125.18,39.16 v3(124.83,39.52)
  IN3 w0.097: v4(125.28,39.61) v3(124.83,39.52)
DDR_D_DQS#2: length 20.8
  IN1 w0.097: v3(118.5,22.4) 118.52,22.4 v2(118.84,22.07)
  IN3 w0.097: v4(123.06,39.11) 123.06,39.01 122.95,38.9 121.64,38.9 121.38,38.63 121.38,37.75 121.55,37.58 121.55,33.12 118.1,29.66 118.1,24.6 118.58,24.11 118.58,23.01 118.87,22.73 118.87,22.51 118.75,22.4 v3(118.5,22.4)
DDR_D_DQS#3: length 27.2
  IN1 w0.097: v3(113.56,22.39) v2(113.24,22.07)
  IN3 w0.051: 122.57,41.56 122.58,41.55 122.63,41.55 122.84,41.33 123.22,41.33 123.4,41.51 123.4,41.68 123.45,41.73 v4(123.71,41.73)
  IN3 w0.097: v3(113.56,22.39) 113.42,22.52 113.42,28.94 118.72,34.24 118.72,40.73 119.9,41.9 120.68,41.9 120.96,41.62 121.6,41.62 121.81,41.83 122.3,41.83 122.57,41.56
DDR_D_ODTA: length 4.5
  TOP w0.069: RD37.1 108.81,20.91 RD38.1 110.23,21.5 111.17,20.56
  TOP w0.081: UD4.G2 112.13,20.46 111.27,20.46 111.17,20.56
DDR_D_ODTB: length 4.1
  TOP w0.069: 111.17,15.25 109.55,15.25 RD40.1 109.39,15.45 RD39.1
  TOP w0.102: UD4.T2 112.12,15.25 111.17,15.25
DDR_DRAMRST#: length 103.3
  TOP w0.069: v5(107.91,20.52) 108.2,20.23 RH12.1 ; v2(166.13,10.25) 166,10.13 166,8.82 165.56,8.37 RH42.1
  IN1 w0.061: v3(109.89,10.91) 110.06,10.75 113.2,10.75 113.51,10.43 115.06,10.43 115.51,9.97 136.43,9.97 136.93,10.47 140.78,10.47 141.62,9.63 145.94,9.63 146.25,9.94 165.81,9.94 v2(166.13,10.25) 166.69,10.81 167.68,10.81 170.35,13.48 170.35,13.85 170.71,14.22 170.71,20.9 170.76,20.95 170.76,21.91 170.9,22.04 170.9,24.8 170.06,25.64 170.06,28.07 170.04,28.09 170.04,30.16 169.69,30.51 169.69,30.74 168.13,32.3 165.86,32.3 v4(165.62,32.53)
  IN3 w0.061: v3(109.89,10.91) 109.89,18.53 v5(107.91,20.52)
  BOTTOM w0.069: UC1.DK47 165.73,36.02 165.73,35.71 165.67,35.65 165.67,35.55 165.73,35.49 165.73,34.11 165.62,34 v4(165.62,32.53)
DDR_DRAMRST#_R: length 73.9
  TOP w0.069: RH42.2 164.99,8.4 164.99,8.93 CC740.1 164.96,9.27 165.04,9.35 165.04,10.02 165.01,10.05 v2(165.01,10.29) ; v2(132.84,15.02) 132.94,14.92 UD3.T11
  IN1 w0.061: v2(119.64,14.92) 120.06,14.92 121.3,13.68 121.3,11.4 122.07,10.62 129.86,10.62 ; 129.87,10.62 129.87,15.04 130.11,15.28 132.58,15.28 v2(132.84,15.02) ; 129.87,10.62 129.95,10.54 136.2,10.54 136.7,11.04 141.01,11.04 141.86,10.2 145.68,10.2 146.75,11.28 147.62,11.28 147.84,11.49 147.84,13.83 148.6,14.6 150.13,14.6 150.28,14.75 150.49,14.75 150.59,14.65 151,14.65 151.28,14.92 v2(151.65,14.92) 151.93,15.21 152.72,15.21 153.19,14.74 153.19,12.68 155.24,10.62 161.68,10.62 ; v2(165.23,14.92) 165.16,15 164.74,15 164.5,15.23 164.38,15.23 164.15,15 163.9,15 163.88,15.02 163.88,15.02 163.59,15.31 162.68,15.31 161.68,14.32 161.68,10.62 ; 161.68,10.62 164.68,10.62 v2(165.01,10.29)
DEBUG_TX: length 3.6
  IN3 w0.061: v4(243.12,11.68) 243.15,11.68 243.18,11.65 243.18,10.94 v4(243.46,10.66)
  BOTTOM w0.069: JDEG1.9 242.61,12.73 RE209.2 242.81,12.64 243.09,12.36 243.09,11.75 243.12,11.73 v4(243.12,11.68)
DISP_UTILS: length 1.1
  IN1 w0.061: v2(124.8,57.73) 124.41,58.12 124.18,58.12 v4(123.93,58.37)
DISPOFF#: length 112.7
  TOP w0.069: v3(169,55.41) 169,54.55 169.64,53.92 171.41,53.92 RH744.1
  IN2 w0.051: v3(169,55.41) 168.99,55.41 168.41,54.83 164.69,54.83 164.57,54.7 163.36,54.7 162.47,55.59 158.71,55.59 156.22,58.08 153.21,58.08 152.81,57.68 147.46,57.68 146.95,58.18 146.19,58.18 145.48,57.47 144.87,57.47 144.31,58.03 143.8,58.03 143.37,58.46 141.66,58.46 140.89,59.23 136.41,59.23 136.31,59.33 136.31,60.22 v3(136.34,60.24) ; v4(205.7,17.67) 205.03,17.67 199.51,23.19 199.51,26.54 195.04,31.01 195.04,31.76 194.17,32.63 189.88,32.63 189.53,32.99 188.75,32.99 188.2,33.54 186.89,33.54 185.35,35.07 184.38,35.07 183.35,36.1 183.35,37.29 182.7,37.94 180.13,40.51 180.02,40.51 178.56,40.51 174.46,44.6 174.46,47.31 175.3,48.15 175.3,48.9 175.53,49.13 175.53,50.79 v3(175.3,51.02)
  IN3 w0.061: v3(169,55.41) 169.01,55.42 170.62,55.42 175.02,51.02 v3(175.3,51.02) ; v3(136.34,60.24) 136.16,60.06 135.83,60.06 v4(135.8,60.04)
  BOTTOM w0.069: v4(135.8,60.04) 135.5,60.04 135.22,59.76 133.82,59.76 133.57,60.01 133.57,61.92 134.25,62.6 134.25,63.95 134.35,64.05 JEDP1.3 ; v4(205.7,17.67) 205.27,17.67 D2.1 204.16,17.49 203.91,17.24 C761.2 R31.2
DISPOFF_R#: length 2
  TOP w0.069: QC2.2 RH744.2 172.89,53.87 v1(172.99,53.97)
DMIC_CLK12: length 175.3
  TOP w0.069: RA62.1 v2(260.69,56.71) ; R634.2 187.36,46.38 187.36,48.42 v1(189.41,50.47) 190.59,51.66 v3(191.07,51.66)
  IN1 w0.061: v3(239.23,19.07) 239.12,19.18 239.21,19.27 239.21,19.41 239.8,20.01 240.34,20.01 240.92,20.59 241.53,20.59 242.23,21.29 243.72,21.9 244.52,22.71 247.88,22.71 249.86,24.69 249.86,25.73 251.79,27.67 254.35,27.67 255.13,28.44 256.29,28.44 258.46,30.61 258.46,33.95 256.12,36.29 256.12,37.6 256.97,38.45 256.97,40.78 257.44,41.26 257.44,42.61 258.44,43.61 258.44,45.8 259.25,46.6 259.25,52.95 259.02,53.18 259.02,55.97 259.75,56.71 v2(260.69,56.71)
  IN3 w0.061: v4(173.78,63.31) 174.13,62.96 174.13,62.65 176.4,60.38 180.63,60.38 181.69,59.33 182.64,59.33 190.31,51.66 v3(191.07,51.66) 191.07,50.93 192.82,49.18 194.36,49.18 200.96,42.58 201.65,42.58 205.07,39.16 205.07,36.93 206.29,35.7 206.29,27.32 205.35,26.38 205.35,21.85 210.89,16.3 218.66,16.3 219.37,17.02 236.86,17.02 237.61,17.76 238.18,17.76 239.04,18.62 239.04,18.87 v3(239.23,19.07)
  BOTTOM w0.069: v4(173.78,63.31) 173.46,63.63 171.45,63.63 169.8,65.28 169.8,66.51 168.94,67.36 162.18,67.36 161.89,67.08 161.89,66.74 162.05,66.58 JUFC1.20
DMIC_CLK12_R: length 1.2
  TOP w0.069: RA62.2 260.01,57.35 UA1.5
DMIC_DATA12: length 175.4
  TOP w0.069: v3(190.89,52.14) 190.45,52.14 v1(187.66,49.35) 187.16,48.85 187.16,46.58 R655.2 ; RA58.1 259.42,56.41 258.94,55.92 258.94,54.78 v2(258.2,54.04)
  IN1 w0.061: v2(258.2,54.04) 258.83,53.42 258.83,53.1 259.06,52.87 259.06,46.68 258.26,45.87 258.26,43.69 257.26,42.69 257.26,41.33 256.78,40.86 256.78,38.52 255.93,37.68 255.93,36.21 258.27,33.87 258.27,30.69 256.21,28.63 255.05,28.63 254.27,27.85 251.71,27.85 249.67,25.81 249.67,24.77 247.8,22.9 244.45,22.9 243.61,22.06 242.12,21.45 241.45,20.78 240.84,20.78 240.26,20.2 239.72,20.2 239.02,19.49 239.02,19.35 v3(238.73,19.06)
  IN3 w0.061: v3(238.73,19.06) 238.85,18.93 238.85,18.7 238.1,17.95 237.53,17.95 236.78,17.2 219.3,17.2 218.58,16.49 210.97,16.49 205.54,21.93 205.54,26.31 206.48,27.24 206.48,35.78 205.25,37 205.25,39.24 201.73,42.77 201.04,42.77 194.44,49.36 192.9,49.36 191.43,50.84 191.43,51.88 191.17,52.14 v3(190.89,52.14) 190.11,52.14 182.73,59.51 181.77,59.51 180.71,60.57 176.48,60.57 174.36,62.69 174.36,63.67 174.05,63.97 v4(173.6,63.97)
  BOTTOM w0.069: v4(173.6,63.97) 173.45,63.82 171.53,63.82 169.99,65.36 169.99,66.59 169.03,67.56 162.09,67.56 161.7,67.16 JUFC1.22
DMIC_DATA12_R: length 1.3
  TOP w0.069: RA58.2 259.61,57.48 UA1.4
DP_RCOMP: length 2.3
  TOP w0.305: RC3.1 129.49,58.75 129.1,59.15 v2(128.69,59.15)
  IN1 w0.305: v2(128.69,59.15) 128.69,58.74 v3(128.87,58.56)
  IN3 w0.305: v4(129.38,58.37) 129.09,58.37 128.89,58.56 v3(128.87,58.56)
EAPD: length 334.6
  TOP w0.069: v3(265.52,56.25) 266.41,56.25 DA10.2 266.1,57.07 RA21.1 265.24,57.07 CA55.1 264.58,56.41 RA84.2 ; v3(193.68,11.77) 193.47,11.77 193.41,11.83 v1(193.41,12.46) ; RE531.2 170.1,12.98 170.1,12.39 170.65,11.84 170.65,11.3 v2(171.26,10.69) ; v2(27.01,21.06) 26.75,21.06 26.4,21.4 26.4,21.71 26.07,22.05 UA2.21 ; v2(273.04,32.28) 272.93,32.28 272.74,32.47 UA3.21
  IN1 w0.061: v3(170.27,9.52) 171.26,10.51 v2(171.26,10.69) ; v3(274.28,42.44) 273.9,42.05 273.9,33.04 273.15,32.28 v2(273.04,32.28) ; v3(30.39,20.49) 30.14,20.74 28.94,20.74 28.63,21.06 v2(27.01,21.06)
  IN2 w0.051: v3(30.39,20.49) 31.06,20.49 32.53,19.03 32.53,15.7 31.43,14.61 31.43,11.93 30.82,11.32 30.82,7.18 31.81,6.19 35.22,6.19 35.57,6.55 37.76,6.55 38.37,5.94 39.92,5.94 40.38,6.4 40.38,6.82 41.46,7.9 41.82,7.9 41.96,8.05 62.57,8.05 63.03,7.59 73.81,7.59 74.36,8.15 80.42,8.15 80.93,7.64 93.44,7.64 94.76,6.32 104.71,6.32 104.92,6.52 107.75,6.52 108.74,7.51 111.61,7.51 112.22,8.12 167.46,8.12 167.84,8.51 169.26,8.51 v3(170.27,9.52) 170.47,9.72 175.89,9.72 177.46,11.3 184.56,11.3 186.26,13 191.52,13 192.67,11.84 193.32,11.84 193.39,11.77 v3(193.68,11.77) ; v3(265.52,56.25) 265.82,55.95 265.82,55.52 266.21,55.14 270.85,55.14 271.46,55.75 273.75,55.75 274.16,55.34 274.16,49.93 274.69,49.4 276.11,49.4 v3(276.21,49.29)
  IN3 w0.061: v3(276.21,49.29) 276.62,48.89 276.62,44.7 274.36,42.44 v3(274.28,42.44) 274.19,42.44 271.78,40.02 268.87,40.02 268.31,39.46 268.31,38.63 267.74,38.05 267.74,33.94 258.37,24.57 255.43,24.57 253.7,22.84 253.28,22.84 252.7,22.26 251.87,22.26 250.79,21.18 250.03,21.18 247.54,18.69 245.99,18.69 244.29,16.99 244.29,15.26 242.6,13.58 236.86,13.58 236.29,13.01 220.61,13.01 220.1,12.49 213.79,12.49 212.81,11.51 195.28,11.51 194.92,11.87 193.78,11.87 v3(193.68,11.77)
EAPD_R: length 8.8
  TOP w0.069: UE1.L2 177.37,14.59 177.03,14.24 175.45,14.24 174.82,13.61 173.88,13.61 173.67,13.4 173.67,12.92 173.62,12.87 171.97,12.87 RE531.1 170.47,14.37 v1(170.47,14.47)
EC_AMP_I2C_CLK: length 39.5
  TOP w0.069: RE527.2 178.5,26.83 178.69,26.64 178.92,26.64 179.39,26.17 v3(179.39,26.15) ; v4(192.5,7.56) 192.5,7.94 195.92,11.36 195.92,13.48 v1(195.39,14.02) 195.28,14.12 195.28,15.35 v3(195.37,15.44)
  IN1 w0.061: v2(178.33,21.79) 178.5,21.96 178.5,22.77 179.54,23.82 179.54,24.16 179.9,24.52 179.9,25.65 v3(179.39,26.15)
  IN2 w0.051: v3(195.37,15.44) 194.76,16.05 189.22,16.05 188.79,16.47 188.79,17.1 188.05,17.84 188.05,20.76 185.88,22.93 182.73,22.93 179.5,26.15 v3(179.39,26.15)
  BOTTOM w0.069: Q352.6 192.37,7.69 v4(192.5,7.56)
EC_AMP_I2C_DAT: length 46.6
  TOP w0.069: v2(178.58,20.59) 178.75,20.41 178.75,19.27 178.98,19.04 179.58,19.04 UE1.E5 ; v4(191.63,7.59) 191.63,7.56 191.99,7.21 192.71,7.21 192.87,7.36 192.87,7.78 196.33,11.24 v1(196.33,12.44) 196.33,14.14 v3(195.55,14.92) ; v3(178.8,26.15) 178.65,26.15 178.35,26.45 177.76,26.45 RE526.2
  IN1 w0.061: v2(178.58,20.59) 178.58,20.64 178.02,21.2 178.02,21.94 178.2,22.12 178.2,22.7 179.35,23.85 179.35,24.31 179.64,24.6 179.64,25.41 179.35,25.7 179.26,25.7 v3(178.8,26.15)
  IN2 w0.051: v3(178.8,26.15) 179.13,25.82 179.4,25.82 180.61,24.62 180.61,23.82 180.89,23.54 181.62,23.54 182.54,22.62 185.75,22.62 187.75,20.63 187.75,17.71 188.49,16.97 188.49,16.35 189.09,15.74 193.84,15.74 194.65,14.93 195.54,14.93 v3(195.55,14.92)
  BOTTOM w0.069: v4(191.63,7.59) 191.63,7.56 191.67,7.53 Q352.3
EDP_AUXN: length 12.9
  TOP w0.081: v5(131.01,59.94) 131.01,59.2 131.68,58.54 v7(132.53,58.54) 133.21,58.54 134.48,59.81 134.48,61.71 134,62.2 133.34,62.2 132.49,63.05 132.49,63.35 C10.1
  IN3 w0.076: v5(131.01,59.94) 131.21,59.74 131.21,58.39 131,58.18 131,57.9 131.29,57.62 v4(131.29,57.39)
EDP_AUXN_C: length 2.8
  TOP w0.081: v5(133.45,65.56) 133.24,65.34 133.24,65.17 133.03,64.97 132.81,64.97 132.53,64.68 132.53,64.33 C10.2
  BOTTOM w0.081: v5(133.45,65.56) 133.24,65.77 133.24,65.98 133.3,66.04 JEDP1.10
EDP_AUXP: length 12.9
  TOP w0.081: v5(131.6,59.94) 131.67,59.94 132.13,59.48 132.13,59.42 131.94,59.23 131.84,59.23 131.51,59.56 131.38,59.56 131.22,59.39 131.22,59.29 131.76,58.74 133.13,58.74 v7(133.84,59.46) 134.28,59.89 134.28,61.63 133.91,61.99 133.25,61.99 132.28,62.96 132.28,63.35 C9.1
  IN3 w0.076: v4(131.29,58.04) 131.27,58.06 131.27,58.17 131.41,58.31 131.41,59.74 v5(131.6,59.94)
EDP_AUXP_C: length 2.8
  TOP w0.081: C9.2 132.32,64.41 132.32,64.76 v7(132.56,65) 132.73,65.17 132.95,65.17 133.03,65.25 133.03,65.39 v5(132.87,65.56)
  BOTTOM w0.081: v5(132.87,65.56) 133.03,65.73 133.03,66.01 132.95,66.09 JEDP1.12
EDP_BIA_PWM: length 48.7
  IN1 w0.061: v3(175.15,47.21) 174.87,47.21 174.05,48.02 172.45,48.02 170.88,49.6 169.08,49.6 168.58,50.09 v4(168.58,50.25)
  IN2 w0.051: v3(175.15,47.21) 175.15,46.35 175.27,46.22 175.27,44.22 178.68,40.81 179.8,40.81 180.26,40.81 184.16,36.91 184.16,35.96 184.75,35.37 185.48,35.37 186.88,33.98 190.87,33.98 191.91,32.94 194.3,32.94 195.7,31.54 195.7,31.45 195.97,31.17 v4(195.97,31.13)
  BOTTOM w0.069: UC1.DU19 169.16,50.28 168.61,50.28 v4(168.58,50.25) ; D3.3 202.39,24.83 v1(201.23,25.99) 200.96,26.26 200.96,27.47 199.04,29.4 198.06,29.4 196.73,30.72 196.42,30.72 196.01,31.13 v4(195.97,31.13)
EDP_HPD: length 108.5
  TOP w0.069: v4(136.01,65.5) 136.84,65.5 TP117.1
  IN1 w0.061: v2(186.33,20.99) 186.56,21.22 186.56,23.24 v3(186.75,23.44)
  IN2 w0.051: v3(193.49,33.48) 191.8,33.48 191,34.28 187,34.28 185.61,35.68 184.88,35.68 184.47,36.09 184.47,37.1 183.31,38.25 183.31,38.99 181.78,40.52 181.55,40.52 181.01,41.06 181.01,41.6 180.65,41.96 180.65,42.4 179.24,43.82 179.24,45.8 178.22,46.82 178.22,48.33 176.12,50.43 v3(176.12,51) 176.09,51.03 176.09,51.61 174.92,52.77 174.92,57.02 167.15,64.79 167.15,65.26 166.91,65.49 165.91,65.49 165.31,66.09 155.2,66.09 154.12,65.02 149.11,65.02 148.42,65.7 145.73,65.7 145.35,66.08 143.6,66.08 143.14,65.63 140.67,65.63 140.34,65.3 136.21,65.3 v4(136.01,65.5)
  IN3 w0.061: v3(186.75,23.44) 187.06,23.74 187.08,23.74 188.25,24.91 188.76,24.91 189.83,25.98 190.17,25.98 190.41,26.23 190.41,26.54 190.96,27.08 191.64,27.08 192.78,28.22 193.07,28.22 193.31,28.45 193.31,28.59 193.9,29.18 193.9,30.75 193.23,31.41 193.23,33.23 v3(193.49,33.48) ; v4(172.51,53.92) 175.05,51.38 175.74,51.38 v3(176.12,51)
  BOTTOM w0.069: v4(136.01,65.5) 135.57,65.07 134.33,65.07 133.97,64.71 133.82,64.71 133.65,64.54 JEDP1.7 ; RH675.1 172.56,53.97 v4(172.51,53.92) 172.48,53.89 171.46,53.89 171.43,53.85 UC1.DW11
EDP_TXN0: length 6.8
  IN3 w0.076: v4(131.54,61.06) 131.62,61.14 131.62,61.39 131.81,61.58 132.3,61.58 133.11,60.78 133.11,57.8 132.45,57.14 131.93,57.14 v4(131.85,57.06)
EDP_TXN0_C: length 5.1
  IN3 w0.076: v4(131.88,64.86) 131.97,64.77 131.97,64.45 132.15,64.27 132.15,63.99 v4(132.06,63.9)
  BOTTOM w0.081: v4(132.06,63.9) 132.14,63.81 132.14,63.39 131.74,62.98 131.74,61.85 C2.2 ; v4(131.88,64.86) 131.97,64.95 131.97,65.98 131.9,66.05 JEDP1.18
EDP_TXN1: length 7.9
  TOP w0.081: C4.1 131.4,61.96 131.4,61.8 131.64,61.56 132.67,61.56 133.16,61.07 v7(133.16,60.83) 133.16,60.27 132.86,59.96 132.48,59.96 132.3,60.15 132.3,60.36 132.4,60.46 v5(132.47,60.46)
  BOTTOM w0.081: v5(132.47,60.46) 132.56,60.46 132.7,60.31 132.7,60.19 132.58,60.06 132.35,60.06 132.3,60.01 132.3,59.75 131.97,59.42 131.97,59.32 132.17,59.12 132.17,58.69 132.12,58.64 131.98,58.64 131.85,58.77 UC1.Y1
EDP_TXN1_C: length 4
  TOP w0.081: C4.2 131.36,62.93 131.36,64.41 130.95,64.81 v7(130.95,65.02) 130.95,65.4 v5(130.78,65.57)
  BOTTOM w0.081: v5(130.78,65.57) 131,65.79 131,65.94 130.85,66.08 JEDP1.24
EDP_TXN2: length 7.9
  TOP w0.081: v5(130.16,60.48) 130.25,60.48 130.34,60.57 130.34,60.9 130.52,61.08 131.07,61.08 131.13,61.14 131.13,61.24 130.63,61.73 130.63,62.15 130.54,62.25 130.14,62.25 129.93,62.45 129.93,62.99 130.12,63.17 130.4,63.17 130.44,63.22 130.44,63.37 130.26,63.55 C6.1
  BOTTOM w0.081: UC1.V2 130.54,58.36 130.39,58.51 130.39,59.1 130.62,59.33 130.62,59.45 130.56,59.5 130.46,59.5 130.27,59.7 130.27,60.1 130.37,60.2 130.37,60.34 130.23,60.48 v5(130.16,60.48)
EDP_TXN2_C: length 2.9
  TOP w0.081: C6.2 130.44,64.36 130.44,64.47 130.38,64.53 130.05,64.53 129.83,64.75 129.83,65.27 v5(129.61,65.5)
  BOTTOM w0.081: JEDP1.30 129.8,65.69 v5(129.61,65.5)
EDP_TXN3: length 6.1
  IN3 w0.076: v4(130.73,57.71) 130.84,57.71 130.93,57.62 130.93,57.42 130.87,57.37 130.7,57.37 130.48,57.58 130.48,59.57 129.82,60.23 129.82,60.82 130.31,61.31 130.62,61.31 130.7,61.23 130.7,61.14 130.54,60.98 130.47,60.98 v4(130.39,61.05)
EDP_TXN3_C: length 5.8
  IN3 w0.076: v4(129.96,63.86) 130.06,63.96 130.06,64.02 129.9,64.18 129.63,64.18 129.25,64.56 129.25,64.72 v4(129.16,64.81)
  BOTTOM w0.081: v4(129.96,63.86) 130.05,63.77 130.05,63.07 130.57,62.55 130.57,61.82 C8.2 ; JEDP1.36 128.75,66.08 128.82,66.01 128.82,65.39 129.25,64.96 129.25,64.9 v4(129.16,64.81)
EDP_TXP0: length 6.8
  IN3 w0.076: v4(131.85,57.71) 131.68,57.71 131.64,57.68 131.64,57.47 131.76,57.34 132.37,57.34 132.91,57.88 132.91,60.69 132.22,61.38 131.89,61.38 131.81,61.31 131.81,61.08 131.89,61 132.06,61 v4(132.12,61.06)
EDP_TXP0_C: length 5.1
  IN3 w0.076: v4(132.26,64.86) 132.17,64.77 132.17,64.53 132.35,64.35 132.35,63.99 v4(132.44,63.9)
  BOTTOM w0.081: v4(132.26,64.86) 132.17,64.95 132.17,65.99 132.25,66.06 JEDP1.16 ; v4(132.44,63.9) 132.35,63.81 132.35,63.31 131.94,62.9 131.94,61.82 C1.2
EDP_TXP1: length 8
  TOP w0.081: v5(131.89,60.46) 131.97,60.46 132.09,60.33 132.09,60.06 132.4,59.76 132.94,59.76 133.36,60.18 133.36,61.16 132.75,61.77 131.72,61.77 131.6,61.89 131.6,61.96 C3.1
  BOTTOM w0.081: v5(131.89,60.46) 132.09,60.25 132.09,59.83 131.76,59.5 131.76,59.35 131.59,59.17 131.59,58.75 131.85,58.48 UC1.Y2
EDP_TXP1_C: length 4
  TOP w0.081: v5(131.37,65.57) 131.15,65.36 131.15,64.9 131.56,64.49 131.56,63.01 C3.2
  BOTTOM w0.081: JEDP1.22 131.2,65.74 v5(131.37,65.57)
EDP_TXP2: length 7.9
  TOP w0.081: v5(130.75,60.48) 130.69,60.48 130.54,60.62 130.54,60.82 130.6,60.88 131.15,60.88 131.33,61.05 131.33,61.32 130.83,61.82 130.83,62.24 130.62,62.45 130.22,62.45 130.14,62.54 130.14,62.91 130.2,62.97 130.48,62.97 130.65,63.14 130.65,63.35 C5.1
  BOTTOM w0.081: UC1.V1 130.63,58.92 130.63,58.75 130.69,58.69 130.91,58.69 131.05,58.83 131.05,59.12 130.82,59.35 130.82,59.53 130.65,59.71 130.54,59.71 130.47,59.78 130.47,60.01 130.57,60.11 130.57,60.3 v5(130.75,60.48)
EDP_TXP2_C: length 2.9
  TOP w0.081: C5.2 130.65,64.34 130.65,64.56 130.47,64.74 130.14,64.74 130.04,64.84 130.04,65.34 v5(130.19,65.5)
  BOTTOM w0.081: JEDP1.28 130.15,66.09 130,65.95 130,65.69 v5(130.19,65.5)
EDP_TXP3: length 6.2
  IN3 w0.076: v4(130.95,61.04) 130.9,61.09 130.9,61.31 130.7,61.51 130.23,61.51 129.62,60.91 129.62,60.15 130.29,59.48 130.29,57.5 130.61,57.17 130.62,57.17 v4(130.73,57.06)
EDP_TXP3_C: length 5.8
  IN3 w0.076: v4(130.34,63.86) 130.26,63.94 130.26,64.11 129.99,64.38 129.71,64.38 129.45,64.64 129.45,64.72 v4(129.54,64.81)
  BOTTOM w0.081: C7.2 130.77,61.8 130.77,62.64 130.25,63.16 130.25,63.77 v4(130.34,63.86) ; JEDP1.34 129.1,66.11 129.02,66.03 129.02,65.47 129.45,65.04 129.45,64.9 v4(129.54,64.81)
EDRAM_OPIO_RCOMP: length 2.2
  TOP w0.127: v1(121.22,52.21) 121.73,52.72 v5(121.88,52.72)
  TOP w0.254: v5(121.88,52.72) 121.85,52.76 RH6.1
  BOTTOM w0.254: UC1.A14 121.88,52.41 v5(121.88,52.72)
EMMC_RCOMP: length 0.8
  IN1 w0.305: v2(169.46,46.54) 169.76,46.24 v4(169.76,46.24)
  BOTTOM w0.305: UC1.DU28 v4(169.76,46.24)
EN1_1.1V_MEM: length 2.4
  TOP w0.069: v5(100.42,11.12) 100.8,11.5 PR706.2
  BOTTOM w0.069: PU700.16 100.07,11.47 v5(100.42,11.12) 100.45,11.12 100.9,10.66 v1(101.21,10.66)
EN2_1.1V_MEM: length 2.2
  TOP w0.069: v1(99.43,12.62) v3(100.07,12.62) 100.8,12.62 PR709.2
  IN3 w0.061: v4(100.07,12.15) v3(100.07,12.62)
EN_3V: length 3.7
  BOTTOM w0.069: PR303.1 219.29,16.5 218.56,17.24 PR302.2 218.56,18.08 v1(218.4,18.23) 218.02,18.61 PU302.11
EN_INVPWR: length 157.6
  IN1 w0.061: v2(177.53,21.79) 177.53,21.76 177.92,22.14 177.92,22.9 v3(178.78,23.77)
  IN2 w0.051: v3(110.53,66.39) 110.73,66.59 114.69,66.59 116.31,65.85 126.22,65.85 126.88,65.19 128.59,65.19 129.07,64.71 133.92,64.71 134.35,65.14 134.63,65.14 136.16,66.67 140.15,66.67 140.68,66.13 142.33,66.13 142.94,66.74 145.63,66.74 146.14,66.24 149.08,66.24 149.59,66.74 167.32,66.74 167.76,66.31 167.76,65.1 175.53,57.33 175.53,53.54 176.65,52.42 179.29,52.42 180.56,51.15 180.56,49.18 181.55,48.19 181.55,45.94 180.9,45.29 180.9,44.2 183.73,41.37 183.73,40.19 184.57,39.36 184.57,38.55 185.9,37.21 185.9,36.06 187.22,34.74 191.83,34.74 191.96,34.87 192.23,34.87 192.87,34.23 192.99,34.23 193.2,34.02 v3(193.45,34.02)
  IN3 w0.061: v4(96.99,68.8) 97.42,68.8 97.93,69.31 102.1,69.31 103.05,68.35 105.58,68.35 106.71,67.22 107.38,67.22 107.98,66.63 108.51,66.63 108.78,66.9 110.15,66.9 110.53,66.51 v3(110.53,66.39) ; v3(178.78,23.77) 179.24,24.22 182.7,24.22 182.85,24.38 186.46,24.38 187.79,25.71 188.14,25.71 188.9,26.46 189.12,26.46 189.52,26.86 190.05,26.86 190.76,27.57 191.44,27.57 192.8,28.93 193.18,28.93 193.38,29.12 193.38,31.04 193.03,31.39 193.03,33.6 v3(193.45,34.02)
  BOTTOM w0.069: v4(96.99,68.8) 96.58,68.39 v1(96.38,68.39) 96.23,68.55 95.52,68.55 94.02,67.05 91.66,67.05 91.42,66.81 R29.1 90.06,66.67 89.83,66.9 89.83,67.38 90.26,67.81 Q16.2
EN_INVPWR_R: length 4.1
  BOTTOM w0.069: Q15.3 90.96,71.83 91.28,72.15 R231.2 C1224.2 90.49,73.93 R30.1
ENBKL_TS: length 0.7
  IN1 w0.061: v4(166.99,49.34) 166.99,49.54 167.09,49.65 v2(167.12,49.65)
  BOTTOM w0.069: UC1.DL21 v4(166.99,49.34)
ENCLK_3V: length 3.2
  BOTTOM w0.069: PR306.2 218.07,15.87 218.07,17.59 217.55,18.11 PU302.12
ENVDD: length 1.8
  BOTTOM w0.069: R25.1 98.73,71.23 98.34,71.62 v1(98.34,72.61)
ENVDD_PCH: length 104.8
  IN1 w0.061: v3(100.75,59.48) 100.52,59.48 99.68,60.32 98.85,60.32 97.93,59.4 92.08,59.4 90.72,60.76 90.72,60.9 90.03,61.59 88.88,61.59 87.92,62.54 87.92,64.08 91.99,68.14 94.65,68.14 v3(95.01,67.78)
  IN2 w0.051: v3(100.75,59.48) 100.9,59.33 104.88,59.33 106.54,57.68 110.91,57.68 111.32,57.27 121.55,57.27 121.93,57.65 125.05,57.65 125.32,57.93 139.44,57.93 140.15,57.22 140.15,55.24 140.53,54.86 146.93,54.86 148.84,56.76 154.09,56.76 156.17,54.68 160.36,54.68 162.45,52.6 163.07,52.6 166,49.67 167.24,49.67 v4(167.52,49.39)
  IN3 w0.061: v4(97.45,69.31) 95.75,69.31 95.01,68.57 v3(95.01,67.78)
  BOTTOM w0.069: UC1.DN21 167.38,49.25 v4(167.52,49.39) ; D1.3 98.12,69.98 v4(97.45,69.31)
ESPI_ALERT#: length 8.2
  TOP w0.069: TP74.1 187.87,15.74 186.25,15.74 185.84,15.33 185.84,15.26 185.66,15.08 184.6,15.08 184.32,15.37 184.32,15.44 183.96,15.79 183.09,15.79 182.74,16.14 182.74,16.21 182.33,16.63 181.89,16.63 UE1.H7
ESPI_CLK: length 3.2
  TOP w0.069: v2(158.31,34.82) 158.31,33.98 RC569.2
  IN1 w0.061: v3(158.05,36.26) 157.87,36.09 157.87,35.25 v2(158.31,34.82)
  IN3 w0.061: v3(158.05,36.26) 158.06,36.26 v4(158.47,36.26)
ESPI_CLK_5105: length 74.5
  TOP w0.069: RE172.1 170.52,23.59 170.52,24.95 170.19,25.28 170.19,25.98 v2(170.49,26.27) ; UE1.G7 181.5,17.79 v3(181.16,17.45) ; JDEBUG2.10 155.51,6.58 155.67,6.73 156.6,6.73 156.87,7.01 v2(159.42,7.01) ; v3(163.97,31.87) 163.97,31.89 163.78,32.09 158.17,32.09 157.82,32.44 CC658.1 RC569.1
  IN1 w0.061: v3(181.16,17.45) 180.12,17.45 179.69,17.02 178.84,17.02 178.63,16.81 178.63,16.2 178.2,15.77 177.86,15.77 176.96,14.88 176.96,13.84 176.04,12.92 175.15,12.92 174.29,12.06 173.9,12.06 173.65,11.81 173.65,11.47 172.42,10.25 171.63,10.25 170.56,9.18 169.48,9.18 168.06,7.76 160.17,7.76 v2(159.42,7.01) ; v2(170.49,26.27) 170.5,26.28 170.5,28.06 170.55,28.11 v3(170.55,28.17)
  IN3 w0.061: v3(181.16,17.45) 180.65,16.93 178.63,16.93 178.14,16.45 176.61,16.45 174.63,18.43 174.63,20.75 173.95,21.43 173.95,25.9 173.55,26.31 172.17,26.31 170.55,27.92 v3(170.55,28.17) 170.93,28.55 170.93,29.21 168.66,31.48 165.98,31.48 165.44,32.02 164.12,32.02 v3(163.97,31.87)
ESPI_CS#: length 69.9
  TOP w0.069: JDEBUG2.7 154.01,5.57 154.11,5.46 156.48,5.46 157.57,6.56 v1(158.55,6.56) 159.68,6.56 159.98,6.85 v2(160.26,6.85) ; v3(180.37,16.6) 180.37,16.63 UE1.H6
  IN1 w0.061: v3(180.37,16.6) 180.09,16.32 179.64,16.32 178.46,15.14 178.12,15.14 177.69,14.71 177.69,13.67 176.3,12.29 175.41,12.29 172.75,9.62 171.89,9.62 170.82,8.55 169.74,8.55 168.32,7.13 160.67,7.13 160.39,6.85 v2(160.26,6.85)
  IN3 w0.061: v4(160.16,33.6) 160.9,32.86 162.25,32.86 162.99,32.12 163.25,32.12 164.32,31.04 168.47,31.04 168.85,30.67 168.85,29 170.86,26.99 170.86,26.43 171.73,25.56 171.73,22.08 171.92,21.89 172.63,21.89 172.99,21.53 172.99,20.2 174.19,19 174.19,18.24 176.43,16 179.44,16 179.76,16.33 180.1,16.33 v3(180.37,16.6)
  BOTTOM w0.069: RC712.1 160.14,33.48 160.14,33.58 v4(160.16,33.6) 160.1,33.66 160.1,34.8 160.01,34.89 160.01,36.77 159.55,37.24 UC1.CT45
ESPI_IO0: length 67.6
  TOP w0.069: JDEBUG2.3 152.01,5.35 152.68,4.68 157.44,4.68 157.93,5.17 160.65,5.17 161.29,5.8 161.29,6.48 v2(161.41,6.6) 161.05,6.95 v1(161.05,7.16)
  IN1 w0.061: v2(179.93,15.39) v3(179.93,15.72) 179.57,15.72 178.78,14.93 178.78,14.55 178.32,14.09 178.32,13.77 176.46,11.91 175.57,11.91 172.9,9.24 172.04,9.24 170.98,8.18 169.9,8.18 168.48,6.75 161.56,6.75 v2(161.41,6.6)
  IN3 w0.061: v3(179.93,15.72) 179.83,15.62 176.28,15.62 173.82,18.09 173.82,18.84 171.92,20.73 171.92,21.36 171.35,21.93 171.35,24.89 170.38,25.87 170.38,26.84 169.43,27.78 168.75,27.78 v4(168.72,27.75)
  BOTTOM w0.069: RC336.2 159.31,32.31 159.42,32.2 160.39,32.2 161.12,31.47 163.61,31.47 164.5,30.57 164.5,28.29 164.91,27.88 168.59,27.88 v4(168.72,27.75)

# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WT_RCOMP: length 1
  IN1 w0.305: v2(168.7,37.53) v3(168.34,37.53)
  IN3 w0.305: v3(168.34,37.53) 168.39,37.47 v4(168.93,37.47)
CNVI_EN#: length 150.2
  TOP w0.069: v2(169.05,32.53) 169,32.48 168.92,32.48 168.64,32.2 RH729.2 ; Q350.2 162.76,6.07 162.15,6.67 R529.1 163.36,7.89 164.56,7.89 164.62,7.83 166.01,7.83 v1(166.4,8.23) 166.62,8.45 166.62,9.08 v2(166.56,9.14)
  IN1 w0.061: v2(169.05,32.53) 169.05,32.36 170.38,31.03 170.38,30.8 171.01,30.17 171.01,28.86 171.73,28.14 v3(171.73,27.91) 171.73,27.33 171.36,26.97 171.36,25.97 171.73,25.61 171.73,22.16 171.87,22.01 173.39,22.01 173.7,21.71 173.7,21 173.15,20.44 173.15,17.75 172.63,17.24 172.63,15.98 172.03,15.37 172.03,12.86 170.1,10.93 169.11,10.93 168.16,9.97 167.4,9.97 v2(166.56,9.14)
  IN2 w0.051: v3(247.41,15.23) 245.65,15.23 240.95,10.53 233.76,10.53 233.46,10.23 224.53,10.23 223.72,9.42 222.46,9.42 222.25,9.2 216.63,9.2 216.15,9.68 210.47,9.68 209.95,9.17 207.06,9.17 205.97,10.25 201.66,10.25 197.65,14.27 194.96,14.27 193.71,15.51 189,15.51 188.26,16.25 188.26,16.87 187.52,17.62 187.52,20.54 186.55,21.51 185.38,21.51 185.15,21.73 183.68,21.73 v3(183.35,21.4)
  IN3 w0.061: v3(171.73,27.91) 172.24,27.39 173.42,27.39 174.63,26.18 174.63,23.25 175.54,22.35 175.54,21.42 176.44,20.52 180.14,20.52 180.67,19.99 181.6,19.99 182.47,20.86 182.81,20.86 v3(183.35,21.4) ; v3(247.41,15.23) 248.18,16 249.33,16 250.35,17.01 250.35,17.78 251.82,19.26 252.6,19.26 253.38,20.03 256.58,20.03 256.82,19.79 259,19.79 260.17,20.96 263.84,20.96 263.97,21.08 v4(263.97,21.1)
CNVI_EN#_R: length 24.1
  TOP w0.069: v5(153.18,38.07) v1(152.59,37.49) 151.52,36.41 151.52,32.84 152.22,32.14 157.48,32.14 157.98,31.64 163.21,31.64 163.4,31.45 166.85,31.45 RH729.1
  BOTTOM w0.069: v5(153.18,38.07) 152.9,38.07 152.73,37.9 152.73,37.34 UC1.CC45
CORE_VID0: length 47.8
  TOP w0.069: v3(191.73,53.51) 191.73,51.91 v1(187.87,48.05) 187.87,47.13 188.05,46.96 188.05,41.62 187.52,41.09 187.52,39.34 v3(187.61,39.25)
  IN3 w0.061: v4(185,39.42) 185.01,39.42 187.43,39.42 v3(187.61,39.25) ; v3(191.73,53.51) 191.73,54.07 190.77,55.03 190.77,56.02 196.04,61.29 196.04,62.65 195.77,62.92 195.77,65.91 v4(196,66.13)
  BOTTOM w0.069: v4(196,66.13) 196,66.18 PU900.6 ; RC690.2 175.71,41.34 175.75,41.3 177.34,41.3 178.14,42.11 178.14,42.61 178.54,43.01 UC6.1 179.3,43.01 179.32,42.99 179.43,42.99 179.71,42.72 RC611.2 RC609.2 180.05,42.38 180.73,42.38 181.47,41.65 182.09,41.65 183.08,40.66 183.43,40.66 183.86,40.23 183.86,40.02 184.45,39.43 184.99,39.43 v4(185,39.42)
CORE_VID0_R: length 19.8
  IN3 w0.061: v4(173.83,41.7) 173.83,41.71 173.46,42.08 169.59,42.08 169.09,42.58 168.45,42.58 167.96,42.09 165.47,42.09 165.19,41.8 160.36,41.8 160.08,41.52 157.12,41.52 v4(157.09,41.55)
  BOTTOM w0.069: RC690.1 174.66,41.34 174.51,41.19 174.13,41.19 173.84,41.48 173.84,41.68 v4(173.83,41.7) ; UC1.CL38 157.09,41.36 v4(157.09,41.55)
CORE_VID1: length 74.6
  TOP w0.069: v3(188.02,38.89) 187.87,39.05 187.87,40.96 188.25,41.34 188.25,47 188.12,47.13 188.12,47.89 190.29,50.06 191.4,50.06 v1(191.63,50.28) 191.63,50.94 192.23,51.54 v3(192.23,53.01)
  IN1 w0.061: v2(155.99,40.89) v3(155.73,40.64)
  IN3 w0.061: v3(192.23,53.01) 192.23,53.98 190.97,55.24 190.97,55.94 196.24,61.21 196.24,62.72 195.95,63.01 195.95,65.6 v4(196.36,66.01) ; v3(155.73,40.64) 155.73,40.31 156.48,39.57 158.05,39.57 158.23,39.74 161.02,39.74 162.27,40.99 165.95,40.99 166.28,40.66 168.55,40.66 168.79,40.42 170.07,40.42 170.53,39.97 171.28,39.97 171.45,40.14 172.48,40.14 172.83,39.79 175.27,39.79 175.53,39.54 175.93,39.54 177.38,40.99 180.4,40.99 181.14,40.25 v4(181.14,40.23) 181.21,40.23 181.7,39.75 183.97,39.75 185.05,38.66 187.8,38.66 v3(188.02,38.89)
  BOTTOM w0.069: v4(196.36,66.01) 196.36,66.39 PU900.5 ; UC6.2 179.16,42.36 179.35,42.17 179.35,41.78 179.71,41.42 RC610.2 RC612.2 180.05,41.04 180.9,41.04 RC664.2 180.91,41 181.14,40.77 v4(181.14,40.23)
CORE_VID1_R: length 2.2
  TOP w0.069: RC689.1 155.09,40.57 v5(154.91,40.57) 154.91,40.56 154.85,40.51 v1(154.32,40.51)
  BOTTOM w0.069: v5(154.91,40.57) 154.94,40.61 155.42,40.61 UC1.CJ38
CPU_B+: length 19.7
  TOP w0.254: v4(92.77,50.49) 92.77,50.69 92.75,50.72 92.75,57.9 91.66,59 88.37,59 88.09,59.28 v5(88.09,59.4)
  BOTTOM w0.254: v5(88.09,59.4) 88.09,59.54 88.45,59.91 90.41,59.91 91.58,61.08 91.58,62.01 92.67,63.1 PR1104.1
  vias: v1(91.76,45.64) v3(94.04,34.61) v3(94.07,44.26) v3(94.58,44.26) v3(94.55,34.61) v3(95.09,44.26) v3(95.06,34.61) v3(96.99,49.34) v3(97.5,49.34) v3(98.01,49.34) v3(98.52,49.34) v3(99.02,49.34) v3(99.53,49.34) v3(100.04,49.34) v4(93.97,34.97) v4(94.25,44.62) v4(94.57,34.96) v4(94.85,44.62) v4(95.09,34.97) v4(95.34,44.65) v4(96.99,49.34) v4(97.5,49.34) v4(98.01,49.34) v4(98.52,49.34) v4(99.02,49.34) v4(99.53,49.34) v4(100.04,49.34) v5(92.47,45.92) v5(92.47,45.28) v5(92.67,42) v5(92.67,41.37) v5(92.67,40.73) v5(92.67,35.96) v5(92.67,35.32) v5(93.21,41.7) v5(93.18,41.06) v5(93.18,40.43) v5(93.23,34.79) v5(93.28,44.29)
CPU_C10_GATE#: length 81.6
  TOP w0.069: UC10.1 143.37,66.24 v3(143.22,66.39)
  IN1 w0.061: v3(185.1,36.35) 184.93,36.35 184.73,36.15 183.77,36.15 183.15,36.77 183.15,37.18 182.83,37.49 182.02,37.49 180.23,39.29 175.65,39.29 175.2,38.83 v4(174.87,38.83)
  IN2 w0.051: v3(185.1,36.35) 185.1,37.11 183.93,38.28 183.93,39.09 183.1,39.93 183.1,40.72 182.16,41.66 181.96,41.66 181.29,42.33 181.29,42.71 179.93,44.07 179.93,45.36 180.4,45.83 180.4,51.08 179.22,52.27 176.58,52.27 175.38,53.47 175.38,57.26 167.6,65.04 167.6,66.25 167.31,66.55 149.61,66.55 149.07,66.01 145.85,66.01 145.47,66.39 v3(143.22,66.39)
  IN3 w0.061: v3(143.22,66.39) 142.75,66.85 142.46,66.85 142.24,67.07 v4(142.24,67.11)
  BOTTOM w0.069: RC226.1 RC631.2 141.92,67.7 142.24,67.38 v4(142.24,67.11) ; RH280.2 174.28,39.44 v1(174.28,39.41) v4(174.87,38.83)
CPU_C10_GATE#_R: length 3.2
  BOTTOM w0.069: UC1.DU40 170.1,40.1 170.35,40.35 170.63,40.35 170.83,40.15 172.63,40.15 RH280.1
CPU_EOPIO_RCOMP: length 2.1
  TOP w0.127: v5(122.53,52.74) 122.53,52.2 v1(122.72,52.01)
  TOP w0.254: RH7.1 122.53,53.32 v5(122.53,52.74)
  BOTTOM w0.254: v5(122.53,52.74) 122.53,52.41 UC1.B14
CPU_POPI_RCOMP: length 2.5
  TOP w0.127: v2(156.04,39.65) 154.99,39.65 v1(154.52,39.18)
  IN1 w0.254: v2(156.04,39.65) 156.01,39.62 v3(156.01,39.3)
  IN3 w0.254: v4(155.72,39.61) 155.72,39.58 v3(156.01,39.3)
CPU_RC_ID: length 9.8
  TOP w0.069: RE530.2 170.22,18.69 170.42,18.89 CE432.1 170.99,18.89 171.09,18.99 172.18,18.99 172.32,19.13 172.32,19.66 172.82,20.16 175.27,20.16 175.68,19.75 176.9,19.75 177.1,19.55 177.1,18.95 177.47,18.59 UE1.F2
CPU_TCP0_HPD: length 1
  IN1 w0.061: v2(161.24,40.41) 161.09,40.26 v3(160.69,40.26)
  IN3 w0.061: v4(160.3,40.26) v3(160.69,40.26)
CPUPWRGD: length 8.7
  BOTTOM w0.069: CC650.1 152.67,63.47 153.1,63.9 153.66,63.9 153.94,63.62 154.75,63.62 155.16,63.21 155.16,61.89 155.33,61.71 v1(155.33,61.69) 155.33,60.9 153.98,59.54 153.98,59.12 154.08,59.01 UC1.CF1
CPVEE: length 1.2
  TOP w0.305: v1(263.41,65.33) 263.87,65.67 CA18.1
CS1: length 37.3
  IN1 w0.254: v3(96.13,65.73) 96.08,65.73 95.85,65.96 93.89,65.96 93.51,66.34 90.79,66.34 88.36,63.9 88.36,62.52 88.99,61.89 90.77,61.89 91.05,61.61 91.05,61.05 91.7,60.4 93.52,60.4 93.9,60.78 94.91,60.78 95.03,60.9 95.75,60.9 v3(96.33,60.32) ; v3(96.99,50.79) 96.99,50.73 96.66,50.39 96.49,50.39 95.92,49.83 95.92,47.64 95.42,47.13 v3(95.42,46.58)
  IN3 w0.254: v4(95.42,46.22) v3(95.42,46.58) ; v3(96.33,60.32) 96.2,60.19 96.2,59.12 95.85,58.77 95.85,57.78 96.91,56.72 96.91,50.87 v3(96.99,50.79) ; v3(96.13,65.73) 96.42,65.44 96.44,65.44 v4(96.84,65.04)
  BOTTOM w0.203: v4(95.42,46.22) 95.34,46.14 PU1201.12
CS2: length 47.7
  IN1 w0.203: v3(96.48,50.82) 96.44,50.79 96.3,50.79 93.38,47.87 arc(93.03,47.34) 92.9,46.71 92.9,45.08 92.39,44.57 92.39,43.27 93.69,41.98 93.69,39.44 95.24,37.89 95.24,36.75 v3(95.49,36.49)
  IN1 w0.254: v3(95.62,65.5) 95.51,65.39 90.61,65.39 88.76,63.54 88.76,62.62 89.13,62.25 91.2,62.25 91.4,62.04 91.4,61.22 91.86,60.75 93.29,60.75 93.67,61.14 94.76,61.14 94.91,61.28 96.1,61.28 v3(96.2,61.38)
  IN3 w0.203: v3(95.49,36.49) 95.34,36.34 v4(95.34,35.81)
  IN3 w0.254: v3(96.48,50.82) 96.55,50.9 96.55,56.57 95.49,57.63 95.49,58.92 95.85,59.27 95.85,61.03 v3(96.2,61.38) ; v3(95.62,65.5) 95.75,65.5 96.08,65.17 v4(96.08,65.04)
CSI_RCOMP: length 9
  BOTTOM w0.076: UC1.B4 122.73,56.52 122.45,56.24 121.72,56.24 121.56,56.41 121.56,57.25 121.58,57.27
  BOTTOM w0.089: UC1.B4 122.52,56.96 121.88,56.96 121.58,57.27
  BOTTOM w0.102: 121.9,57.59 122.4,57.59
  BOTTOM w0.127: UC1.B4 122.73,57.27 122.4,57.59 ; 121.58,57.27 121.9,57.59
  BOTTOM w0.305: RC8.1 119.93,58.91 121.58,57.27
CSSUM: length 13.1
  BOTTOM w0.203: PU1100.8 100.74,62.11 101.32,62.69 101.32,63 102.12,63.8 102.12,67.23 101.69,67.66 v1(97.8,67.66) 97.32,67.66 96.91,67.25 96.89,67.25 96.89,66.82 96.84,66.77 PR1107.1 PR1108.1
CTRL0: length 263.8
  TOP w0.069: UW1.13 v2(265.23,15.42)
  IN1 w0.061: v2(265.23,15.42) 264.73,15.92 262.27,15.92 261.43,15.08 258.3,15.08 255.73,12.51 255.73,12.33 254.53,11.13 251.11,11.13 v3(250.89,11.35)
  IN2 w0.051: v3(250.89,11.35) 249.51,11.35 247.34,9.19 246.64,9.19 245.35,7.89 243.38,7.89 241.99,6.49 228.03,6.49 227.45,5.91 198.97,5.91 198.34,5.28 v3(198.34,5.14)
  IN3 w0.061: v4(25.03,23.9) 25.64,23.9 26.57,22.97 29.86,22.97 33.22,19.62 36.41,19.62 43.99,12.04 75.66,12.04 81.39,17.76 84.94,17.76 86.93,15.77 88.7,15.77 92.85,11.63 100.14,11.63 100.94,12.43 103.36,12.43 107.65,8.14 108.89,8.14 111.38,5.65 114.23,5.65 114.44,5.86 117.27,5.86 117.92,5.2 119.34,5.2 119.99,5.86 127.41,5.86 129.04,7.49 151.35,7.49 152.12,8.26 167.1,8.26 167.69,7.68 172.09,7.68 174.75,5.02 180.25,5.02 181.27,4 188.88,4 189.06,3.82 191.08,3.82 191.58,4.32 191.83,4.32 192.11,4.04 193.37,4.04 193.76,3.66 196.26,3.66 197.21,4.61 197.81,4.61 v3(198.34,5.14)
CTRL0_R: length 7.5
  BOTTOM w0.069: L73.2 25.03,25.12 24.86,25.29 24.86,25.56 24.88,25.59 CW227.2 24.4,26.4 24.4,27.02 DA16.1 24.1,27.7 v1(23.48,28.31) 23.43,28.36 22.95,28.36 22.06,29.25 21.43,29.25 21.24,29.44 JWLA2.1
CTRL1: length 1.5
  TOP w0.069: RW1241.1 264.23,15.58 UW1.15
CTRL1_R: length 295.3
  TOP w0.069: v2(263.92,15.26) 263.73,15.45 263.73,16.03 RW1241.2 264.1,16.4 264.1,17.47 v1(263.89,17.67) 263.89,17.95 264.12,18.18 RW57.1
  IN1 w0.061: v3(245.92,9.58) 246.7,10.36 247.69,10.36 247.81,10.48 256.97,10.48 258.53,12.03 258.53,13.11 258.81,13.4 261.38,13.4 262.68,14.7 263.36,14.7 v2(263.92,15.26) ; v3(178.68,5.4) 178.98,5.4 179.67,6.09 179.67,10.63 179.29,11.02 179.29,12.72 v3(179.26,12.74) ; v2(186.33,18.59) 186.52,18.4 186.52,17.61 186.73,17.4 v3(186.73,16.76)
  IN2 w0.051: v3(179.26,12.74) 179.39,12.62 184.01,12.62 186.17,14.77 186.17,16.19 v3(186.73,16.76)
  IN3 w0.061: v4(23.2,25.72) 23.31,25.82 24.37,25.82 24.86,25.34 26.81,25.34 27.27,25.8 28.23,25.8 29.22,24.81 29.22,24.4 33.76,19.85 36.4,19.85 44.06,12.2 75.59,12.2 81.32,17.92 85.01,17.92 87,15.93 88.77,15.93 92.9,11.8 100.09,11.8 100.88,12.59 103.43,12.59 107.72,8.3 108.95,8.3 111.44,5.81 114.16,5.81 114.37,6.02 127.34,6.02 128.97,7.65 151.28,7.65 152.05,8.43 167.12,8.43 167.4,8.7 168.62,8.7 169.48,7.84 172.16,7.84 173.2,6.8 173.22,6.8 174.84,5.18 178.46,5.18 v3(178.68,5.4) 178.68,5.4 178.9,5.18 180.32,5.18 181.34,4.17 188.95,4.17 189.13,3.99 191.01,3.99 191.51,4.48 191.9,4.48 192.18,4.2 193.44,4.2 193.82,3.82 196.19,3.82 197.14,4.77 197.49,4.77 198.2,5.47 207.3,5.47 207.65,5.83 216.64,5.83 216.86,5.61 225.15,5.61 226.33,6.78 229.01,6.78 230.32,5.47 239.8,5.47 242.87,8.54 243.42,8.54 243.84,8.95 245.29,8.95 v3(245.92,9.58)
  BOTTOM w0.069: v4(23.2,25.72) 23.2,25.82 19.74,29.29 JWLA2.4
CTRL2: length 4.4
  TOP w0.069: L71.1 v2(265.7,14.55)
  IN1 w0.061: v2(262.73,14.39) 264.8,14.39 264.96,14.55 v2(265.7,14.55)
CTRL2_R: length 10.6
  TOP w0.069: L71.2 265.79,16.86 CW226.2 265.94,17.67 DA18.1 266.72,18.25 v5(266.64,18.33) 266.99,18.69 v1(267.6,18.69)
  IN3 w0.061: v5(266.64,18.33) 266.64,18.11 266.46,17.93 266.46,13.3 v4(266.61,13.15)
  BOTTOM w0.069: JWLA1.1 v4(266.61,13.15)
CTRL3: length 1.3
  TOP w0.069: RW1240.1 260.91,11.59 UW1.23
CTRL3_R: length 103
  TOP w0.069: RW1240.2 260.11,11.12 260.47,10.76 RW58.1 259.79,10.17 v3(259.55,9.92) 260.11,9.36 260.11,6.71 257.35,3.95 252.73,3.95 251.59,2.81 236.54,2.81 234.65,4.7 233.42,4.7 232.33,5.8 198.92,5.8 197.84,4.72 197.19,4.72 196.23,5.68 196.23,8.07 197.22,9.06 v2(197.22,9.77) ; UE1.E12 v2(185.91,19.39)
  IN1 w0.061: v3(193.46,13.75) 193.74,13.75 197.22,10.27 v2(197.22,9.77) ; v3(186.63,19.07) 186.22,19.07 185.91,19.38 v2(185.91,19.39)
  IN2 w0.051: v3(259.55,9.92) 259.68,9.92 260.44,10.69 260.97,10.69 262.35,12.06 v3(263.01,12.06) ; v3(193.46,13.75) 193.31,13.75 192.27,14.8 188.64,14.8 187.55,15.89 187.55,16.58 186.82,17.31 186.63,17.5 v3(186.63,19.07)
  IN3 w0.061: v3(263.01,12.06) 263.02,12.06 263.16,11.93 263.16,11.8 v4(263.2,11.75)
  BOTTOM w0.069: v4(263.2,11.75) 263.31,11.65 JWLA1.4 264.88,11.42 264.22,10.76 v1(264.07,10.76)
DAR_INT#: length 99.9
  TOP w0.069: DR3.1 268.75,10.71 269.25,10.2 269.25,8.96 v1(268.54,8.25) 267.63,7.33 264.66,7.33 260.87,3.55 v2(259.42,3.55) ; RW59.2 189.1,14.94 187.68,14.94 v2(187.35,15.27) ; v3(236.72,12.03) 236.72,11.96 236.95,11.74 244.47,11.74 248.67,7.54 v2(250.1,7.54)
  IN1 w0.061: v2(259.42,3.55) 259.14,3.83 258.05,3.83 255.92,5.96 250.99,5.96 250.1,6.85 v2(250.1,7.54) ; v2(185.53,15.39) 185.53,15.97 185.64,16.08 186.14,16.08 186.55,15.66 186.96,15.66 v2(187.35,15.27) v3(187.62,15)
  IN3 w0.061: v3(187.62,15) 188.74,15 192.21,11.53 192.21,11.04 192.57,10.69 193.2,10.69 193.65,10.24 195.57,10.24 196.04,10.7 216.48,10.7 216.87,10.31 221.71,10.31 221.88,10.48 221.88,10.58 222.04,10.74 223.71,10.74 223.94,10.51 223.94,10.13 224.19,9.87 224.52,9.87 225.58,10.94 235.63,10.94 v3(236.72,12.03)
DAT_SMB: length 2.8
  BOTTOM w0.069: PR196.1 38.62,21.51 39.01,21.51 39.19,21.34 39.72,21.34 39.85,21.46 40.24,21.46 40.31,21.39 40.31,20.71 JBATT1.5
DAT_TP_SIO_I2C_CLK: length 3.5
  TOP w0.069: UE1.C12 185.84,20.68 186.66,20.68 187.62,21.64 RE468.2
DBC_EN: length 58
  TOP w0.069: v3(129.05,60.85) 129.22,60.85 130.04,61.66 v1(130.04,61.77) 129.86,61.77 129.45,62.17 129.45,63.39 RH622.1
  IN2 w0.051: v3(129.05,60.85) 129.1,60.85 129.3,61.05 138.54,61.05 138.98,60.62 142.1,60.62 142.25,60.77 147.6,60.77 148.85,59.53 153.2,59.53 153.89,58.84 156.93,58.84 157.73,58.03 163.17,58.03 165.08,56.13 168.15,56.13 168.35,56.33 168.58,56.33 168.62,56.37 169.67,56.37 171.1,54.94 171.1,50.73 170.32,49.95 170.32,49.78 v3(169.51,48.96)
  IN3 w0.061: v4(169.51,48.23) v3(169.51,48.96)
  BOTTOM w0.069: UC1.DW24 170.61,47.31 170.22,47.69 169.61,47.69 169.51,47.8 v4(169.51,48.23)
DBC_EN_R: length 5
  TOP w0.069: TP115.1 129.5,66.51 v4(128.56,65.58) 129.35,64.79 129.35,64.43 RH622.2
  BOTTOM w0.069: JEDP1.40 128.05,66.09 v4(128.56,65.58)
DBG_PMODE: length 97.6
  TOP w0.069: v2(92.65,61.18) 92.62,61.18 92.47,61.03 91.56,61.03 91.21,61.37 R545.2 91.15,61.03 90.72,60.6 90.18,60.6 89.88,60.9 R6143.1 89.74,61.51 89.19,61.51 88.04,60.36 v5(87.69,60.36)
  IN1 w0.061: v2(92.65,61.18) 92.7,61.18 92.73,61.21 v3(93.08,61.21)
  IN2 w0.051: v3(168.42,52.45) 168.24,52.63 168.24,53.23 167.93,53.54 167.37,53.54 167.15,53.31 165.9,53.31 165.52,53.69 162.78,53.69 161.33,55.14 157.19,55.14 155.84,56.48 155.06,56.48 154.32,57.22 148.65,57.22 146.74,55.31 141.82,55.31 140.91,56.23 140.91,57.11 139.6,58.41 129.49,58.41 128.01,59.89 121.58,59.89 119.43,57.73 111.5,57.73 111.1,58.13 106.73,58.13 105.05,59.81 101.32,59.81 100.61,60.52 99.52,60.52 98.73,61.31 97.94,61.31 97.36,60.72 95.8,60.72 95.39,61.13 93.16,61.13 v3(93.08,61.21)
  IN3 w0.061: v4(168.42,52.9) v3(168.42,52.45)
  BOTTOM w0.069: R270.1 87.69,61.82 v5(87.69,60.36) 88.96,60.36 v1(89.55,60.95) ; v4(168.42,52.9) 168.42,52.7 167.93,52.21 167.12,52.21 UC1.DL15
DBG_PMODE_MIPI60_RST#: length 4.7
  TOP w0.069: R545.1 90.84,62.27 90.84,63.03 91.03,63.23 R544.1 91.15,63.47 92.38,64.7 JMIPI60.7
DDR_A_CA0: length 43.1
  IN1 w0.089: v2(158.03,15.57) 157.97,15.88 157.87,16.03 157.81,16.09 157.74,16.25 157.65,16.71 157.65,16.75 157.58,17.16 157.58,18.39 v3(157.65,18.46) 157.4,18.71 157.1,18.71 157.01,18.8 157.01,18.99 157.1,19.08 157.93,19.08 158.03,19.18 v2(158.03,20.12)
  IN3 w0.094: v4(145.33,35.93) 144.89,35.49 144.89,35.29 144.95,35.23 144.95,35.04 145.27,34.71 145.43,34.71 145.51,34.63 145.51,34.47 145.4,34.36 145.17,34.36 145.06,34.25 145.06,34.09 145.17,33.98 145.4,33.98 145.51,33.87 145.51,33.71 145.4,33.6 145.17,33.6 145.06,33.49 145.06,33.34 145.17,33.23 145.4,33.23 145.51,33.12 145.51,32.6 149.43,28.68 149.85,28.68 155.13,23.4 155.13,23.17 155.02,23.06 154.76,23.06 154.67,23.14 154.09,23.14 153.99,23.04 153.99,22.79 154.1,22.68 155.02,22.68 155.13,22.57 155.13,22.41 155.02,22.3 154.28,22.3 154.2,22.22 154.2,22.01 154.28,21.93 155.2,21.93 155.33,22.05 155.51,22.05 155.61,21.96 155.61,21.66 155.5,21.55 154.68,21.55 154.57,21.44 154.57,21.32 154.72,21.18 155.52,21.18 155.62,21.08 155.62,20.89 155.51,20.78 154.87,20.78 154.73,20.63 154.73,20.47 155.03,20.16 155.17,20.16 155.43,20.42 155.59,20.42 155.8,20.21 155.8,20.08 155.54,19.81 155.54,19.66 155.65,19.55 155.8,19.55 156.1,19.84 156.25,19.84 156.37,19.73 156.37,19.58 156.07,19.28 156.07,19.12 156.29,18.91 156.42,18.91 156.49,18.98 156.68,18.98 156.77,19.07 156.77,19.28 156.68,19.37 156.68,19.46 156.86,19.64 156.99,19.64 157.23,19.4 157.23,18.9 157.31,18.83 157.51,18.83 157.58,18.89 157.58,19.15 157.67,19.25 157.99,19.25 158.08,19.15 158.08,18.75 157.79,18.46 v3(157.65,18.46)
DDR_A_CA1: length 42.2
  TOP w0.107: UD1.J2 158.4,19.47 v2(158.42,19.45)
  IN1 w0.089: v2(158.42,19.45) 158.71,19.23 158.94,19.07 159.05,18.96 159.08,18.87 159.08,18.4 v3(158.68,17.32) 158.39,17.32 158.28,17.21 158.28,17.03 158.35,16.96 158.66,16.96 158.72,16.89 158.72,16.77 158.63,16.68 158.39,16.68 158.31,16.6 158.31,16.49 158.36,16.44 158.36,16.23 158.29,16.16 158.1,16.16 v2(158.03,16.22)
  IN3 w0.094: v4(144.09,36.59) 143.74,36.59 143.64,36.49 143.64,36.22 143.74,36.12 144.16,36.12 144.23,36.05 144.23,35.82 144.16,35.76 143.8,35.76 143.71,35.66 143.71,35.49 143.83,35.37 144.15,35.37 144.25,35.27 144.25,34.95 144.32,34.88 144.32,32.72 149.1,27.94 149.54,27.94 149.68,27.8 149.68,27.64 149.61,27.57 149.61,27.42 149.72,27.31 149.88,27.31 149.95,27.38 150.1,27.38 150.21,27.27 150.21,27.11 150.14,27.04 150.14,26.88 150.25,26.77 150.41,26.77 150.48,26.85 150.63,26.85 150.87,26.61 150.87,26.35 151.01,26.21 151.27,26.21 151.4,26.08 151.4,25.81 151.54,25.68 151.8,25.68 151.94,25.54 151.94,25.28 152.07,25.15 152.33,25.15 152.64,24.84 152.64,24.5 152.52,24.37 152.52,24.12 152.64,24 152.64,23.74 152.52,23.62 152.52,23.37 152.64,23.25 152.64,22.75 152.97,22.42 152.97,21.88 153.43,21.41 153.43,21.21 153.43,20.64 153.57,20.5 153.57,20.19 153.69,20.07 154.07,20.07 154.81,19.33 154.81,19.18 154.63,19.01 154.63,18.85 154.74,18.74 154.9,18.74 155.07,18.92 155.23,18.92 155.34,18.81 155.34,18.65 155,18.31 155,18.16 155.12,18.05 155.27,18.05 155.61,18.38 155.76,18.38 155.87,18.27 155.87,18.12 155.51,17.75 155.51,17.6 155.62,17.49 155.77,17.49 156.14,17.85 156.29,17.85 156.38,17.76 156.38,17.45 156.48,17.36 156.79,17.36 157.11,17.04 157.52,17.04 157.62,16.94 157.62,16.51 157.7,16.43 157.93,16.43 158.01,16.51 158.01,16.98 158.11,17.07 158.32,17.07 158.42,16.98 158.42,16.53 158.51,16.44 158.75,16.44 158.85,16.53 158.85,16.84 158.94,16.93 159.19,16.93 159.29,17.02 159.29,17.2 159.02,17.46 158.81,17.46 v3(158.68,17.32)
DDR_A_CA2: length 41.6
  IN1 w0.089: v2(163.63,20.12) 163.63,19.83 163.89,19.57 163.89,19.38 163.7,19.19 163.7,18.22 v3(164.38,17.54) 164.78,17.14 164.78,16.17 164.5,15.9 164.34,15.9 164.28,15.96 163.93,15.96 163.63,15.66 v2(163.63,15.57)
  IN3 w0.094: v3(164.38,17.54) 163.92,17.54 162.96,16.58 161.77,16.58 161.69,16.5 161.69,16.39 161.61,16.31 161.41,16.31 161.32,16.4 161.32,16.49 161.23,16.58 160.73,16.58 160.4,16.25 157.55,16.25 156.69,17.1 155.64,17.1 153.19,19.55 153.19,21.31 152.72,21.78 152.72,22.29 152.34,22.68 152.34,24.53 150.55,26.32 150.36,26.32 144.07,32.6 144.07,34.7 143.43,35.34 143.43,36.58 v4(144.09,37.24)
DDR_A_CA3: length 42.9
  IN1 w0.089: v2(164.43,20.12) 164.51,20.05 164.51,19.94 164.51,19.94 164.51,19.8 164.44,19.72 164.32,19.72 164.19,19.58 164.13,19.58 164.07,19.53 164.07,19.33 164.14,19.27 164.29,19.27 164.38,19.18 164.38,19.02 164.29,18.93 163.93,18.93 163.87,18.87 163.87,18.7 163.96,18.61 164.2,18.61 164.29,18.52 164.29,18.37 v3(164.17,18.25) 164.45,17.98 164.67,17.69 164.91,17.3 164.96,17.18 164.96,16.1 v2(164.43,15.57)
  IN3 w0.094: v3(164.17,18.25) 164.15,18.23 164.09,18.23 162.82,16.96 160.09,16.96 159.29,17.76 159.29,17.95 159.13,18.12 158.51,18.12 158.37,17.98 157.28,17.98 157.19,18.07 157.19,18.68 157.05,18.82 156.87,18.82 156.78,18.73 156.6,18.73 156.47,18.61 156.24,18.61 154.48,20.37 154.48,21.07 153.95,21.6 153.95,22.48 153.71,22.72 153.37,22.72 153.14,22.95 153.14,24.27 153.21,24.34 153.36,24.34 154.29,23.41 154.44,23.41 154.54,23.5 154.54,23.64 149.75,28.43 149.32,28.43 144.81,32.94 144.81,34.91 144.7,35.02 144.7,35.86 145.33,36.49 v4(145.33,36.59)
DDR_A_CA4: length 43.7
  IN1 w0.089: v2(165.23,20.12) 165.16,20.04 165.16,19.94 165.16,19.94 165.16,19.81 165.24,19.72 165.34,19.72 165.45,19.61 165.7,19.61 165.79,19.52 165.79,19.37 165.92,19.24 165.92,19.12 165.82,19.02 165.82,18.88 165.88,18.82 165.92,18.82 165.97,18.77 165.97,18.68 165.91,18.61 165.63,18.61 165.58,18.66 165.46,18.66 165.37,18.57 v3(165.37,18.31) 165.37,18.3 165.68,17.91 165.79,17.55 165.79,16.24 165.77,16.18 165.6,15.94 v2(165.23,15.57)
  IN3 w0.094: v4(145.33,37.24) 145,37.24 144.87,37.1 144.87,36.85 144.99,36.73 144.99,36.53 144.47,36 144.47,35 144.57,34.9 144.57,32.83 149.21,28.18 149.64,28.18 153.11,24.72 153.11,24.59 152.89,24.37 152.89,22.85 153.22,22.52 153.22,21.98 153.42,21.78 153.6,21.78 153.68,21.7 153.68,21.24 153.77,21.15 154.05,21.15 154.23,20.96 154.23,20.26 156.47,18.02 156.76,18.02 157.15,17.63 157.15,17.3 157.24,17.22 157.48,17.22 157.56,17.3 157.56,17.63 157.66,17.72 158.37,17.72 158.59,17.94 159.04,17.94 159.11,17.86 159.11,17.68 159.6,17.19 159.6,16.62 159.7,16.53 159.87,16.53 160.11,16.77 162.89,16.77 164.05,17.93 164.51,17.93 164.68,17.75 164.88,17.75 165.04,17.92 165.04,18.27 165.12,18.34 165.34,18.34 v3(165.37,18.31)
DDR_A_CA5: length 39.3
  IN1 w0.089: v2(165.23,19.47) 165.16,19.4 165.16,19.1 165.13,19.07 164.99,18.93 164.99,18.69 165.04,18.64 165.04,18.07 v3(165.34,17.77) 165.61,17.5 165.61,16.31 165.52,16.22 v2(165.23,16.22)
  IN3 w0.094: v4(142.83,35.28) 143.23,35.28 143.83,34.69 143.83,32.5 150.26,26.07 150.45,26.07 152.06,24.46 152.06,22.61 152.48,22.19 152.48,20.31 152.89,19.9 152.89,19.5 156.3,16.09 156.83,15.84 156.88,15.84 157.05,15.79 157.25,15.59 157.59,15.48 158.92,15.48 159.12,15.54 159.41,15.54 159.8,15.69 160.64,15.92 162.38,15.92 162.59,15.96 162.89,16.15 163.21,16.25 163.45,16.25 163.78,16.2 164.15,16.2 164.29,16.24 164.71,16.66 164.73,16.71 164.85,16.98 164.88,17.06 164.88,17.17 164.93,17.38 165.08,17.57 v3(165.34,17.77)
DDR_A_CKE0: length 34.4
  IN1 w0.089: v2(159.63,19.47) 159.66,19.5 159.84,19.5 159.87,19.48 159.97,19.33 159.96,19.2 159.86,19.09 159.86,18.94 159.95,18.85 160.1,18.85 160.22,18.96 160.34,18.96 160.51,18.79 160.65,18.48 160.65,18.43 v3(160.47,18.25) 160.22,18.1 160.08,17.96 160.02,17.87 159.98,17.74 159.92,16.96 159.86,16.71 v2(159.63,16.22)
  IN3 w0.094: v4(145.33,35.28) 145.33,35.61 145.4,35.68 145.61,35.68 145.76,35.53 145.76,34.36 145.63,34.24 145.63,34.09 145.76,33.97 145.76,33.6 145.63,33.48 145.63,33.35 145.76,33.22 145.76,32.71 149.54,28.92 149.95,28.92 155.37,23.5 155.37,22.44 155.49,22.32 155.74,22.32 155.85,22.21 155.85,21.56 155.74,21.45 155.74,21.31 155.87,21.18 155.87,21.13 155.98,21.01 155.98,20.88 155.84,20.74 155.84,20.6 155.97,20.47 156.06,20.47 156.26,20.67 156.36,20.67 156.52,20.51 156.52,20.41 156.34,20.23 156.34,20.1 156.57,19.87 156.7,19.87 156.86,20.03 156.86,20.2 156.95,20.3 157.08,20.3 157.26,20.12 157.26,20 157.13,19.88 157.13,19.76 157.45,19.45 157.75,19.45 158.01,19.71 158.14,19.71 158.24,19.61 158.24,19.44 158.34,19.35 158.63,19.35 158.67,19.31 158.81,19.31 158.95,19.45 159.06,19.45 159.18,19.32 159.18,19.16 158.91,18.89 158.91,18.76 159.06,18.61 159.21,18.61 159.5,18.9 159.62,18.9 159.75,18.76 160.54,18.76 160.67,18.64 160.67,18.44 v3(160.47,18.25)
DDR_A_CKE1: length 37.6
  IN1 w0.089: v2(160.43,16.22) 160.43,16.29 161.63,17.49 ; v3(161.4,18.39) 161.4,18.71 161.67,18.98 161.67,19.57 161.43,19.81 160.76,19.81 160.43,19.48 v2(160.43,19.47)
  IN1 w0.094: v3(161.4,18.39) 161.63,18.16 161.63,17.49
  IN3 w0.094: v3(161.4,18.39) 161.7,18.09 161.7,17.64 161.79,17.55 162.71,17.55 163.31,18.15 163.31,18.53 162.62,19.22 162.27,19.37 162.23,19.39 161.94,19.68 161.94,20.31 161.11,21.14 160.63,21.14 160.54,21.24 160.54,21.53 160.47,21.68 160.08,22.06 159.89,22.06 159.4,22.55 159.25,22.55 159.08,22.39 158.93,22.39 158.82,22.5 158.82,22.65 158.98,22.82 158.98,22.97 158.52,23.44 157.21,23.44 157.06,23.59 157.06,24.01 150.57,30.51 150.14,30.51 149.1,31.54 149.1,32.24 146.98,34.36 146.98,35.07 147.14,35.23 147.14,36.55 146.81,36.88 146.06,36.88 145.96,36.79 v4(145.96,36.26)
DDR_A_CLK: length 37.5
  IN1 w0.097: v2(162.83,16.22) 163.04,16.22 163.13,16.31 163.13,16.44 162.75,16.82 162.69,16.82 162.29,17.23 162.29,17.77 162.27,17.79 v3(162.12,17.94) 162.29,18.12 162.29,18.79 162.51,19.01 162.91,19.01 163.11,19.21 163.11,19.35 162.99,19.47 v2(162.83,19.47)
  IN3 w0.097: v4(146.59,36.59) 146.31,36.31 146.31,35.78 146.5,35.6 146.5,33.18 146.7,32.99 147,32.99 147.11,33.09 147.24,33.09 147.41,32.92 147.41,32.76 147.26,32.61 147.26,32.28 147.49,32.05 147.82,32.05 147.97,32.2 148.13,32.2 148.35,31.98 148.35,31.2 149.76,29.79 150.15,29.79 156.12,23.81 156.12,23.07 156.34,22.85 156.52,22.85 156.64,22.73 156.64,22.59 156.43,22.38 156.43,21.99 156.67,21.75 157.07,21.75 157.14,21.67 157.14,21.63 157.33,21.44 157.83,21.44 158.05,21.65 158.05,21.81 158.13,21.89 158.67,21.89 158.77,21.79 158.77,21.54 159.15,21.17 159.15,21.08 158.76,20.69 158.76,20.38 159.04,20.1 159.34,20.1 159.62,20.38 159.76,20.38 159.9,20.23 159.9,20.08 159.61,19.79 159.61,19.49 159.92,19.19 160.48,19.19 160.69,19.4 160.69,19.63 161.13,20.07 161.29,20.07 161.43,19.93 161.43,19.03 161.67,18.79 162.18,18.79 162.29,18.68 162.29,18.12 v3(162.12,17.94)
DDR_A_CLK#: length 37.6
  IN1 w0.097: v2(163.63,19.47) 163.42,19.47 163.32,19.37 163.32,19.13 163,18.81 162.6,18.81 162.5,18.7 162.5,18.08 v3(162.62,17.95) 162.49,17.82 162.49,17.31 162.78,17.02 162.83,17.02 163.33,16.52 163.33,16.31 163.42,16.22 v2(163.63,16.22)
  IN3 w0.097: v4(146.59,35.93) 146.59,36.16 146.66,36.23 146.85,36.23 146.93,36.15 146.93,35.84 146.71,35.61 146.71,33.27 146.78,33.19 146.92,33.19 147.03,33.3 147.32,33.3 147.61,33.01 147.61,32.68 147.46,32.53 147.46,32.37 147.58,32.25 147.74,32.25 147.89,32.4 148.22,32.4 148.55,32.07 148.55,31.28 149.85,29.99 150.23,29.99 156.33,23.89 156.33,23.15 156.42,23.06 156.6,23.06 156.85,22.81 156.85,22.51 156.63,22.29 156.63,22.07 156.75,21.95 157.15,21.95 157.34,21.76 157.34,21.71 157.42,21.64 157.75,21.64 157.85,21.74 157.85,21.89 158.05,22.09 158.76,22.09 158.97,21.88 158.97,21.63 159.35,21.25 159.35,20.99 158.96,20.6 158.96,20.47 159.12,20.31 159.26,20.31 159.53,20.58 159.84,20.58 160.11,20.32 160.11,20 159.82,19.71 159.82,19.57 160,19.39 160.39,19.39 160.49,19.49 160.49,19.71 161.05,20.27 161.37,20.27 161.63,20.01 161.63,19.12 161.75,18.99 162.27,18.99 162.5,18.76 162.5,18.08 v3(162.62,17.95)
DDR_A_CS#0: length 40.7
  IN1 w0.089: v2(159.63,15.57) 160.17,16.11 160.17,16.35 160.27,16.46 160.27,16.63 160.17,16.74 160.17,16.89 160.26,16.99 160.38,16.99 160.55,16.82 160.64,16.82 160.79,16.97 160.79,17.06 160.6,17.24 160.6,17.35 v3(160.8,17.55) 160.83,17.69 160.83,18.52 160.66,18.9 160.1,19.46 v2(159.63,20.12)
  IN3 w0.094: v4(147.24,40.91) 147.11,41.04 146.67,41.04 146.52,41.19 146.29,41.19 146.19,41.09 146.19,40.89 146.37,40.7 146.37,39.29 146.6,39.06 146.6,38.76 146.33,38.48 146.33,37.37 146.19,37.23 145.81,37.23 145.66,37.08 145.66,35.91 146,35.56 146,32.83 149.66,29.17 150.05,29.17 155.62,23.6 155.62,22.79 156.11,22.29 156.11,21.87 156.27,21.72 156.27,21.53 156.12,21.38 156.12,21.25 156.22,21.15 156.45,21.15 156.55,21.06 156.55,20.88 156.55,20.83 156.75,20.62 156.89,20.62 157.07,20.8 157.24,20.8 157.33,20.71 157.33,20.43 157.54,20.21 157.82,20.21 157.97,20.36 158.18,20.36 158.28,20.26 158.58,20.26 158.76,20.09 158.76,19.9 158.91,19.74 159.1,19.74 159.85,19 160.82,19 161.05,18.76 161.05,18.36 160.82,18.13 160.82,17.96 160.93,17.85 160.93,17.68 v3(160.8,17.55)
DDR_A_CS#1: length 40.5
  IN1 w0.089: v2(158.83,15.57) 158.83,15.85 158.58,16.11 158.58,16.35 158.9,16.67 158.9,17.04 159.46,17.6 v3(159.46,18.38) 159.32,18.52 159.32,19.34 159.04,19.61 159.04,19.83 159.32,20.1 159.32,20.48 159.2,20.6 159.02,20.6 158.83,20.41 v2(158.83,20.12)
  IN3 w0.094: v4(147.24,38.96) 146.75,38.4 146.62,38.1 146.62,38 146.73,37.68 147,37.3 147.33,36.59 147.33,35.17 147.16,34.99 147.16,34.53 149.35,32.34 149.35,32.07 156.96,24.46 158.56,23.73 158.85,23.58 159.21,23.22 159.49,23.05 159.9,22.8 160.04,22.8 160.2,22.75 160.36,22.58 160.36,22.29 160.84,21.55 160.95,21.45 161.05,21.41 161.28,21.34 162.17,20.45 162.17,19.8 162.33,19.64 162.45,19.58 162.75,19.43 163.54,18.64 163.54,18.04 162.72,17.21 160.55,17.21 160.41,17.28 160.11,17.49 160.01,17.6 v3(159.46,18.38)
DDR_A_D0_0: length 42.8
  IN1 w0.094: v3(159.91,12.5) 159.73,12.32 v2(159.63,12.32)
  IN3 w0.094: v4(152.03,35.96) 152.15,35.96 153.85,34.26 155.08,34.26 158.84,30.49 161.31,30.49 164.18,27.62 165.15,27.62 169.09,23.69 169.09,13.72 167.68,12.31 166.22,12.31 166.19,12.28 160.13,12.28 v3(159.91,12.5)
  BOTTOM w0.107: v4(152.03,35.96) 151.62,35.96 UC1.CA48
DDR_A_D0_1: length 45.3
  IN3 w0.094: v4(151.6,36.59) 151.91,36.59 153.32,35.18 154.09,35.18 154.65,34.62 155.06,34.62 158.94,30.74 161.41,30.74 164.28,27.87 165.26,27.87 169.34,23.79 169.34,13.62 167.78,12.07 166.22,12.07 166.19,12.03 159.57,12.03 159.31,12.28 158.67,12.28 158.62,12.33 158.04,12.33 v3(158.03,12.32)
DDR_A_D0_2: length 40.3
  IN3 w0.094: v3(159.63,13.62) 160.43,13.62 160.69,13.88 162.18,13.88 162.19,13.87 162.54,13.87 162.85,13.56 164.05,13.56 164.61,14.11 165.19,14.11 165.65,14.57 166.54,14.57 167.82,15.86 167.82,16.58 167.71,16.69 167.42,16.69 167.31,16.8 167.31,16.95 167.42,17.06 167.71,17.06 167.82,17.17 167.82,17.33 167.71,17.44 167.42,17.44 167.31,17.55 167.31,17.7 167.42,17.81 167.71,17.81 167.82,17.92 167.82,18.08 167.71,18.19 167.42,18.19 167.31,18.3 167.31,18.46 167.42,18.57 167.71,18.57 167.82,18.68 167.82,21.41 167.31,21.92 167.31,23.76 164.66,26.41 163.2,26.41 160.36,29.24 158.38,29.24 154.18,33.45 153.85,33.45 152.19,35.1 151.78,35.1 v4(151.6,35.28)
DDR_A_D0_3: length 41
  TOP w0.107: UD1.U2 v3(157.62,14.56)
  IN3 w0.094: v3(157.62,14.56) 157.81,14.76 158.88,14.76 159.09,14.55 159.37,14.55 159.9,15.08 160.18,15.08 160.31,15.21 161.3,15.21 161.41,15.32 161.41,15.39 161.52,15.5 161.67,15.5 161.78,15.39 161.78,15.32 161.89,15.21 163.06,15.21 163.74,15.89 164.81,15.89 165.02,16.1 165.02,16.26 164.94,16.34 164.94,16.49 165.05,16.6 165.2,16.6 165.28,16.52 165.44,16.52 166.03,17.11 166.03,17.92 166.26,18.15 166.26,18.48 166.03,18.71 166.03,19.42 165.92,19.53 165.3,19.53 165.18,19.65 165.18,20.55 165.4,20.77 165.78,20.77 166.03,21.02 166.03,22.2 165.95,22.28 165.52,22.28 165.45,22.34 165.45,22.58 165.54,22.66 165.92,22.66 166.03,22.77 166.03,23.99 164.35,25.67 162.89,25.67 160.06,28.51 158.08,28.51 153.82,32.76 153.69,32.76 152.26,34.2 151.66,34.2 150.61,35.25 150.61,35.4 150.53,35.48 v4(150.53,35.56)
  BOTTOM w0.089: UC1.BV49 150.34,35.37 v4(150.53,35.56)
DDR_A_D0_4: length 45
  IN3 w0.094: v3(159.63,11.67) 159.73,11.77 160.24,11.77 160.67,11.34 161.22,11.34 161.66,11.78 166.32,11.78 166.36,11.82 167.88,11.82 169.58,13.52 169.58,23.89 165.36,28.11 164.38,28.11 161.51,30.98 159.05,30.98 155.23,34.8 154.72,34.8 154.16,35.36 153.42,35.36 151.6,37.18 v4(151.6,37.24)
DDR_A_D0_5: length 43.2
  IN3 w0.094: v4(150.34,36.59) 150.34,36.53 150.98,35.89 150.98,35.41 151.82,34.58 152.45,34.58 153.83,33.2 154.08,33.2 158.28,29 160.26,29 163.1,26.16 164.56,26.16 167.06,23.66 167.06,21.11 167.17,21 167.46,21 167.57,20.89 167.57,20.74 167.46,20.63 167.17,20.63 167.06,20.52 167.06,20.36 167.17,20.25 167.46,20.25 167.57,20.14 167.57,19.98 167.46,19.87 167.17,19.87 167.06,19.76 167.06,19.61 167.17,19.5 167.46,19.5 167.57,19.39 167.57,19.23 167.46,19.12 167.17,19.12 167.06,19.01 167.06,15.78 166.56,15.28 166.26,15.28 165.73,14.75 165.57,14.75 165.14,14.32 164.1,14.32 163.83,14.32 163.7,14.2 163.44,14.2 163.4,14.24 163.12,14.24 163.08,14.2 162.87,14.2 162.52,14.55 161.63,14.55 161.23,14.14 160.62,14.14 160.34,13.86 159.88,13.86 159.42,14.32 159.07,14.32 158.37,13.62 v3(158.03,13.62)
DDR_A_D0_6: length 49.2
  IN3 w0.094: v3(158.03,11.67) 158.62,11.09 161.4,11.09 161.71,11.4 162.55,11.4 162.95,10.99 166.13,10.99 166.69,11.55 167.96,11.55 169.83,13.42 169.83,23.99 165.46,28.36 164.49,28.36 161.62,31.23 159.15,31.23 155.4,34.98 154.8,34.98 154.21,35.57 153.48,35.57 152.06,37 152.06,37.13 151.69,37.5 150.94,37.5 v4(150.67,37.24)
  BOTTOM w0.107: UC1.BV45 v4(150.67,37.23)
DDR_A_D0_7: length 41.7
  IN1 w0.094: v2(159.63,14.27) 159.96,14.27 159.98,14.25 v3(159.98,14.24)
  IN3 w0.094: v3(159.98,14.24) 160.08,14.14 160.34,14.14 160.49,14.29 160.49,14.47 160.36,14.6 160.36,14.91 160.45,15 161.07,15 161.18,14.89 161.18,14.84 161.29,14.73 161.45,14.73 161.56,14.84 161.56,14.89 161.67,15 161.82,15 161.93,14.89 161.93,14.84 162.04,14.73 162.2,14.73 162.31,14.84 162.31,14.89 162.42,15 163.11,15 163.43,15.33 163.57,15.33 163.85,15.04 163.85,14.74 163.96,14.63 164.12,14.63 164.23,14.74 164.23,14.94 164.32,15.03 164.74,15.03 164.78,14.99 165.08,14.99 165.21,15.12 165.21,15.49 165.02,15.67 165.02,15.81 165.21,16 165.37,16 165.73,15.64 165.89,15.64 166,15.75 166,15.9 165.64,16.26 165.64,16.42 165.8,16.58 166.59,16.58 166.82,16.81 166.82,21.05 166.74,21.13 166.33,21.13 166.25,21.2 166.25,21.34 166.34,21.43 166.72,21.43 166.82,21.53 166.82,23.56 164.45,25.92 162.99,25.92 160.16,28.75 158.18,28.75 153.99,32.94 153.82,32.94 152.37,34.39 151.74,34.39 150.8,35.33 150.8,35.64 150.51,35.93 v4(150.34,35.93)
DDR_A_D1_0: length 37.8
  IN1 w0.094: v3(152.28,38.77) 152.28,38.69 151.88,38.29 151.88,36.63 151.93,36.58 151.93,34.85 158.09,28.69 159.58,28.69 162.47,25.81 165.44,25.81 167.29,23.96 167.29,14.88 166.73,14.32 165.72,14.32 165.43,14.02 165.13,14.02 165.01,14.14 164.71,14.14 164.44,13.87 164.31,13.87 164.06,13.62 v2(163.63,13.62)
  IN3 w0.094: v3(152.28,38.77) v4(152.73,38.96)
DDR_A_D1_1: length 39.6
  IN1 w0.094: v3(152.28,40.63) 152.28,40.54 151.95,40.21 151.95,38.62 151.62,38.3 151.62,36.62 151.69,36.56 151.69,34.74 157.98,28.45 159.47,28.45 159.76,28.16 159.76,28.01 159.65,27.89 159.65,27.74 159.76,27.63 159.91,27.63 160.03,27.74 160.18,27.74 160.29,27.63 160.29,27.47 160.18,27.36 160.18,27.2 160.29,27.09 160.44,27.09 160.56,27.21 160.71,27.21 160.82,27.1 160.82,26.94 160.71,26.83 160.71,26.67 160.82,26.56 160.98,26.56 161.09,26.68 161.24,26.68 161.36,26.57 161.36,26.41 161.24,26.3 161.24,26.14 161.35,26.03 161.51,26.03 161.62,26.14 161.78,26.14 162.36,25.56 165.34,25.56 167.04,23.86 167.04,15.08 166.54,14.57 165.53,14.57 v2(165.23,14.27)
  IN3 w0.094: v4(152.73,40.26) v3(152.28,40.63)
DDR_A_D1_2: length 37
  IN1 w0.094: v3(152.24,38.18) 152.09,38.03 152.09,36.69 152.18,36.6 152.18,34.95 158.18,28.95 159.7,28.95 162.6,26.05 165.55,26.05 167.54,24.06 167.54,21.41 167.65,21.3 167.71,21.3 167.82,21.19 167.82,21.04 167.71,20.93 167.65,20.93 167.54,20.82 167.54,20.66 167.65,20.55 167.71,20.55 167.82,20.44 167.82,20.28 167.71,20.17 167.65,20.17 167.54,20.06 167.54,19.91 167.65,19.8 167.71,19.8 167.82,19.69 167.82,19.53 167.71,19.42 167.65,19.42 167.54,19.31 167.54,19.16 167.65,19.05 167.71,19.05 167.82,18.94 167.82,18.78 167.71,18.67 167.65,18.67 167.54,18.56 167.54,14.77 166.83,14.06 165.8,14.06 165.36,13.62 v2(165.23,13.62)
  IN3 w0.094: v4(152.73,38.31) 152.42,38.34 v3(152.24,38.18)
DDR_A_D1_3: length 42.5
  IN1 w0.094: v2(165.23,11.67) 167.36,11.67 169.52,13.82 169.52,21.31 169.56,21.36 169.56,24.44 166.25,27.75 163.73,27.75 160.68,30.8 159.23,30.8 154.04,35.99 154.04,36.75 153.97,36.82 153.97,38.43 153.77,38.63 153.77,40.79 v3(153.19,41.37)
  IN3 w0.094: v3(153.19,41.37) v4(153.64,40.91)
DDR_A_D1_4: length 40.9
  TOP w0.086: UD1.U9 163.97,14.61 165.37,14.61 165.55,14.79 165.55,14.8 v2(165.64,14.89)
  IN1 w0.094: v2(165.64,14.89) 166.03,15.28 166.51,15.28 166.79,15.56 166.79,23.04 164.51,25.31 162.37,25.31 162.29,25.24 162.29,24.42 162.21,24.34 161.99,24.34 161.92,24.42 161.92,25.31 161.81,25.42 161.41,25.42 160.04,26.79 158.75,28.08 158,28.08 151.44,34.64 151.44,36.43 151.41,36.47 151.41,38.35 151.76,38.7 151.76,40.29 151.89,40.42 151.89,40.99 v3(152.28,41.37)
  IN3 w0.094: v3(152.28,41.37) v4(152.73,40.91)
DDR_A_D1_5: length 43
  IN1 w0.094: v3(153.18,40.63) 153.45,40.36 153.55,40.27 153.55,38.55 153.79,38.31 153.79,35.89 159.13,30.55 160.58,30.55 163.63,27.5 166.15,27.5 169.31,24.34 169.31,21.46 169.27,21.41 169.27,13.93 167.62,12.27 167.13,12.27 166.74,11.88 165.77,11.88 165.71,11.94 164.01,11.94 v2(163.63,12.32)
  IN3 w0.094: v3(153.18,40.63) v4(153.64,40.26)
DDR_A_D1_6: length 39
  IN1 w0.094: v3(153.18,38.77) 153.34,38.61 153.34,38.42 153.58,38.18 153.58,37.89 153.4,37.71 153.4,35.92 159.03,30.3 160.48,30.3 163.52,27.26 166.05,27.26 169.07,24.24 169.07,21.62 169.02,21.58 169.02,14.03 167.51,12.52 167.03,12.52 167.01,12.5 167.01,12.5 166.58,12.07 165.89,12.07 165.64,12.32 165.46,12.32 165.45,12.32 v2(165.23,12.32)
  IN3 w0.094: v3(153.18,38.77) v4(153.64,38.96)
DDR_A_D1_7: length 41.6
  IN1 w0.094: v3(154.36,38.11) 154.36,36.01 159.33,31.04 160.79,31.04 163.83,28 166.35,28 169.81,24.54 169.81,21.26 169.76,21.22 169.76,13.72 167.44,11.4 166.51,11.4 165.98,10.86 164.96,10.86 164.48,11.35 163.96,11.35 v2(163.63,11.67)
  IN3 w0.094: v3(154.36,38.11) 153.84,38.11 v4(153.64,38.31)
DDR_A_D2_0: length 20.5
  IN3 w0.094: v3(163.63,23.37) 163.17,23.37 162.8,23.74 162.8,24.22 159.61,27.42 157.63,27.42 151.71,33.34 151.14,33.34 150.26,34.21 150.26,34.55 149.56,35.24 149.3,35.24 149.1,35.44 v4(149.1,35.93)
DDR_A_D2_1: length 22.6
  IN3 w0.094: v3(165.23,23.37) 165.21,23.4 164.67,23.4 164.47,23.6 164.47,24.47 164.32,24.61 163.93,24.61 163.47,25.07 162.65,25.07 159.81,27.91 157.83,27.91 152.03,33.71 151.29,33.71 150.71,34.29 150.71,34.62 149.72,35.61 149.72,36.16 149.3,36.59 v4(149.1,36.59)
DDR_A_D2_2: length 19.7
  IN1 w0.094: v2(163.63,24.02) 163.44,24.22 163.44,24.28 v3(163.43,24.28)
  IN3 w0.094: v3(163.43,24.28) 163.09,24.28 159.71,27.66 157.73,27.66 151.87,33.52 151.21,33.52 150.49,34.25 150.49,34.57 149.5,35.56 v4(149.4,35.56)
  BOTTOM w0.089: UC1.BT49 149.37,35.56 v4(149.4,35.56)
DDR_A_D2_3: length 25.1
  IN3 w0.094: v3(165.23,22.07) 164.58,22.07 164.43,21.93 164.43,21.39 164.12,21.07 162.35,21.07 161.68,21.73 161.68,22.37 160.24,23.82 159.78,23.82 159.45,24.15 159.45,24.55 159.3,24.71 158.69,24.71 158.15,25.24 157.38,25.24 150.99,31.63 150.72,31.63 148.17,34.18 148.17,34.88 147.99,35.06 147.99,35.13 v4(147.83,35.28)
DDR_A_D2_4: length 22.2
  IN3 w0.094: v3(165.23,24.02) 165.23,24.3 164.21,25.32 162.75,25.32 159.91,28.16 157.93,28.16 152.08,34.01 151.58,34.01 150.42,35.18 150.42,35.27 149.92,35.77 149.92,36.41 v4(149.1,37.24)
DDR_A_D2_5: length 23
  IN3 w0.094: v3(163.63,22.07) 163.59,22.12 163.01,22.12 162.55,22.57 162.24,22.57 161.28,23.54 161.28,24.15 160.82,24.6 160.71,24.6 159.47,25.85 157.47,25.85 151.12,32.2 150.75,32.2 148.65,34.3 148.65,34.92 148.38,35.19 148.38,35.36 148.09,35.65 148.09,36.08 147.83,36.34 v4(147.83,36.59)
DDR_A_D2_6: length 27.2
  IN3 w0.094: v4(147.83,37.24) 147.56,36.96 147.56,35.14 147.4,34.98 147.4,34.65 150.66,31.39 150.88,31.39 157.31,24.96 157.98,24.96 159.45,23.49 160.19,23.49 161.43,22.24 161.43,21.56 162.16,20.83 163.78,20.83 163.79,20.83 164.07,20.83 164.07,20.83 164.49,20.83 164.55,20.77 164.91,20.77 165.23,21.09 v3(165.23,21.42)
DDR_A_D2_7: length 22.9
  IN3 w0.094: v4(147.83,35.93) 147.83,35.65 148.2,35.29 148.2,35.12 148.43,34.89 148.43,34.23 150.68,31.98 150.99,31.98 157.37,25.6 159.22,25.6 160.36,24.45 160.36,24.07 161.99,22.45 161.99,22.06 162.2,21.85 162.61,21.85 163.04,21.42 v3(163.63,21.42)
DDR_A_D3_0: length 21.5
  IN1 w0.094: v2(158.05,23.39) 157.6,23.39 157.22,23.76 156.69,23.76 156.57,23.88 156.57,24.08 156.68,24.19 156.98,24.19 157.09,24.3 157.09,24.45 156.98,24.56 156.68,24.56 156.57,24.67 156.57,25.92 148.68,33.81 148.68,36.38 148.91,36.61 148.91,37.95 149.53,38.58 v3(149.53,38.77)
  IN3 w0.094: v3(149.53,38.77) v4(149.98,38.96)
DDR_A_D3_1: length 23.5
  IN1 w0.094: v3(149.72,40) 149.39,40 149.19,39.79 149.19,39.68 149.17,39.66 149.17,38.56 148.72,38.11 148.72,36.7 148.43,36.41 148.43,33.71 156.17,25.97 156.17,23.13 156.98,22.32 157.34,22.32 157.54,22.13 157.54,22.12 157.58,22.07 v2(158.03,22.07)
  IN3 w0.094: v4(149.98,40.26) v3(149.72,40)
DDR_A_D3_2: length 21
  IN1 w0.094: v2(158.03,24.02) 158.11,24.1 158.11,24.43 158.04,24.5 157.84,24.5 157.76,24.41 157.76,24.17 157.69,24.1 157.5,24.1 157.4,24.2 157.4,24.68 157.7,24.98 157.7,25.13 157.57,25.26 157.42,25.26 157.1,24.94 156.94,24.94 156.83,25.05 156.83,25.21 157.15,25.53 157.15,25.68 148.93,33.91 148.93,36.17 149.19,36.44 149.19,37.73 149.41,37.94 v3(149.52,37.94)
  IN3 w0.094: v3(149.52,37.94) 149.56,38.08 v4(149.98,38.31)
DDR_A_D3_3: length 27.4
  IN1 w0.094: v2(159.63,21.42) 159.78,21.28 161.15,21.28 161.66,21.79 161.66,24.64 158.56,27.74 157.85,27.74 151.09,34.5 151.09,36.52 151.2,36.63 151.2,38.38 151,38.59 151,40.7 v3(150.47,41.22)
  IN3 w0.094: v4(150.9,40.91) 150.58,41.22 v3(150.47,41.22)
DDR_A_D3_4: length 24.9
  IN1 w0.094: v2(158.03,21.42) 158.03,21.6 157.81,21.82 157.13,21.82 155.92,23.03 155.92,25.87 148.18,33.61 148.18,36.64 148.53,36.99 148.53,38.2 148.98,38.65 148.98,39.95 149.37,40.33 149.75,40.33 149.98,40.56 v4(149.98,40.91)
DDR_A_D3_5: length 25.9
  IN1 w0.094: v2(159.63,22.07) 160.08,22.07 160.33,21.82 160.61,21.82 161.41,22.62 161.41,24.54 158.46,27.49 157.75,27.49 150.85,34.39 150.85,36.6 151.01,36.77 151.01,38.3 150.81,38.51 150.81,40.27 v3(150.45,40.63)
  IN3 w0.094: v3(150.45,40.63) v4(150.9,40.26)
DDR_A_D3_6: length 21.9
  IN1 w0.094: v3(150.45,38.77) 150.45,38.55 150.82,38.17 150.82,36.97 150.6,36.76 150.6,34.29 160.23,24.66 160.81,24.66 161.13,24.34 161.13,24.07 160.75,23.69 159.95,23.69 v2(159.63,23.37)
  IN3 w0.094: v3(150.45,38.77) v4(150.9,38.96)
DDR_A_D3_7: length 18.5
  IN1 w0.094: v2(159.63,24.02) 159.63,24.91 150.35,34.19 150.35,36.9 150.63,37.18 150.63,37.9 v3(150.49,38.04)
  IN3 w0.094: v3(150.49,38.04) v4(150.9,38.31)
DDR_A_DQS0: length 46.7
  TOP w0.099: v2(158.56,13.23) 158.58,13.23 UD1.W3
  IN1 w0.097: v2(158.56,13.23) 158.59,13.23 v3(158.87,12.95)
  IN3 w0.097: v3(158.87,12.95) 158.92,13 165.4,13 165.61,13.21 165.61,13.97 165.71,14.07 166.02,14.07 166.11,13.97 166.11,13.28 166.39,13 167.65,13 168.57,13.91 168.57,14.5 168.12,14.95 168.12,15.14 168.57,15.59 168.57,22.43 168.27,22.73 168.27,22.91 168.57,23.21 168.57,23.5 164.95,27.12 163.49,27.12 163.37,27.24 163.37,27.72 162.27,28.82 161.79,28.82 161.52,29.09 161.52,29.57 161.1,29.99 158.63,29.99 154.65,33.98 153.87,33.98 152.28,35.57 152.06,35.57 151.48,36.16 151.48,36.33 150.97,36.84 v4(150.97,36.91)
DDR_A_DQS1: length 40.2
  IN1 w0.097: v2(164.43,12.97) 164.52,13.06 165.51,13.06 165.7,13.24 166.23,13.24 166.38,13.1 167.38,13.1 168.52,14.24 168.52,21.74 168.57,21.78 168.57,24.03 165.84,26.76 162.97,26.76 160.02,29.7 158.42,29.7 152.9,35.23 152.9,36.47 152.53,36.84 152.53,37.68 152.81,37.96 152.81,39.42 152.9,39.52 v3(153.18,39.52)
  IN3 w0.097: v4(153.64,39.61) v3(153.18,39.52)
DDR_A_DQS2: length 23.1
  IN1 w0.097: v3(164.15,23) 164.43,22.72 v2(164.43,22.72)
  IN3 w0.097: v3(164.15,23) 163.51,23 163.48,23.04 163.14,23.04 162.64,23.54 162.27,23.54 162.02,23.79 162.02,24.3 159.75,26.56 157.77,26.56 151.38,32.95 151.02,32.95 149.95,34.03 149.95,34.53 149.45,35.03 149.18,35.03 148.83,35.37 148.83,36.39 148.47,36.76 v4(148.47,36.91)
DDR_A_DQS3: length 22.7
  TOP w0.099: v2(159.22,22.62) 158.84,22.72 UD1.D3
  IN1 w0.097: v2(159.22,22.62) 159.07,22.78 159.07,22.9 159.35,23.17 159.35,23.56 159.16,23.76 158.72,23.76 158.54,23.94 158.54,24.8 158.43,24.9 158.43,25.4 149.85,33.98 149.85,37.49 150.1,37.73 150.1,38.98 149.94,39.14 149.94,39.4 150.06,39.52 v3(150.45,39.52)
  IN3 w0.097: v4(150.9,39.61) v3(150.45,39.52)
DDR_A_DQS#0: length 46.8
  TOP w0.099: v2(159.17,13.3) 159.16,13.3 UD1.V3
  IN1 w0.097: v2(159.17,13.3) 159.14,13.3 v3(158.87,13.58)
  IN3 w0.097: v4(150.82,36.56) 150.96,36.56 151.28,36.24 151.28,36.07 151.98,35.37 152.19,35.37 153.79,33.77 154.56,33.77 158.55,29.79 161.02,29.79 161.31,29.49 161.31,29.01 161.7,28.62 162.19,28.62 163.17,27.64 163.17,27.16 163.41,26.92 164.86,26.92 168.37,23.41 168.37,23.29 168.07,22.99 168.07,22.65 168.37,22.35 168.37,15.67 167.92,15.23 167.92,14.86 168.37,14.42 168.37,14 167.57,13.2 166.48,13.2 166.32,13.36 166.32,14.06 166.1,14.27 165.62,14.27 165.41,14.06 165.41,13.3 165.31,13.2 159.13,13.2 159.04,13.29 159.04,13.48 158.95,13.58 v3(158.87,13.58)
  BOTTOM w0.099: UC1.BY47 150.97,36.41 v4(150.82,36.56)
DDR_A_DQS#1: length 40.1
  IN1 w0.097: v2(164.43,13.62) 164.43,13.4 164.57,13.26 165.43,13.26 165.62,13.45 166.32,13.45 166.46,13.3 167.3,13.3 168.32,14.32 168.32,21.82 168.36,21.87 168.36,23.95 165.75,26.55 162.88,26.55 159.94,29.5 158.34,29.5 152.69,35.14 152.69,36.39 152.33,36.75 152.33,37.77 152.61,38.04 152.61,39.47 152.56,39.52 v3(152.28,39.52)
  IN3 w0.097: v3(152.28,39.52) v4(152.73,39.61)
DDR_A_DQS#2: length 23
  IN1 w0.097: v2(164.43,22.07) 164.42,22.07 v3(164.12,22.37)
  IN3 w0.097: v4(148.47,36.26) 148.63,36.1 148.63,35.29 149.09,34.83 149.36,34.83 149.75,34.44 149.75,33.94 150.94,32.75 151.29,32.75 157.69,26.36 159.67,26.36 161.81,24.22 161.81,23.71 162.18,23.33 162.55,23.33 163.05,22.83 163.4,22.83 163.43,22.8 163.87,22.8 164.12,22.55 v3(164.12,22.37)
DDR_A_DQS#3: length 22.8
  TOP w0.099: v2(159.14,22.26) 159.12,22.2 UD1.E3
  IN1 w0.097: v2(159.14,22.26) 159.13,22.26 158.87,22.52 158.87,22.98 159.14,23.26 159.14,23.48 159.07,23.55 158.64,23.55 158.33,23.86 158.33,24.72 158.23,24.82 158.23,25.32 149.65,33.9 149.65,37.57 149.9,37.82 149.9,38.9 149.74,39.06 149.74,39.3 v3(149.53,39.52)
  IN3 w0.097: v3(149.53,39.52) v4(149.98,39.61)
DDR_A_ODTA: length 4.3
  TOP w0.069: UD1.G2 157.78,20.77 157.44,20.44 157.11,20.44 155.76,19.09 RD26.1 RD25.1
DDR_A_ODTB: length 3.8
  TOP w0.069: RD28.1 RD27.1 155.7,15.5 155.97,15.23 157.47,15.23 157.78,14.92 UD1.T2
DDR_B_CA0: length 42.3
  IN1 w0.094: v3(146.79,40.01) 147.03,39.71 147.25,39.3 147.32,38.96 147.32,37.89 147.26,37.82 147.26,33.34 154.49,26.1 154.49,18.62 153.42,17.55 152.56,17.55 152.39,17.39 149.91,17.39 149.29,16.76 147.37,16.76 147.21,16.92 145.01,17.44 144.64,17.56 144.37,17.66 144.2,17.83 v3(144.11,18.22)
  IN3 w0.094: v3(146.79,40.01) v4(147.24,40.26) ; v3(144.44,20.12) 144.12,20.12 143.6,19.6 143.6,18.83 143.8,18.62 143.99,18.62 144.11,18.5 v3(144.11,18.22) 143.98,17.54 143.98,17.05 144.06,16.48 144.06,16.22 144.23,15.83 v3(144.44,15.57)
DDR_B_CA1: length 40.3
  IN1 w0.094: v3(145.05,17.87) 145.35,17.57 146.2,17.57 146.31,17.68 146.31,18.22 146.51,18.42 146.67,18.42 147.17,17.92 147.17,17.65 147.68,17.15 149.15,17.15 149.76,17.75 149.91,17.75 150.3,18.14 150.39,18.23 151.47,18.23 151.6,18.1 152.03,18.1 152.29,18.36 152.29,19.18 152.4,19.29 152.66,19.29 152.77,19.4 152.77,19.55 152.66,19.66 152.4,19.66 152.29,19.77 152.29,19.93 152.4,20.04 152.66,20.04 152.77,20.15 152.77,20.3 152.66,20.41 152.4,20.41 152.29,20.52 152.29,20.68 152.4,20.79 152.59,20.79 152.7,20.9 152.7,26.49 149.73,29.47 149.58,29.47 148.87,28.76 148.71,28.76 146.26,31.21 146.26,32.54 145.78,33.01 145.78,36.31 145.94,36.47 145.94,36.94 146.19,37.19 146.19,38.33 v3(145.84,38.67)
  IN3 w0.094: v3(144.44,16.22) 144.44,16.75 144.76,17.06 v3(145.05,17.87) 145.05,17.95 144.44,18.56 v3(144.44,19.47) ; v3(145.84,38.67) v4(146.32,38.96)
DDR_B_CA2: length 39.7
  IN1 w0.094: v3(149.72,18.08) 149.67,18.08 148.42,19.32 148.42,19.83 148.64,20.05 148.9,20.05 149.05,20.2 149.62,20.2 149.69,20.26 149.69,20.56 149.59,20.66 149.36,20.66 149.28,20.74 149.28,21.98 149.15,22.11 149.11,22.11 149.01,22.2 149.01,22.7 149.12,22.81 149.59,22.81 149.68,22.9 149.68,24.14 150.11,24.57 150.39,24.57 150.5,24.68 150.5,24.84 150.44,24.9 150.44,25.05 150.66,25.27 150.81,25.27 150.94,25.14 151.1,25.14 151.21,25.25 151.21,25.45 151.66,25.9 152.13,25.9 152.21,25.98 152.21,26.29 151.53,26.97 151.37,26.97 150.67,26.26 150.51,26.26 150.04,26.74 150.04,26.89 150.77,27.62 150.77,27.73 150.61,27.89 150.5,27.89 149.77,27.16 149.62,27.16 149.15,27.63 149.15,27.78 149.85,28.49 149.85,28.65 149.74,28.76 149.59,28.76 148.88,28.05 148.72,28.05 145.76,31.01 145.76,32.33 145.29,32.81 145.29,36.72 145.44,36.87 145.44,37.67 145.06,38.05 v3(145.06,38.3)
  IN3 w0.094: v4(145.41,38.31) 145.07,38.31 v3(145.06,38.3) ; v3(150.05,20.12) 150.34,20.12 150.5,19.95 150.5,19.21 150.07,18.78 150.07,18.43 v3(149.72,18.08) 149.83,17.48 150.17,16.67 150.35,16.37 150.37,16.26 150.37,16.13 150.36,16.02 150.31,15.96 v3(150.05,15.57)
DDR_B_CA3: length 42.3
  IN1 w0.094: v3(146.79,39.36) 146.79,38.59 146.62,38.42 146.62,37.3 146.75,37.18 146.75,36.94 146.66,36.85 146.53,36.85 146.43,36.75 146.43,36.6 146.53,36.51 146.67,36.51 146.75,36.43 146.75,36.17 146.64,36.06 146.49,36.06 146.38,35.95 146.38,35.79 146.49,35.68 146.64,35.68 146.75,35.57 146.75,33.15 146.91,32.98 146.91,32.82 146.75,32.66 146.75,32.14 146.82,32.07 147.03,32.07 147.13,31.97 147.13,31.85 147.02,31.74 146.82,31.74 146.75,31.68 146.75,31.42 147.26,30.9 147.42,30.9 148.12,31.61 148.27,31.61 148.38,31.49 148.38,31.34 147.68,30.64 147.68,30.48 148.16,30.01 148.31,30.01 149.02,30.72 149.18,30.72 149.29,30.61 149.29,30.45 148.57,29.73 148.57,29.6 148.7,29.46 148.84,29.46 149.56,30.18 149.71,30.18 153.63,26.27 153.63,26.17 153.52,26.07 153.28,26.07 153.2,25.98 153.2,25.8 153.28,25.72 153.89,25.72 154,25.61 154,25.45 153.89,25.34 153.31,25.34 153.2,25.23 153.2,25.07 153.31,24.96 153.89,24.96 154,24.85 154,24.7 153.89,24.59 153.31,24.59 153.2,24.48 153.2,18.91 152.87,18.59 152.87,18.38 152.43,17.94 152.43,17.7 152.34,17.6 151.3,17.6 v3(151.18,17.72)
  IN3 w0.094: v3(150.85,15.57) 150.86,15.59 150.86,16.66 151.32,17.11 151.39,17.18 151.39,17.52 v3(151.18,17.72) 151.06,18.09 150.95,18.32 150.85,19.04 v3(150.85,20.12) ; v3(146.79,39.36) v4(147.24,39.61)

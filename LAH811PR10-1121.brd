# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N52693170: length 4.8
  BOTTOM w0.203: PR1108.2 95.8,65.78 95.47,65.45 95.47,64.48 95.82,64.13 PR1110.2 96.1,64.1 96.1,63.87 96.41,63.57 97.25,63.57 97.5,63.31 PU1100.2
N52693178: length 4.2
  BOTTOM w0.203: PR1107.2 96.99,65.78 97.35,65.42 97.35,64.51 97.12,64.28 96.99,64.28 PR1116.2 97.04,63.92 97.52,63.92 97.9,63.55 PU1100.3
N52751344: length 2.4
  BOTTOM w0.203: PC510.1 197.89,62.61 PU500.8
  BOTTOM w0.254: PC510.1 197.38,62.32 PR503.2
N52752447: length 13.1
  IN3 w0.254: v4(192.23,56.11) 192.23,56.75 196.53,61.05 196.53,62.86 196.28,63.11 196.28,64.64 197.01,65.37 v4(197.93,65.37)
  BOTTOM w0.254: v4(197.93,65.37) 198.42,65.85 PR501.1
N52755459: length 2.1
  BOTTOM w0.254: PU900.8 195.91,65.14 PC911.1 PR912.2
N52755987: length 2.6
  BOTTOM w0.254: PR907.1 189.96,68.78 191.64,68.78 PU900.14
N52759880: length 2.3
  BOTTOM w0.203: PU900.18 192.43,70.32 PC900.1 PR900.2
N52765760: length 0.6
  BOTTOM w0.069: 104.53,28.52 104.53,28.08 v1(104.62,28)
N52768180: length 3.8
  BOTTOM w0.069: PR1202.2 96.18,48 96.66,48.48 v1(97.19,48.48)
  BOTTOM w0.203: PR1202.2 PC1219.1 96.14,46.89 PU1201.14
N52827933: length 0.7
  IN1 w0.061: v2(26.84,55.78) v3(26.47,55.78)
  IN3 w0.061: v3(26.47,55.78) 26.72,55.78 v4(26.79,55.7)
N52924590:
  vias: v1(201.69,48.48) v5(202.15,48.84) v5(202.15,48.2)
N52924674: length 6.7
  IN3 w0.254: v4(205.33,44.25) 205.33,44.84 204.92,45.26 v4(200.75,45.26)
  BOTTOM w0.254: v4(200.75,45.26) 200.83,45.17 PU800.8
N52928923: length 1.4
  BOTTOM w0.069: v1(190.62,51) 190.83,51.21 PC512.1
N52929663: length 0.8
  TOP w0.069: v1(205.59,41.66) 205.45,41.8 204.89,41.8
N52929949: length 1.1
  BOTTOM w0.508: PC912.1 187.28,70.42 187.28,70.13
N52995203: length 3.1
  TOP w0.069: PQ600.2 103.34,3.31 PR603.2 102.99,2.96 PR604.1 v1(101.08,2.96)
N53135832: length 1.2
  BOTTOM w0.508: CC176.1 175.14,46.55 174.75,46.55 174.48,46.82 RC589.2
N53169467: length 2.2
  TOP w0.254: PR602.2 113.33,3.38 PC600.1 112.96,2.56 112.69,2.83 PU600.7
N53193542: length 52.2
  IN3 w0.203: v4(40.76,23.26) 41.09,23.26 47.46,16.88 72.96,16.88 75.71,19.63 v4(75.71,20.39)
  BOTTOM w0.203: v4(40.76,23.26) 39.16,23.26 37.35,25.06 v1(36.55,25.06) 36.29,25.06 35.5,24.27 35.5,21.39 33.75,19.64 PR222.1
  BOTTOM w0.254: 75.23,19.91 v4(75.71,20.39)
N53201443:
  vias: v1(31.21,15.69)
N53201562: length 1.9
  TOP w0.127: v1(28.16,16.3) 28.16,15.23 v2(28.18,15.21)
  IN1 w0.203: v2(28.18,15.21) 28.18,15.92 v4(28.23,15.96)
N53201602: length 2.5
  BOTTOM w0.069: PR401.2 24.63,17.26 v1(24.35,17.54)
  BOTTOM w0.203: PR401.2 25.24,16.98 25.73,16.49 PU400.11
N53201659: length 3.2
  BOTTOM w0.069: v1(24.35,18.84) 24.63,19.12 PC405.1
  BOTTOM w0.203: PR406.2 25.85,18.18 25.24,18.79 PC405.1
  BOTTOM w0.254: PR406.2 26.81,18.18 PR407.1
N53201824: length 2.5
  BOTTOM w0.203: PU400.3 28.23,12.57 28.75,12.05 PC414.1 28.88,11.35 PR408.2
N53201840: length 5.3
  IN3 w0.203: v4(27.4,16.71) 26.8,17.3 v4(26.8,19.74)
  BOTTOM w0.127: v4(26.8,19.74) 26.34,19.74 v1(25.84,20.24)
  BOTTOM w0.203: v4(27.4,16.71) 27.23,16.54 PU400.14
N53201891: length 2.8
  TOP w0.069: v1(20.63,18.03) PR410.2
  TOP w0.508: PR410.2 20.88,19.37 PC415.1
N53202040:
  vias: v1(240.2,5.76) v4(250.69,6.06) v4(250.79,5.78) v4(251.02,6.06) v4(251.07,5.76) v4(251.07,5.43) v4(251.07,5.15) v4(251.07,4.87) v4(264.1,8.2) v4(264.28,7.92) v4(264.45,8.2) v4(264.61,7.92) v4(264.78,8.2) v4(264.99,7.92) v4(265.19,8.2)
N53202160: length 2.5
  BOTTOM w0.254: PR412.2 273.39,18.03 273.2,18.22 PU401.16
N53202194: length 3.5
  TOP w0.254: v5(274.31,22.22) 274.31,22.04 274.38,21.96 PR413.2
  BOTTOM w0.254: PU401.11 273.27,20.72 273.47,20.92 273.47,21.53 274.08,22.14 274.23,22.14 v5(274.31,22.22)
N53202247: length 1.5
  TOP w0.069: PR418.2 273.67,19.63 PR419.1 273.72,19.58 PC421.1
N53202418: length 3.8
  BOTTOM w0.069: PR420.2 266.99,19.03 266.99,19.6 v1(266.87,19.73)
  BOTTOM w0.254: PU401.3 268.55,18.22 PC430.1 267.56,18.46 PR420.2
N53202436: length 2.2
  BOTTOM w0.254: PR423.1 274.11,18.13 273.62,18.61 273.62,18.92 273.31,19.22 PU401.14
N53202478: length 1.3
  TOP w0.069: PC431.1 v1(271.1,18.28)
N53355134: length 2.1
  BOTTOM w0.203: PU1100.16 99.1,57.47 PR1123.1
N53373804: length 2.3
  BOTTOM w0.069: QM1.3 178.22,53.44 RC616.2 177.95,52.79 QM1.2
N53375471: length 1
  BOTTOM w0.069: RC627.1 180.99,44.06 180.82,44.23 UC9.4
N53408431: length 1.5
  TOP w0.203: U31.10 184.39,48.4 C1467.1
N53408470: length 1.5
  TOP w0.203: U31.12 183.59,48.49 C217.1
N53659927: length 2.1
  TOP w0.069: RD23.2 114.8,24.71 UD4.A5
N54122777: length 2
  TOP w0.069: UC8.4 180.38,49.33 180.38,50.08 v1(180.48,50.18) 180.86,50.18 RC623.1
N54819198: length 1.8
  BOTTOM w0.152: URT1.A12 30.62,58.4 30.76,58.54 30.76,59.16 30.56,59.36 30.56,59.72 RT101.2
N54819372: length 1.7
  BOTTOM w0.069: RT102.2 271.18,56.15 270.5,55.47 URT2.A12
N55030338: length 0.9
  IN1 w0.061: v2(267.3,51.97) v3(267.06,52.2)
  IN3 w0.061: v4(266.67,52.61) 266.67,52.6 v3(267.06,52.2)
N55957128: length 4.7
  BOTTOM w0.069: v1(261.73,64.01) 261.96,63.77 RA28.2
  BOTTOM w0.254: RA28.2 RA9.2 260.9,63.01 RA30.1 CA48.1 CA13.1 259.17,63.06 CA14.1
N55957255: length 3
  BOTTOM w0.069: v1(263.25,63.39) 262.29,62.43 RA28.1 CA47.1 261.91,61.74 RA27.2
N55957257: length 2.5
  BOTTOM w0.069: RA27.1 RA8.2 261.91,60.47 CA46.1 262.9,60.52 v1(263.04,60.38)
N55962826: length 2.2
  TOP w0.203: CA15.1 259.55,65.96 260.01,65.5 UA1.32
N55978423: length 4.6
  TOP w0.069: v1(257.37,66.62) 257.37,65.96 CA17.2
  TOP w0.203: CA17.2 257.6,65.42 257.39,65.22 257.01,65.22 256.81,65.02 256.81,63.65 257.21,63.24 UA1.38
N55978441: length 3.2
  TOP w0.254: RA10.2 256.17,64.76 v2(256.25,64.69)
  IN1 w0.254: v2(257.66,62.84) 257.66,63.28 v2(256.25,64.69)
N56357496: length 2.5
  TOP w0.069: UA1.1 258.41,58.11 258.15,57.85 257.57,57.85 RA63.2
N56357525: length 2.3
  TOP w0.203: RA64.1 258.78,66.23 258.78,66.23 v1(259.58,65.43) 259.61,65.4 UA1.33
N56877756: length 1.7
  BOTTOM w0.069: RM12.1 280.22,54.19 UM2.11
N56877758: length 1.8
  BOTTOM w0.069: UM2.15 278.62,54.44 RM11.1
N57277748: length 4
  BOTTOM w0.069: RC624.1 179.39,43.29 179.24,43.44 178.27,43.44 177.89,43.06 177.89,42.3 177.3,41.71 UC6.4
N57457324: length 3
  BOTTOM w0.203: PC1103.2 97.91,64.84 PR1117.2 97.88,64.69 98.26,64.31 98.26,63.95 98.27,63.94 v1(98.27,63.87) 98.3,63.85 PU1100.4
N57485049: length 1.6
  BOTTOM w0.203: PR1204.2 94.59,37.11 94.94,36.76 PU1200.11
N57485111: length 1.6
  BOTTOM w0.203: PU1201.11 94.94,45.82 95.04,45.92 95.04,46.25 94.51,46.77 PR1205.2
N57581670:
  vias: v1(199.7,42.66)
N57612688: length 2.5
  BOTTOM w0.203: PU900.15 191.88,69.17
  BOTTOM w0.254: PR908.1 190.46,69.28 191.77,69.28 191.88,69.17
N57652232: length 4.5
  TOP w0.069: PR103.2 104.43,9.14 PR100.1 104.36,8.6 PR104.2 104.5,8.45 v5(103.61,7.56)
  BOTTOM w0.069: PQ100.5 v5(103.61,7.56) v1(103.61,6.8)
N57652736: length 3.2
  TOP w0.069: PR102.1 102.83,7.69 v5(102.96,7.56)
  BOTTOM w0.069: v1(102.27,7.56) v5(102.96,7.56) PQ100.6
N57652767: length 3.9
  BOTTOM w0.069: v1(105.45,10.99) PR101.2 104.43,10.99
  BOTTOM w0.254: 104.43,10.99 104.43,10.69 104.26,10.51 PQ100.3 104.26,9.56 103.98,9.27 103.79,9.27 103.61,9.45 PQ100.2
N57792379: length 7
  TOP w0.279: JMIPI60.12 93.38,72.73 93.1,73.01
  TOP w0.508: R114.2 R113.2 91.49,74.83 91.76,74.57 v5(91.83,74.57) 91.89,74.52 91.89,74.22 93.1,73.01
  BOTTOM w0.381: C100.1 90.96,75.18 91.09,75.05 v1(91.56,75.05) 91.83,74.77 v5(91.83,74.57)
N58351095: length 1.9
  TOP w0.069: RE193.2 RE428.2 154.75,6.8 154.51,6.56 JDEBUG2.8
N58555606: length 1.2
  BOTTOM w0.069: R623.1 115.91,68.39 v1(116.47,67.84)
N58555679: length 1
  BOTTOM w0.203: QV20.1 111.22,67.76 111.04,67.94 R628.2
N58555687: length 1
  BOTTOM w0.203: QV20.2 112.44,67.98 112.47,68.01 R622.1
N58555721: length 1
  BOTTOM w0.203: R652.2 111.92,67.32 111.92,67.48 QV20.3
N58555838: length 1.2
  BOTTOM w0.203: R627.2 109.74,69.31 110.33,69.89 QV18.1
N58555842: length 1.8
  BOTTOM w0.069: QV18.2 109.79,71.06 v1(109.79,71.59)
  BOTTOM w0.254: R621.1 109.66,70.31 QV18.2
N59045842: length 3.2
  BOTTOM w0.069: v1(158.54,28.41) 157.89,29.07 QE15.3 158.56,29.64 RE477.2 RE219.1
N59045862: length 3.4
  BOTTOM w0.069: v1(160.36,28.41) 159.77,29.01 QE16.2 159.6,29.7 159.36,29.94 159.36,29.96 159.22,30.09 159.22,30.74 RE219.2
N59074234: length 3.6
  TOP w0.254: RE479.2 183.77,8.46 184.86,8.46 CE109.1 186.12,8.25 UE6.7
N59074258: length 2.7
  TOP w0.254: UE6.3 186.62,5.56 186.4,5.78 185.43,5.78 185.22,5.58 RE478.2
N59074292: length 39.4
  TOP w0.069: v2(194.58,8.02) 194.43,8.02 193.97,7.56 193.97,7.37 192.55,5.95 192.55,3.9 192.08,3.43 191.11,3.43 190.84,3.17 189.4,3.17 188.27,4.29 RE480.1 188.21,4.99 187.12,6.08 UE6.5
  IN1 w0.061: v3(198.42,7.82) 198.29,7.94 194.66,7.94 v2(194.58,8.02)
  IN3 w0.061: v3(198.42,7.82) 198.47,7.76 198.94,7.76 v4(199.32,7.38)
  BOTTOM w0.069: QE19.2 207.61,17.64 207.59,17.66 206.13,17.66 205.38,16.91 204.47,16.91 202.83,15.27 202.83,11.61 201.91,10.69 201.91,9.25 202.58,8.58 202.58,7.76 202.46,7.65 202.24,7.65 202.02,7.43 202.02,6.49 201.4,5.87 199.63,5.87 199.32,6.18 v1(199.32,6.7) v4(199.32,7.38)
N59591541: length 4.9
  BOTTOM w0.069: v1(265.98,1.29) 267.37,1.29 268.24,2.15 C237.1 266.92,2.43 266.82,2.52 U34.6
N59636611: length 5.9
  BOTTOM w0.254: R5769.2 200.61,21.75 199.95,21.75 D116.1 199.05,22.62 R5779.1 C1131.1 199.01,23.6 R2745.1 199.05,24.36 Q349.2
N59636658: length 6.3
  BOTTOM w0.254: R5768.2 200.06,23.23 200.85,22.45 v1(200.95,22.45) 201.49,21.91 202.27,21.91 202.53,21.66 202.53,19.35 Q348.1
N60434250: length 0.6
  TOP w0.069: RC734.2 CC659.1
N62320917: length 2.5
  TOP w0.069: v1(179.08,3.85) 179.77,4.54
  TOP w0.254: CS95.1 179.77,4.54 179.02,5.29 US1.6
N62322923: length 3.3
  BOTTOM w0.069: CT362.1 25.35,46.89 v5(25.24,46.78) 25.16,46.78 24.8,47.14 UT1.6
N62323625: length 2.5
  TOP w0.069: v1(255.35,46.92) 255.61,47.19 CT210.1 256.39,47.2 UT2.6
N62327553: length 1.6
  BOTTOM w0.254: UC24.6 193.46,38.05 C4189.1
N62327555: length 3.4
  TOP w0.069: v1(273.88,40.96) 273.11,40.96 272.89,41.19 C234.1 273.27,41.6 273.27,42.61 273.12,42.76 UC25.6
N62327559: length 3
  BOTTOM w0.069: C4205.1 31.59,3.7 v1(30.82,4.46)
  BOTTOM w0.203: C4205.1 31.32,2.97 UC28.6
N64510614: length 1.5
  BOTTOM w0.069: C4213.1 225.78,18.16 U60.6
N65197718: length 3
  BOTTOM w0.069: v1(253.35,54.58) 253.35,54.7 C245.1
  BOTTOM w0.254: C245.1 254.22,55.31 254.87,54.66 U36.6
N65755618: length 4.4
  TOP w0.069: C227.1 124.39,1.69 123.92,2.16 123.14,2.16 v1(122.63,1.66)
  TOP w0.254: C227.1 124.85,2.08 124.85,2.86 124.61,3.11 UC30.6
N66651145: length 4.2
  TOP w0.069: RW45.2 RW39.1 260.69,16.32 260.57,16.45 260.57,16.96 260.5,17.02 QW2.3 259.49,17.44 259.25,17.44 v1(258.74,17.95)
N67742614: length 0.6
  BOTTOM w0.069: C453.1 R648.1
N67754895: length 3.4
  TOP w0.069: UE1.K1 175.78,15.39 175.6,15.56 173.57,15.56 TP148.1
N73050981: length 2.9
  BOTTOM w0.069: QZ20.1 219.11,13.94 R789.1 218.15,12.97 v1(217.13,12.97)
N73527472: length 16.5
  TOP w0.069: v2(176.59,8.73) 176.59,8.46 176.54,8.41 RS381.1
  IN1 w0.061: v2(176.59,8.73) 176.75,8.88 v3(176.75,9.21)
  IN3 w0.061: v3(176.75,9.21) v4(176.75,9.97)
  BOTTOM w0.069: v4(176.75,9.97) 177.48,10.71 177.48,19.7 178.93,21.15 181.28,21.15
N73528232: length 6.4
  IN1 w0.061: v4(180.51,6.16) 180.79,6.44 v2(180.79,6.8)
  BOTTOM w0.069: JNGFF1.8 180.61,9.65 179.85,8.88 179.85,5.94 v1(179.97,5.81) 180.25,5.81 180.51,6.06 v4(180.51,6.16)
N73529044: length 6.3
  BOTTOM w0.069: JNGFF1.68 180.23,24.65 178.63,26.26 178.63,27.32 178.02,27.93 RS382.1
N73529838: length 4
  BOTTOM w0.069: JNGFF1.69 189.64,24.9 190.08,25.34 190.97,25.34 191.52,24.8 RS384.2 RS383.2
N73573884: length 1.8
  TOP w0.069: UA3.19 274.53,32.25 275.07,32.78 RA82.2
N73644088: length 2.7
  TOP w0.069: CA88.1 v1(22.04,26.36)
  TOP w0.203: UA2.4 23.78,25.51 23.08,26.21 CA88.1
N73644091: length 2.5
  TOP w0.069: v1(24.8,27.4) 24.86,27.35 CA89.1
  TOP w0.203: CA89.1 24.98,26.24 UA2.1
N73645628: length 1.3
  TOP w0.069: 20.64,25.75 20.64,25.93 v1(19.83,26.74)
N73649539: length 1.1
  TOP w0.069: v1(268.21,29.74) 268.21,29.89 268.16,29.94 268.16,30.4 CA95.1
N73649541:
  vias: v1(268.97,33.98)
N73649585: length 1.2
  TOP w0.069: CA106.1 271.67,35.88 271.26,36.29 v1(271.24,36.29)
N73649611: length 3.9
  TOP w0.254: CA98.1 269.3,28.14 v1(269.84,28.67) 270.24,28.67 270.45,28.87 UA3.7
  TOP w0.508: CA107.1 268.31,28.14 CA98.1
N73656820: length 1.2
  TOP w0.069: UA3.17 274.17,31.45 TP156.1
N73656823: length 1.8
  TOP w0.069: UA3.18 275.17,31.85 TP157.1
N73656826: length 2.7
  TOP w0.069: UA3.20 273.14,33.34 273.35,33.55 273.78,33.55 v1(274.19,33.96) 274.73,33.96 RA80.2
N73656829: length 2.7
  TOP w0.069: TP153.1 24.1,18.89 UA2.17
N73656832: length 1.2
  TOP w0.069: TP154.1 24.5,20.11 UA2.18
N73656835: length 3.3
  TOP w0.069: RA79.2 v1(25.79,18.43)
  TOP w0.254: UA2.20 25.79,21.52 RA79.2
N73928341: length 1.3
  BOTTOM w0.069: U713.6 210.66,8.48 210.63,8.5 C4236.1
N74028108: length 3.4
  TOP w0.069: v1(175.22,51.76) 175.22,53 175.25,53.03 ; 175.25,53.03 QC2.5 ; 175.25,53.03 175.57,53.03 RC147.1 175.55,53.38 QC2.6
N74740396: length 2.5
  TOP w0.069: RA84.1 264.05,57.8 264.05,59.12 263.93,59.24 UA1.13
N75620288: length 5.6
  TOP w0.069: UE1.M4 178.82,13.48 178.82,12.86 178.86,12.83 178.86,12.21 177.71,11.07 177.71,9.29 TP147.1
N77061749: length 4.5
  TOP w0.508: R6225.1 R6226.1 5.27,42 4.71,42.56 4.71,43.83 v5(4.8,43.92)
  BOTTOM w0.508: v5(4.8,43.92) 5.17,44.29 5.88,44.29 5.88,44.29 RTCD3.2
N77098291: length 25.6
  TOP w0.069: R6227.2 233.34,1.26 231.38,1.26 230.9,1.74 v1(230.9,2.25) 229.96,3.19 213.78,3.19 212.96,2.37 210.82,2.37 210.45,1.99 ULID1.2
N78164634: length 8.9
  TOP w0.508: v2(266.59,16.73) 266.52,16.66 CW223.1
  IN3 w0.508: v3(266.94,16.73) 267.09,16.58 267.09,12.85 v4(266.9,12.65)
  BOTTOM w0.069: v1(264.02,13.94) 264.02,13.15 264.52,12.65 JWLA1.2
  BOTTOM w0.305: JWLA1.2 v4(266.9,12.65)
N78166986: length 8.5
  BOTTOM w0.069: v1(20.97,31.23) 20.74,31 JWLA2.2
  BOTTOM w0.254: L74.2 24.14,25.27 23.99,25.42 CW225.1 23.88,25.91 23.48,26.31 23.48,27.41 22.1,28.8 21.35,28.8 20.74,29.41 JWLA2.2
N78422576: length 18.9
  IN1 w0.061: v3(258.26,10.77) 258.26,10.64 257.93,10.31 247.98,10.31 247.65,9.98 v4(246.98,9.98)
  IN3 w0.061: v3(258.26,10.77) 258.38,10.89 258.38,11.88 259.07,12.57 260.92,12.57 262.22,11.27 v4(262.36,11.27)
  BOTTOM w0.069: UWL1.67 262.63,11.01 v4(262.36,11.27) ; v4(246.98,9.98) 246.77,9.98 246.7,10.05 DR13.2
N78816294: length 6.1
  BOTTOM w0.069: DR2.2 249.47,10.74 250.03,11.3 v1(250.28,11.3) 250.28,11.44 250.97,12.13 250.97,15.11 251.37,15.51 UWL1.19
N78816296: length 6.8
  BOTTOM w0.069: UWL1.18 251.32,15.01 251.14,14.83 251.14,12.03 250.71,11.6 250.71,10.25 v1(250.36,9.9) 249.39,9.9 DR1.2
N79011622: length 4.3
  BOTTOM w0.069: R271.2 195.47,20.06 197.32,20.06 197.47,20.21 197.85,20.21 198.08,19.98 Q3.1 198.08,19.48 v1(198.73,18.83)
N79012834: length 2.2
  BOTTOM w0.069: RT225.1 261.74,56.05 262.62,56.05 262.83,56.26 QT2.2
N79027926: length 5.9
  BOTTOM w0.069: D132.1 71.34,6.2 R38.1 69.65,5.53 68.47,5.53 67.95,6.05 JFAN1.3 v4(67.95,8.04)
N79028066: length 4.1
  BOTTOM w0.069: D12.1 v4(233.64,6.14) 234.2,6.14 R41.1 234.61,6.85 234.15,7.31 JFAN2.3
N79087328: length 0.7
  TOP w0.069: RT228.1 24.91,58.06 24.92,58.07 24.92,58.16 QT1.2
N79266901: length 6.5
  BOTTOM w0.069: RD48.2 218.33,14.51 218.43,14.61 219.24,14.61 219.86,15.23 219.87,15.23 v1(220.36,15.71) 220.08,15.99 220.08,17.47 219.86,17.69 ; QE26.5 220.2,18.02 219.86,17.69 ; 219.86,17.69 219.55,18 QE26.6
N79266909: length 34.8
  IN3 w0.061: v4(220.85,19.96) 220.44,20.36 218.16,20.36 206.84,31.68 206.84,35.93 205.62,37.16 205.62,39.5 v4(202.76,42.36)
  BOTTOM w0.069: RD47.2 200.12,42.21 202.6,42.21 v4(202.76,42.36)
N79384190: length 10.1
  BOTTOM w0.069: v1(184.39,71.95) 183.88,71.44 R5867.2 183.35,71.42 C3314.2 182.12,71.77 179.44,71.77 QZ10.3 178.09,70.95 177.69,70.55 177.69,68.78 R5868.1
N79384208: length 25.7
  TOP w0.069: v2(174.54,64.43) 174.54,64.1 v1(173.06,62.63) v3(172.58,62.15)
  IN1 w0.061: v2(174.54,64.43) v3(174.54,64.91)
  IN2 w0.051: v4(182.21,48.28) 182.21,50.18 181.47,50.91 181.47,54.27 178.48,57.26 177.1,57.26 172.58,61.77 v3(172.58,62.15)
  IN3 w0.061: v3(174.54,64.91) 174.97,65.35 174.97,65.88 v4(176.16,67.07)
  BOTTOM w0.069: v4(176.16,67.07) 176.16,67.25 R5868.2
N79413033: length 6.5
  BOTTOM w0.069: R30.2 89.35,73.35 89.49,73.21 R633.2 88.94,72.94 88.74,72.74 v1(88.74,72.36) 88.74,72.28 88.87,72.15 88.87,70.86 88.28,70.27 88.28,69.03 Q16.6
N79413091: length 2
  BOTTOM w0.069: R931.2 R932.2 91.28,67.53 90.91,67.16 Q16.3
N79476902: length 1.3
  TOP w0.069: UW1.22 260.83,12.09 CW123.2
N79477480: length 3.6
  TOP w0.069: v1(268.85,9.72) 268.34,10.23 267.93,10.23 267.45,10.71 DR3.2 266.46,11.59 UW1.8
N79477679: length 2.1
  TOP w0.069: UW1.2 263.23,9.07 263.25,9.06 ; v1(262.4,9.06) 263.25,9.06 ; 263.25,9.06 RW1234.2
N79766737: length 2.2
  TOP w0.069: UT3.6 166.55,6.21 166.69,6.34 167.17,6.34 167.85,5.66 C4247.1
N79796602: length 5.1
  TOP w0.069: RW54.2 261.91,18.18 261.53,17.8 v1(260.95,17.8) 260.95,17.21 v2(261.2,16.96)
  IN1 w0.061: v2(261.2,16.96) 260.82,16.96 260.19,16.32 v2(259.06,16.32)
N80090458: length 6.7
  BOTTOM w0.069: Q16.5 89.27,67.81 89.68,68.22 89.68,68.8 88.97,69.5 88.97,69.71 v1(88.74,69.94) 89.14,70.35 89.14,72.01 R633.1
N81124602: length 2.2
  BOTTOM w0.069: v1(191.38,72.56) 191.38,73.45 QC5.6
  BOTTOM w0.254: QC5.6 192.55,73.64 RC782.2
N81124608: length 5.5
  BOTTOM w0.069: v1(189.71,72.57) 189.03,72.57 RC783.2
  BOTTOM w0.254: RC783.2 189.22,73.75 189.22,74.12 189.38,74.29 QC5.2 190.54,74.29 190.72,74.47 190.72,74.72 190.5,74.94 QC5.3

## Copper pours and planes (outline as drawn)
+0.6V_VDDQ on TOP: 169.89,26.87 169.64,27.12 169.64,32.07 169.89,32.33 172.81,32.33 173.19,32.71 179.67,32.71 182.53,35.57 189.32,35.57 191.61,37.85 198.08,37.85 199.48,36.45 199.48,35.63 197.85,35.63 197.63,35.86 193.28,35.86 191.72,34.3 191.72,33.96 191.71,33.96 191.71,33.62 189.27,31.18 185.88,31.18 185.88,31.18 185.64,31.18 184.88,31.95 183.48,31.95 181.5,29.96 172.51,29.96 171.97,29.43 171.97,26.92 171.92,26.87
+0.6V_VDDQ on BOTTOM: 199.99,40.33 199.99,40.86 199.78,41.06 199.02,41.06 198.65,40.7 198.65,40.49 198.62,40.45 198.62,38.83 197.96,38.17 197.96,36.16 198.54,35.58 200.9,35.58 201.28,35.96 201.28,37.38 201.26,37.41 200.72,37.41 200.72,37.97 201.26,37.97 201.28,37.99 201.28,38.17 201.26,38.19 200.72,38.19 200.72,38.75 201.26,38.75 201.28,38.78 201.28,39.11 201.21,39.11
+0.6V_VDDQP on BOTTOM (solid shape): 205.44,41.56 205.44,40.21 205.22,40 204.86,40 204.46,39.59 204.46,37.53 204.81,37.18 204.81,36.24 204.51,35.93 202.55,35.93 201.44,37.05 201.44,37.56 200.88,37.56 200.88,37.81 201.44,37.81 201.44,38.35 200.9,38.35 200.88,38.37 200.88,38.6 201.41,38.6 201.44,38.63 201.44,39.24 200.83,39.84 200.83,40.4 201.04,40.62 201.04,41.64 201.33,41.93 205.07,41.93
+0.9V_TBT_L_LVR on BOTTOM: 26.14,55.29 23.48,55.29 23.38,55.39 23.38,56.02 23.41,56.05 24.43,56.05 24.82,55.66 26.16,55.66 26.2,55.62 26.2,55.35
+0.9V_TBT_L_SVR on BOTTOM (solid shape): 23.98,51.87 23.98,51.37 24.09,51.26 24.58,51.26 24.63,51.22 24.63,50.84 24.2,50.42 24.2,49.81 23.84,49.45 23.15,49.45 23.04,49.56 23.04,50.48 22.9,50.61 21.5,50.61 21.29,50.82 21.29,51.71 21.58,52 23.85,52
+0.9V_TBT_L_SVR on IN2: 22.7,56.71 22.7,51.12 23.2,50.61 29.1,50.61 29.89,51.41 29.89,57.01 29.17,57.73 23.71,57.73
+0.9V_TBT_R_SVR on BOTTOM (solid shape): 263.63,48.77 263.63,47.86 263.64,47.85 263.64,46.17 263.34,45.86 261.53,45.86 261.35,46.04 261.35,47.46 261.53,47.64 262.41,47.64 262.6,47.83 262.6,48.86 262.68,48.94 263.46,48.94
+0.9V_TBT_R_SVR on IN3 (solid shape): outline of 457 points within 262.7,47.04 268.8,54.12
+1.1V_MEM on BOTTOM (solid shape): outline of 4960 points within 126.58,39.29 152.24,42.74
+1.1V_MEM on TOP: 122.14,20.52 125.57,20.52 125.69,20.39 126.07,20.39 126.46,20.01 126.46,15.69 126.07,15.31 122.26,15.31 121.63,15.94 121.63,20.01
+1.1V_MEM on TOP: 153.89,20.13 154.14,20.13 154.27,20.01 156.81,20.01 157.44,19.37 157.44,16.2 156.81,15.56 154.52,15.56 153.51,16.58 153.51,17.59 153.89,17.98
+1.1V_MEM on TOP: outline of 338 points within 101.82,8.45 168.49,42.58
+1.1V_MEM on BOTTOM: 102.58,23.56 102.45,23.69 102.45,24.45 102.33,24.58 101.18,24.58 100.76,25 100.76,25.56 101.32,25.56 101.32,26.11 100.76,26.11 100.76,26.37 101.32,26.37 101.32,26.92 100.76,26.92 100.76,27.59 101.06,27.88 104.61,27.88 105.25,28.52 112.1,28.52 112.61,29.02 112.61,31.18 112.87,31.44 125.82,31.44 126.58,32.2 126.58,39.69 126.84,39.95 147.54,39.95 147.79,39.69 151.6,39.69 151.86,39.95 152.11,39.95 152.24,39.82 152.24,37.66 152.36,37.53 152.36,35.25 151.86,34.74 148.3,34.74 147.16,33.6 147.16,31.31 147.92,30.55 148.43,30.55 148.55,30.68 148.55,31.69 148.68,31.82 150.2,31.82 150.33,31.69 150.33,24.96 149.7,24.33 121.5,24.33 120.74,23.56
+1.1V_MEM on IN2: 166.84,12.13 166.84,13.02 166.46,13.4 166.46,14.17 167.22,14.93 167.22,22.17 166.08,23.31 157.44,23.31 156.68,22.55 112.87,22.55 111.72,21.4 111.72,19.37 111.22,18.86 111.22,15.18 112.99,13.4 132.17,13.4 133.82,11.75 152.24,11.75 152.74,11.24 162.78,11.24 163.16,10.86 165.57,10.86 ; 4 cut-outs
+1.1V_MEMP on BOTTOM: 98.42,27.54 100.51,27.54 100.61,27.44 100.61,24.77 101.06,24.33 101.82,24.33 101.94,24.2 101.94,23.31 101.82,23.18 99.15,23.18 98.9,22.93 98.9,20.52 98.64,20.26 94.58,20.26 94.45,20.39 94.45,22.17 94.86,22.57 94.86,24.17 95.52,24.83 95.52,25.87 94.86,26.54 94.86,27.5 95.59,27.5 95.77,27.67 98.29,27.67
+1.05V_VCCST on BOTTOM: 113.09,57.22 111.85,57.22 111.6,57.47 111.6,59.33 111.65,59.38 111.67,59.38 112.1,58.95 113.15,58.95 113.2,58.89 113.2,57.32
+1.8V_MEM on TOP (solid shape): 168.57,14.65 168.57,13.61 168.49,13.53 167.4,13.53 167.27,13.66 167.27,14.52 167.63,14.88 168.34,14.88
+1.8V_MEM on TOP: 136.53,20.23 136.09,20.23 135.83,20.48 135.83,21.69 135.9,21.75 136.34,21.75 136.6,21.5 136.6,20.29
+1.8V_MEM on TOP: 167.48,7.56 167.73,7.31 169.36,7.31 169.44,7.38 169.44,8.7 169.33,8.81 169.33,9.47 169.08,9.72 167.6,9.72 167.48,9.59
+1.8V_MEM on BOTTOM: 168.11,23.69 154.27,23.69 154.24,23.66 121.8,23.66 120.56,22.42 110.15,22.42 109.29,21.56 109.29,14.04 109.3,14.03 109.3,11.64 109.91,11.02 137.69,11.02 137.7,11.02 162.24,11.02 163.79,9.47 163.79,7.94 164.17,7.56 168.49,7.56 168.75,7.82 168.75,9.72 168.73,9.73 168.73,23.07
+1.8V_MEM on IN1: 125.38,14.47 122.17,14.47 121.78,14.08 121.78,12.52 122.07,12.23 123.59,12.23 125.13,13.77 125.3,13.77 125.47,13.94 125.47,14.38
+1.8V_MEM_R on TOP: 170.65,6.29 168.82,6.29 168.6,6.07 167.41,6.07 167.1,6.38 166.39,6.38 166.25,6.24 166.25,5.39 166.2,5.34 165.37,5.34 165.14,5.57 165.14,6.99 165.38,7.24 166.29,7.24 166.69,7.64 167.27,7.64 167.73,7.18 169.46,7.18 169.64,7.36 169.64,8.2 169.76,8.32 170.92,8.32 171.02,8.22 171.02,6.66
+1.8V_PRIM on BOTTOM (solid shape): 177.25,50.67 177.25,49.34 177.44,49.15 178.34,49.15 178.39,49.1 178.39,48.43 178.34,48.39 177.5,48.39 177.18,48.07 177.18,47.12 177.12,47.05 176.48,47.05 176.42,47.12 176.42,47.99 176.09,48.33 176.09,50.72 176.17,50.8 177.12,50.8
+1.8V_PRIM on IN2 (solid shape): 143.47,63.31 143.47,62.81 143.35,62.68 141.7,62.68 141.57,62.81 141.57,62.96 142.05,63.44 143.35,63.44
+1.8V_PRIM on TOP: 257.27,13.65 257.42,13.65 257.65,13.43 257.65,12.51 257.44,12.31 257.15,12.31 257.15,12.09 256.87,11.81 252.49,11.81 252.4,11.89 252.4,12.51 252.95,12.51 254.73,14.29 257.04,14.29 257.14,14.19 257.14,13.78
+1.8V_PRIM on TOP: 196.81,38.3 199.23,38.3 199.61,38.68 199.61,40.07 199.1,40.58 196.69,40.58 195.97,41.3 195.39,41.3 195.16,41.07 195.16,39.95
+1.8V_PRIM on TOP: 197.83,6.04 198.59,6.04 200.27,7.71 200.27,8.53 199.78,9.01 198.36,9.01 196.99,7.64 196.99,6.7 197.16,6.53 197.33,6.53
+1.8V_PRIM on TOP: 171.54,6.04 171.54,4.39 171.41,4.26 170.4,4.26 170.14,4.01 170.14,3.62 170.52,3.24 174.01,3.24 174.1,3.34 176.1,3.34 176.24,3.48 176.24,4.11 176.42,4.29 177.5,4.29 177.65,4.13 177.65,3.52 177.85,3.32 182.94,3.32 183.38,3.75 185.38,3.75 185.64,3.5 185.64,1.97 185.26,1.59 165.3,1.59 165.08,1.81 165.08,3.72 165.43,4.07 166.13,4.07 166.21,3.98 166.21,3.09 166.7,2.61 167.93,2.61 168.11,2.79 168.11,4.22 168.78,4.88 168.78,5.88 169.06,6.16 171.41,6.16
+1.8V_PRIM on TOP: 269.08,44.26 270.73,44.26 270.85,44.14 270.85,43.25 270.73,43.12 269.08,43.12 268.95,43.25 268.95,44.14
+1.8V_PRIM on BOTTOM: 196.05,38.3 195.92,38.42 195.92,39.06 195.54,39.44 194.27,39.44 193.89,39.82 193.89,42.87 194,42.97 194.93,42.97 194.93,42.49 195.72,42.49 195.72,42.97 196.18,42.97 196.18,42.49 196.91,42.49 196.91,42.97 198.06,42.97 198.21,42.82 198.21,39.95 197.7,39.44 197.7,38.93 197.07,38.3
+1.8V_PRIM on BOTTOM: 140.68,66.87 140.81,67 142.33,67 142.46,66.87 142.46,63.95 143.09,63.31 143.09,62.81 142.97,62.68 141.7,62.68 141.31,63.06 140.43,63.06 140.3,63.19 140.3,63.57 139.92,63.95 139.92,65.35 140.17,65.6 140.43,65.6 140.68,65.85
+1.8V_PRIM on IN1: 184.24,2.99 183.73,3.5 183.73,4.58 184.13,4.98 188.29,4.98 189.09,5.78 193.13,5.78 193.42,6.07 193.42,6.08 196.01,6.08 197.12,7.18 197.8,7.18 197.93,7.05 198.49,7.05 198.49,4.87 196.61,2.99
+1.8V_PRIM on VCC: 187.65,37.91 181.68,43.88 176.87,43.88 176.87,45.05 177.11,45.28 180.41,45.28 180.94,45.81 180.94,52.01 192.01,52.01 196.76,47.26 196.76,38.73 195.95,37.91
+1.8V_PRIM on IN2: 175.86,48.58 177.26,48.58 177.51,48.33 177.51,47.19 179.03,45.66 179.03,43.63 180.43,42.23 180.43,41.6 180.3,41.47 178.4,41.47 175.73,44.14 175.73,48.46
+1.8V_PRIM on IN3: 176.24,49.09 176.62,49.09 177.13,48.58 177.13,48.07 177,47.95 176.24,47.95 176.11,48.07 176.11,48.96
+1.8V_PRIMP on BOTTOM (solid shape): 197.96,51.76 197.96,43.24 197.83,43.11 194,43.11 193.89,43.22 193.89,48.33 194.4,48.84 194.4,51.76 194.46,51.82 197.89,51.82
+1.8VS on TOP: 260.1,16.88 257.51,16.88 256.61,15.99 256.61,15.65 256.87,15.4 257.12,15.4 257.32,15.6 257.32,15.97 257.61,16.26 258.67,16.26 258.9,16.49 260.13,16.49 260.17,16.53 260.17,16.81
+1.8VS on BOTTOM: 225.39,11.24 225.39,10.61 225.52,10.48 225.77,10.48 225.9,10.61 225.9,11.88 225.52,12.26 225.13,12.26 225.01,12.13 225.01,11.63
+1.8VS on BOTTOM: 192.23,39.36 192.23,42.16 192.1,42.28 191.21,42.28 191.09,42.16 191.09,39.36 191.21,39.24 192.1,39.24
+1.8VS on IN3: 224.75,12.77 225.13,12.77 225.17,12.73 226.47,12.73 226.63,12.57 226.63,12.13 226.25,11.75 224.88,11.75 224.63,12.01 224.63,12.64
+1.8VS_AUDIO on TOP (solid shape): 23.51,23.92 23.51,23.46 23.46,23.41 21.65,23.41 20.92,22.67 20.92,20.64 20.79,20.52 20.03,20.52 19.9,20.64 19.9,23.56 20.03,23.69 20.89,23.69 21.27,24.07 23.36,24.07
+1.8VS_AUDIO on TOP (solid shape): 28.41,21.15 28.41,19.12 28.28,18.99 26.25,18.99 26.13,19.12 26.13,20.64 26.25,20.77 27.27,20.77 27.4,20.9 27.4,21.15 27.52,21.28 28.28,21.28
+1.8VS_AUDIO on TOP: 270.93,30.88 271.29,30.88 271.39,30.78 271.39,28.97 271.74,28.62 271.92,28.62 272.12,28.41 272.12,28.01 271.9,27.78 270.5,27.78 270.4,27.88 270.4,28.47 270.7,28.77 270.7,30.65
+1.8VS_AUDIO_R on TOP: 272.25,43.12 274.66,43.12 274.79,43.25 274.79,44.14 274.66,44.26 272.25,44.26 272.12,44.14 272.12,43.25
+1.8VS_R on BOTTOM: 193.51,38.3 194.4,38.3 194.53,38.42 194.53,39.18 194.4,39.31 194.15,39.31 193.77,39.69 193.77,40.59 193.58,40.78 192.68,40.78 192.57,40.67 192.57,39.73 193.12,39.18 193.13,39.18 193.38,38.93 193.38,38.42
+3.3V_ALW_UE1 on TOP (solid shape): 173.03,18.84 173.03,17.61 173.6,17.05 174.86,17.05 175.21,17.4 176.79,17.4 176.8,17.35 176.85,17.24 176.96,17.17 177,17.16 177,16.67 176.85,16.52 175.91,16.52 175.75,16.36 172.99,16.36 172.99,16.51 172.09,16.51 172.09,17.23 172.16,17.3 172.16,17.87 172.22,17.93 172.25,18.01 172.25,18.02 172.48,18.25 172.48,18.63 172.62,18.77 172.62,18.87 173,18.87
+3.3V_ALW_UE1 on TOP: 182.92,12.59 184.09,12.59 185.46,11.22 185.46,10.61 185.33,10.48 184.49,10.48 184.39,10.58 184.39,11.09 183.91,11.57 183.1,11.57 182.67,12.01 182.67,12.34
+3.3V_TBT_L on BOTTOM (solid shape): 28.82,47.52 28.82,47.08 28.77,47.02 28.13,47.02 27.62,46.51 27.62,45.68 27.59,45.65 26.77,45.65 26.67,45.75 26.67,46.45 26.48,46.64 26.48,47.33 26.54,47.4 27.05,47.4 27.24,47.59 28.75,47.59
+3.3V_TBT_L_B on BOTTOM (solid shape): 24.73,46.78 25.02,46.49 25.08,46.49 25.24,46.45 25.39,46.49 26.19,46.49 26.23,46.45 26.23,45.62 26.16,45.56 24.39,45.56 24.07,45.87 24.07,46.7 24.15,46.78 24.73,46.78
+3.3V_TBT_L_SVR on BOTTOM (solid shape): 25.76,55.12 25.76,54.42 25.69,54.34 25.41,54.34 25.22,54.15 24.9,54.15 24.68,54.37 23.23,54.37 23.06,54.2 22.43,54.2 22.39,54.25 22.39,55.14 22.41,55.16 25.73,55.16
+3.3V_TBT_R on BOTTOM (solid shape): 259.19,51.37 259.19,50.4 259.58,50.01 261.66,50.01 261.7,49.97 261.7,49.48 260.84,48.62 260.84,47.9 260.75,47.81 259.31,47.81 259.17,47.95 259.17,49.22 258.6,49.79 258.6,51.33 258.66,51.4 259.16,51.4
+3.3V_TBT_R on IN2 (solid shape): 261.46,49.22 261.46,48.79 260.92,48.25 260.21,48.25 259.93,48.53 259.93,49.29 260.08,49.45 261.23,49.45
+3.3V_TBT_R on TOP: 259.42,49.22 259.42,47.31 259.55,47.19 261.08,47.19 261.33,47.44 261.33,49.09 261.08,49.34 259.55,49.34
+3.3V_TBT_R_B on TOP: 256.76,48.96 256.76,47.95 256.88,47.82 258.66,47.82 258.79,47.95 258.79,48.96 258.66,49.09 256.88,49.09
+3.3V_TBT_R_SVR on BOTTOM (solid shape): 264.36,52.16 264.53,52.01 264.76,52.01 264.77,52.02 265.6,52.02 265.64,51.98 265.64,51.46 265.56,51.37 265.31,51.37 265.28,51.4 264.91,51.4 264.44,50.94 262.09,50.94 261.87,50.94 261.76,50.83 261.76,50.36 261.74,50.35 261.07,50.35 261.05,50.36 261.05,51.21 261.57,51.72 262.12,51.72 262.13,51.73 263.59,51.73 264.02,52.16
+3.3V_VPS_TPM on BOTTOM: 186.45,38.45 186.68,38.68 186.68,39.59 186.73,39.64 186.88,39.64 186.96,39.57 186.96,38.7 187.47,38.19 187.47,37.81 187.34,37.69 186.07,37.69 185.81,37.43 184.27,37.43 184.27,36.72 184.09,36.54 183.38,36.54 182.97,36.95 182.97,37.6 183.15,37.78 183.15,38.07 183.27,38.19 185.81,38.19 186.07,38.45
+3V_1.8V_HDA_R on BOTTOM (solid shape): 176.67,45.11 176.67,43.86 176.62,43.81 175.79,43.81 175.66,43.69 175.66,43.43 175.6,43.37 175.21,43.37 175.09,43.5 175.09,45.15 175.12,45.18 176.59,45.18
+3V_NB_LID_R on TOP: 184.49,8.07 185.13,8.07 185.38,8.32 185.64,8.32 185.76,8.2 185.76,7.05 185.64,6.93 185.26,6.93 185.13,7.05 184.49,7.05 184.37,7.18 184.37,7.94
+3V_PRIM on BOTTOM (solid shape): 179.92,49.22 179.92,48.2 179.41,47.69 179.41,47.24 179.19,47.01 179.19,46.1 179.8,45.49 179.8,44.52 178.85,43.58 178.21,43.58 178.19,43.55 178.03,43.55 177.6,43.12 177.6,42.33 177.34,42.08 175.3,42.08 175.23,42.15 175.23,43.14 175.27,43.18 175.7,43.18 175.78,43.1 175.79,43.1 175.86,43.03 176.37,43.03 176.49,43.15 176.49,43.58 176.59,43.68 176.88,43.68 177.03,43.83 177.03,44.39 177.09,44.45 178.03,44.45 178.03,44.45 178.79,44.45 178.88,44.54 178.88,45.03 178.8,45.11 178.8,45.14 178.77,45.14 178.23,45.68 178.23,47.93 178.64,48.34 178.64,49.2 178.78,49.34 179.8,49.34
+3V_PRIM on TOP: 183.3,37.74 183.58,37.46 183.58,37.36 183.15,36.92 182.25,36.92 182.25,37.67 181.09,38.83 181.09,39.54 181.24,39.69 182.28,39.69 183.3,38.68
+3V_PRIM on TOP: 185.51,50.87 185.51,50.49 185.64,50.36 186.02,50.36 186.15,50.23 186.15,49.6 186.02,49.47 185.26,49.47 184.88,49.85 184.24,49.85 183.99,50.11 183.99,50.87 184.11,51 185.38,51
+3V_PRIM on TOP: 154.65,37.91 154.52,38.04 154.52,38.68 155.03,39.18 160.49,39.18 160.75,39.44 160.75,39.82 160.62,39.95 159.22,39.95 159.09,40.07 159.09,40.45 158.97,40.58 158.33,40.58 158.21,40.45 158.21,40.07 158.08,39.95 157.06,39.95 156.94,40.07 156.94,40.84 157.06,40.96 159.98,40.96 160.11,40.84 160.75,40.84 160.87,40.71 160.87,40.2 161.13,39.95 163.34,39.95 163.72,40.33 164.17,40.33 164.24,40.26 164.24,39.61 164.2,39.57 161.38,39.57 161.25,39.44 161.25,38.42 161.13,38.3 159.98,38.3 159.6,37.91 159.09,37.91 158.97,38.04 158.97,38.42 158.84,38.55 157.06,38.55 156.94,38.42 156.94,38.04 156.81,37.91 156.55,37.91 156.43,38.04 156.43,38.47 156.35,38.55 155.74,38.55 155.67,38.47 155.67,38.04 155.54,37.91
+3V_PRIM on TOP: 164.94,47.95 166.84,47.95 166.97,47.82 166.97,47.57 166.84,47.44 165.57,47.44 165.44,47.31 165.44,46.3 165.57,46.17 167.22,46.17 167.35,46.3 167.35,46.68 167.48,46.8 167.98,46.8 168.11,46.93 168.11,47.82 168.24,47.95 168.49,47.95 168.62,47.82 168.62,47.44 168.75,47.31 169.25,47.31 169.38,47.44 169.38,47.82 169.51,47.95 170.65,47.95 170.78,48.07 170.78,48.58 170.83,48.63 173.98,48.63 174,48.66 174.66,48.66 175.86,49.85 176.24,49.85 176.49,49.6 176.49,49.22 174.33,47.06 172.56,47.06 172.3,46.8 172.05,46.8 170.52,45.28 164.81,45.28 164.05,46.04 164.05,47.06
+3V_PRIM on BOTTOM: 173.85,36.42 173.78,36.49 173.78,36.85 174.59,37.66 174.59,38.14 175.38,38.14 175.38,36.54 175.25,36.42
+3V_PRIM on IN1: 163.16,47.69 164.43,47.69 165.32,46.8 165.32,45.66 165.19,45.53 164.81,45.53 164.68,45.66 164.68,46.17 164.05,46.8 163.16,46.8 163.03,46.93 163.03,47.57
+3V_PRIM on IN3: 164.05,47.82 164.3,47.82 165.32,46.8 165.32,45.66 165.19,45.53 164.68,45.53 164.56,45.66 164.56,46.8 163.92,47.44 163.92,47.69
+3V_PRIM on IN3: 180.18,24.99 179.39,25.77 179.39,27.73 179.46,27.81 180.53,27.81 180.66,27.68 180.66,26.64 181.34,25.95 184.47,25.95 185.33,26.81 186.73,26.81 186.91,26.64 186.91,25.7 186.32,25.11 182.67,25.11 182.54,24.99
+3V_PRIM_R on TOP: 185.26,48.96 186.02,48.96 186.15,48.84 186.15,48.2 185.38,47.44 185.38,46.8 185.26,46.68 184.75,46.68 184.62,46.8 184.62,47.69 185.13,48.2 185.13,48.84
+3VALW on TOP (solid shape): 7.61,43.06 7.61,42.8 7.32,42.51 5.32,42.51 5.08,42.76 5.08,43.68 5.33,43.93 6.74,43.93
+3VALW on TOP (solid shape): 122.29,5.12 122.29,3.45 122.21,3.37 121.5,3.37 121.38,3.5 121.38,4.97 121.68,5.28 122.14,5.28
+3VALW on TOP (solid shape): 170.6,17.37 170.6,16.65 170.83,16.43 171.07,16.43 171.07,15.76 171.86,15.76 171.86,16.21 171.89,16.26 171.95,16.25 172,16.2 172,16.15 172.1,16.05 172.1,15.85 173.08,15.85 173.08,15.27 173.17,15.18 174.03,15.18 174.11,15.11 174.11,14.67 173.36,13.93 171.13,13.93 170.7,14.36 170.71,14.39 170.65,14.65 170.39,14.71 170.36,14.7 169.48,15.58 169.48,17.09 169.84,17.44 170.52,17.44
+3VALW on BOTTOM (solid shape): 22.38,42.9 22.38,41.94 22.12,41.69 21.65,41.69 21.65,41.59 20.47,41.59 20.24,41.82 20.24,42.59 20.48,42.84 20.82,42.87 20.84,43.2 20.9,43.26 22.02,43.26
+3VALW on BOTTOM (solid shape): 22.11,49.19 22.11,48.81 22.09,48.79 21.71,48.79 21.6,48.68 21.6,48.15 21.65,48.1 22.54,48.1 22.67,47.97 22.67,47.53 22.61,47.46 21.78,47.46 21.72,47.4 21.72,46.89 21.78,46.83 22.54,46.83 22.67,46.7 22.67,46.06 22.61,46 20.96,46 20.83,46.13 20.83,47.78 21.08,48.03 21.08,48.77 21.53,49.22 22.09,49.22
+3VALW on BOTTOM (solid shape): 226.24,14.11 226.24,13.68 226.46,13.46 226.46,12.84 226.53,12.77 226.53,11.63 226.4,11.5 226.4,9.85 226.79,9.47 226.79,7.84 226.58,7.64 225.82,7.64 225.64,7.82 225.64,8.66 225.51,8.8 225.23,8.8 225.16,8.87 225.16,9.49 225.39,9.72 225.39,9.72 226.02,10.36 226.02,12.01 225.67,12.36 225.67,14.04 225.78,14.15 226.21,14.15
+3VALW on IN1 (solid shape): 31.37,26.3 31.37,25.52 31.16,25.31 30.99,25.31 30.41,25.89 30.41,26.32 30.72,26.63 31.04,26.63
+3VALW on IN2 (solid shape): 31.38,26.4 31.38,24.34 31.22,24.18 30.6,24.18 30.36,24.42 30.36,26.37 30.64,26.65 31.14,26.65
+3VALW on IN2 (solid shape): 97.61,23.29 97.61,22.64 97.41,22.44 95.57,22.44 95.05,22.96 95.05,23.42 95.14,23.51 97.39,23.51
+3VALW on TOP: 181.04,7.84 181.55,7.84 181.75,7.64 182.59,7.64 182.69,7.54 182.69,7.21 182.51,7.03 182.08,7.03 181.98,6.93 181.98,6.62 181.88,6.52 181.5,6.52 181.34,6.67 181.34,6.98 180.96,7.36 180.96,7.76
+3VALW on TOP: 189.07,9.85 188.94,9.97 188.94,10.23 189.07,10.36 189.45,10.36 189.57,10.48 189.57,10.99 189.45,11.12 189.07,11.12 188.94,11.24 188.94,12.77 189.07,12.9 189.83,12.9 189.96,13.02 189.96,14.27 189.57,14.65 189.57,15.54 189.65,15.61 189.83,15.61 189.96,15.74 189.96,15.82 190.72,16.58 190.72,24.58 190.84,24.71 191.35,24.71 191.48,24.58 191.48,23.06 192.62,21.91 192.62,21.84 193.13,21.33 193.13,20.06 192.62,19.55 192.62,10.61 191.86,9.85
+3VALW on TOP: 256.88,50.36 257.77,50.36 257.9,50.49 258.79,50.49 258.92,50.61 258.92,52.65 258.79,52.77 257.14,52.77 257.01,52.65 257.01,51.63 256.76,51.38 256.76,50.49
+3VALW on TOP: 20.22,43.22 21.81,43.22 22.15,42.88 22.15,42.24 21.88,41.97 20.26,41.97 20,42.23 20,43.01
+3VALW on TOP: 174.59,5.66 174.97,5.28 176.75,5.28 176.87,5.4 176.87,7.46 176.73,7.6 175.45,7.6 174.59,6.74
+3VALW on TOP: 191.48,38.04 189.45,36.01 185.26,36.01 183.41,37.85 183.41,38.74 181.95,40.2 181.95,41.72 181.07,42.61 181.07,45.15 181.19,45.28 182.08,45.28 182.21,45.15 182.21,44.01 182.34,43.88 182.46,43.88 182.59,44.01 182.59,45.28 182.72,45.41 183.22,45.41 183.35,45.28 183.35,43.5 183.22,43.38 182.72,43.38 182.59,43.25 182.59,42.74 182.97,42.36 182.97,41.34 183.48,40.84 183.99,40.84 184.11,40.96 184.11,41.85 184.24,41.98 184.49,41.98 184.62,42.11 184.62,45.28 184.75,45.41 185.38,45.41 185.51,45.28 185.51,43.12 185.38,42.99 185.38,40.58 185.37,40.57 185.37,39.4 187.97,39.4 187.97,40.97 188.4,41.4 188.4,43.39 190.2,45.18 190.69,45.18 190.96,44.92 190.96,42.34 192.63,42.34 193.65,43.36 198.9,43.36 199.13,43.12 202.02,43.12 202.4,42.74 202.4,41.34 202.53,41.22 204.31,41.22 204.69,40.84 204.69,36.39 205.45,35.63 205.45,12.87 207.05,11.27 226.3,11.27 226.96,10.61 226.96,7.61 226.66,7.31 201.51,7.31 200.65,8.17 200.65,9.16 202.15,10.66 202.15,37.91 199.35,40.71 195.92,40.71 193.26,38.04
+3VALW on BOTTOM: 200.24,34.74 196.31,34.74 196.05,34.49 196.05,32.33 198.1,30.28 200.5,30.28 200.62,30.41 200.62,34.36
+3VALW on BOTTOM: 265.72,4.78 265.14,5.36 264.89,5.36 264.63,5.61 264.63,6.77 265.04,7.18 267.64,7.18 267.87,6.94 267.87,4.94 267.72,4.78
+3VALW on BOTTOM: 189.61,47.04 190.21,47.04 192.09,45.16 192.09,44.33 191.78,44.02 191.34,44.02 190.36,45.01 190.36,45.56 189.87,46.05 189.74,46.05 189.36,46.43 189.36,46.79
+3VALW on BOTTOM: 210.15,5.91 210.28,5.91 210.4,5.78 210.4,5.02 210.53,4.89 210.53,4.39 210.15,4.01 208.37,4.01 206.97,5.4 206.97,9.56 207.16,9.75 209.23,9.75 209.36,9.62 209.36,8.6 209.77,8.2 209.77,6.29
+3VALW on BOTTOM: 106.39,62.5 107.41,62.5 107.58,62.32 107.58,62.17 108.45,61.31 108.45,61 108.29,60.85 106.9,60.85 106.64,61.1 106.64,61.61 106.26,61.99 106.26,62.37
+3VALW on BOTTOM: 237.42,12.24 242.92,12.24 243.1,12.06 243.1,10.34 242.83,10.07 237.39,10.07 237.26,10.19 237.26,12.08
+3VALW on BOTTOM: 211.09,5.83 211.77,5.83 211.85,5.76 211.85,5.5 211.95,5.4 211.93,5.38 211.93,4.13 211.72,3.93 210.86,3.93 210.81,3.98 210.81,4.59 210.99,4.77 210.99,5.73
+3VALW on IN1: 21.54,43.07 21.79,42.81 21.79,41.68 21.5,41.39 20.56,41.39 20.3,41.65 20.3,42.81 20.56,43.07
+3VALW on IN1: 30.66,64.52 21.34,64.52 20.23,63.4 20.23,48.11 21.26,47.08 21.97,47.08 22.31,47.42 22.31,48.21 21.37,49.15 21.37,62.27 22.34,63.25 30.31,63.25 30.61,62.95 31.28,62.95 31.51,63.18 31.51,63.66
+3VALW on IN1: 190.49,45.11 191.25,45.11 191.99,44.38 191.99,43.67 191.81,43.49 191.24,43.49 190.35,44.38 190.35,44.95 190.49,45.09
+3VALW on VCC: 263.48,1.22 262.95,1.75 262.95,10.99 261.94,12.01 242.56,12.01 238.62,8.07 222.57,8.07 222.09,8.56 222.09,12.01 235.53,12.01 236.85,13.33 249.17,21.08 253.18,25.09 258.64,25.09 259.78,26.23 262.45,26.23 263.49,27.27 263.49,34.46 260.69,37.26 260.69,48.94 258.15,51.48 258.15,62.32 258.54,62.7 258.54,63.59 258.64,63.7 262.49,63.7 262.73,63.46 262.73,62.07 263.13,61.66 265.34,61.66 265.82,61.18 266.74,61.18 266.94,60.98 269.84,60.98 269.84,27.63 265.26,23.06 262.11,23.06 261.33,22.27 261.33,19.39 262.24,18.48 274.72,18.48 274.72,6.42 271.51,6.42 269.33,4.24 269.33,1.42 269.13,1.22
+3VALW on VCC: 172.53,6.55 170.02,9.06 170.02,24.94 166.18,28.77 163.18,28.77 162.42,28.01 161.74,28.01 160.98,28.77 120.25,28.77 117.97,26.48 107.68,26.48 105.63,24.43 105.63,20.92 107.91,18.63 107.91,8.32 100.53,8.32 96.1,12.75 96.1,68.29 96.72,68.9 111.83,68.9 112.99,70.07 112.99,71.88 115.28,71.88 115.28,70.05 115.28,70.05 115.92,68.63 117.34,67.99 117.34,67.99 132.81,67.99 132.81,60.75 132.57,60.52 124.06,60.52 118.6,55.06 107.17,55.06 104.61,52.5 104.61,32.35 105.78,31.18 112.97,31.18 124.53,42.74 148.58,42.74 149.97,41.34 161.23,41.34 162.27,42.38 162.27,44.14 173.98,44.14 174.74,43.38 181.47,43.38 187.44,37.41 195.8,37.41 195.8,35.9 197.7,34 197.7,25.36 204.69,18.38 204.69,15.54 195.69,6.55 ; 1 cut-out
+3VALW on IN3: 209.89,3.8 209.64,4.06 209.64,4.49 209.79,4.64 211.8,4.64 211.93,4.51 211.93,3.93 211.8,3.8
+3VALW on IN3: 20.82,46.62 21.15,46.62 22.12,45.65 22.12,42.35 21.97,42.2 21.35,42.2 20.68,42.86 20.68,46.48
+3VALW_DSW on TOP: 164.05,44.39 171.54,44.39 172.05,44.9 172.43,44.9 172.56,44.77 172.56,44.39 172.68,44.26 173.19,44.26 173.32,44.14 174.97,44.14 175.1,44.01 175.1,43.63 174.97,43.5 172.18,43.5 171.92,43.76 164.05,43.76 163.92,43.88 163.92,44.26
+3VALW_DSW_R on TOP: 182.97,48.96 183.1,48.84 183.1,47.69 183.35,47.44 183.35,46.8 183.22,46.68 182.46,46.68 181.95,47.19 181.95,47.57 181.57,47.95 181.57,48.84 181.7,48.96
+3VALW_TPM on BOTTOM: 186.2,45.94 186.32,45.94 186.45,45.81 186.96,45.81 187.08,45.69 187.08,45.31 186.96,45.18 186.2,45.18 186.07,45.05 186.07,43.91 185.94,43.78 185.69,43.78 185.56,43.91 185.56,45.05 185.42,45.19 184.35,45.19 184.21,45.33 184.21,45.79 184.39,45.97 186.17,45.97
+3VALWP on BOTTOM: 203.99,26.29 203.99,26.08 203.57,25.65 203.57,24.95 203.93,24.59 205.7,24.59 207.48,22.8 207.86,22.8 211.55,26.48 211.55,27.25 206.34,32.45 206.34,33.47 204.94,34.87 201.26,34.87 201.13,34.74 201.13,29.15
+3VLP on BOTTOM: 261,42.89 260.82,43.07 260.82,43.68 260.9,43.76 262.01,43.76 262.19,43.58 262.19,43.05 262.04,42.89
+3VLP on IN2: 180.71,6.34 184.04,6.34 184.47,5.91 184.47,5.33 184.11,4.97 180.48,4.97 180.2,5.25 180.2,5.83
+3VS on TOP: 177.89,43.38 178.27,43.38 178.4,43.25 178.4,41.42 178.3,41.32 177.86,41.32 177.76,41.42 177.76,43.25
+3VS on TOP: 141.45,5.02 141.44,5.02 126.07,5.02 125.14,5.96 123.89,5.96 123.76,6.09 123.76,6.75 123.79,6.78 125.6,6.78 125.71,6.67 151.58,6.67 151.73,6.53 151.73,3.98 151.54,3.79 150.53,3.79 150.38,3.95 150.38,4.18 150.17,4.38 148.64,4.38 147.79,5.23 145.57,5.23 145.35,5.02
+3VS on TOP: 153.76,35.76 154.27,35.76 154.4,35.63 154.4,35.25 154.52,35.12 154.78,35.12 155.16,35.5 155.54,35.5 155.67,35.63 155.67,36.01 155.79,36.14 156.43,36.14 156.68,35.88 156.68,34.99 156.43,34.74 155.79,34.74 155.54,34.49 155.16,34.49 155.03,34.36 155.03,32.96 154.9,32.83 154.4,32.83 154.27,32.96 154.27,34.1 154.14,34.23 153.76,34.23 153.51,34.49 153.51,35.5
+3VS on TOP: 253.99,23.84 254.93,23.84 255.16,24.07 255.16,24.4 254.26,25.3 253.62,25.3 253.58,25.26 253.58,24.25
+3VS on TOP: 169.76,55.82 171.03,55.82 171.29,56.08 171.29,57.09 171.03,57.35 169.89,57.35 169.76,57.22
+3VS on BOTTOM: 253.4,24.17 253.15,24.43 251.78,24.43 251.63,24.58 251.63,25.27 251.8,25.44 253.86,25.44 254.12,25.19 254.12,23.61 253.99,23.49 253.63,23.49 253.4,23.72
+3VS on IN1: 156.17,35.37 156.94,35.37 157.44,34.87 157.44,34.74 157.19,34.49 156.55,34.49 156.05,34.99 156.05,35.25
+3VS on IN2: 150.37,4.93 150.37,3.79 150.62,3.54 152.4,3.54 152.78,3.92 152.78,4.68 152.4,5.06 150.5,5.06
+3VS on IN2: 174.97,4.01 175.05,3.93 196.23,3.93 197.58,5.28 197.58,5.66 197.45,5.78 188.71,5.78 188.05,5.12 179.69,5.12 179.34,4.77 175.1,4.77 174.97,4.64
+3VS on IN3: 254.34,24.94 254.73,24.94 254.95,24.71 254.95,24.35 254.42,23.82 253.48,23.82 253.28,24.02 253.28,24.35 253.51,24.58 253.99,24.58
+3VS_CR on BOTTOM (solid shape): 12.41,46.55 12.41,45.53 12.28,45.41 11.9,45.41 11.84,45.34 11.76,45.34 11.63,45.21 11.63,43.48 11.39,43.48 11.36,43.52 11.36,44.74 11.13,44.98 11.13,46.54 11.27,46.68 12.28,46.68
+3VS_CR on BOTTOM (solid shape): 19.62,37.98 19.72,37.98 19.72,37.74 19.6,37.61 15.13,37.61 14.7,38.04 14.02,38.04 13.88,37.91 13.88,37.73 13.78,37.62 13.42,37.62 13.35,37.55 13.26,37.55 13.26,37.46 13.02,37.22 11.6,37.22 11.6,37.6 11.77,37.77 12.16,37.77 12.16,37.78 12.37,37.78 12.37,38 12.48,38.12 13.04,38.12 13.04,38.68 13.15,38.78 13.6,38.78 13.6,38.8 13.7,38.91 15.66,38.91 15.8,38.77 16.11,38.67 16.35,38.87 16.37,38.91 16.68,38.91 16.88,38.7 17.49,38.7 17.64,38.55 18.4,38.55 18.81,38.96 19.62,38.96
+3VS_CR on IN1: 14.19,37.53 16.35,37.53 16.73,37.91 16.73,46.93 16.47,47.19 12.03,47.19 11.52,46.68 11.52,45.15 13.43,43.25 13.43,38.3
+3VS_FP on BOTTOM: 255.31,40.2 255.16,40.35 255.16,41.29 255.28,41.42 255.66,41.42 255.84,41.6 255.84,41.78 255.94,41.88 258.03,41.88 258.61,41.29 258.61,40.94 257.87,40.2
+3VS_R on TOP: 123.74,3.37 123.66,3.45 123.66,4.26 123.65,4.27 123.65,5.39 123.72,5.45 124.85,5.45 124.88,5.42 124.88,3.45 124.8,3.37
+3VS_SSD on TOP (solid shape): 186.02,27.6 186.02,26.59 185.53,26.1 184.52,26.1 184.37,26.25 184.37,26.48 184.62,26.74 184.62,27.5 184.85,27.73 185.89,27.73
+3VS_SSD on TOP: 183.4,4.95 183.2,5.15 181.24,5.15 180.91,5.48 180.91,6.04 181.27,6.39 182.94,6.39 183.05,6.29 183.47,6.29 184.18,5.58 184.42,5.58 184.42,5.02 184.34,4.95
+3VS_SSD on BOTTOM: 179.92,26.61 179.92,25.47 180.43,24.96 182.21,24.96 183.99,23.18 185.38,23.18 185.64,23.44 185.64,27.53 185.48,27.68 184.8,27.68 184.62,27.5 184.62,26.94 184.54,26.87 181.14,26.87 180.94,27.07 180.94,27.96 181.12,28.14 181.12,28.87 181.07,28.92 181.07,29.28 181.01,29.33 180.4,29.33 180.33,29.25 180.33,28.97 180.09,28.73 180.09,26.78
+3VS_SSD on BOTTOM: 180.43,8.07 182.46,6.04 182.46,5.02 182.59,4.89 185.76,4.89 185.89,5.02 185.89,10.86 185.64,11.12 183.61,11.12 182.34,12.39 180.56,12.39 180.43,12.26
+3VS_SSD_R on TOP: 179.35,5.29 179.1,5.54 178.39,5.54 178.27,5.66 178.27,6.43 178.34,6.49 179.19,6.49 179.39,6.29 180.46,6.29 180.58,6.16 180.58,5.45 180.42,5.29
+3VS_TP on BOTTOM (solid shape): 209.7,10.84 210.2,10.84 210.3,10.74 210.3,9.42 210.26,9.37 209.63,9.37 209.61,9.39 209.61,9.67 209.41,9.88 207.1,9.88 206.82,9.59 206.11,9.59 206.03,9.67 206.03,10.63 206.29,10.89 209.65,10.89
+3VS_TP_R on BOTTOM (solid shape): 211.8,10.23 211.8,7.1 211.7,7 211.06,7 211.01,7.05 211.01,10.3 211.08,10.37 211.66,10.37
+3VS_TS on TOP: 128.49,66.87 128.36,66.74 126.2,66.74 125.95,66.49 125.95,66.11 126.33,65.73 126.33,64.46 126.46,64.33 127.85,64.33 127.98,64.2 127.98,63.95 127.85,63.82 125.69,63.82 125.69,64.69 124.83,65.55 124.83,67.38 124.96,67.51 128.41,67.51 128.49,67.43
+3VS_TS on BOTTOM: 105.96,72.97 107.51,72.97 107.63,72.84 107.63,71.87 107.43,71.67 105.96,71.67 105.78,71.85 105.78,72.79
+3VS_TS on IN1: 106.8,70.96 106.8,71.44 106.64,71.59 106.64,72.1 106.69,72.15 107.51,72.15 107.61,72.05 107.61,71.8 107.46,71.65 107.46,70.96 107.28,70.78 106.97,70.78
+3VS_TS_R on BOTTOM: 105.8,71.39 105.8,70.15 106.47,69.49 107.99,69.49 108.12,69.61 108.12,70.07 107.81,70.38 107.18,70.38 106.92,70.63 106.92,71.34 106.82,71.44 105.86,71.44
+3VS_WLAN on TOP (solid shape): 265.65,4.56 265.65,3.27 265.55,3.17 264.43,3.17 264.38,3.21 264.38,3.31 264.39,3.32 264.39,4.54 264.56,4.72 265.49,4.72
+3VS_WLAN on BOTTOM (solid shape): 263.18,8.6 263.18,7.94 263.03,7.79 262.01,7.79 261.89,7.92 261.89,8.53 262.07,8.7 263.08,8.7
+3VS_WLAN on BOTTOM (solid shape): 261.96,11.57 261.96,10.97 261.96,10.96 261.96,10.81 261.88,10.74 261.27,10.74 261.22,10.75 261.17,10.76 261.14,10.79 260.77,10.79 260.67,10.89 260.67,11.55 260.82,11.7 261.84,11.7
+3VS_WLAN on BOTTOM (solid shape): 249.85,8.7 252.67,8.7 252.86,8.51 252.86,8.09 252.56,7.79 251.27,7.79 250.58,7.1 248.02,7.1 247.92,7.21 247.92,9.06 248.12,9.26 249.29,9.26
+3VS_WLAN on IN1 (solid shape): 259.81,11.81 259.81,10.56 259.67,10.42 258.92,10.42 258.56,10.78 258.55,10.84 258.53,10.9 258.53,11.79 258.8,12.06 259.56,12.06
+3VS_WLAN on IN1 (solid shape): outline of 254 points within 261.53,2.99 271.87,18.72
+3VS_WLAN on IN3 (solid shape): 265.72,4.75 265.72,3.83 265.26,3.36 264.44,3.36 264.32,3.48 264.32,4.23 264.99,4.9 265.57,4.9
+3VS_WLAN on TOP: 267.17,17.04 267.17,16.27 267.25,16.2 268.16,16.2 268.39,16.43 268.39,17.06 268.24,17.21 267.35,17.21
+3VS_WLAN on TOP: 263.01,7.1 263.08,7.18 263.08,7.84 262.89,8.03 261.66,8.03 261.58,7.96 261.58,7.14 261.62,7.1
+3VS_WLAN on TOP: 261.49,15.97 261.49,17.28 262.11,17.89 262.61,17.89 262.75,17.75 262.75,17.06 262.59,16.9 262.28,16.9 262.18,16.8 262.18,16.07 261.96,15.85 261.61,15.85
+3VS_WLAN on TOP: 259.02,10.41 259.02,12.34 259.17,12.49 259.7,12.49 259.81,12.39 259.81,10.41
+3VS_WLAN on BOTTOM: 263.84,5.25 264.43,5.25 264.66,5.02 264.66,4.77 265.27,4.16 265.27,3.32 265.14,3.19 264.07,3.19 263.64,3.62 263.64,5.05
+3VS_WLAN on IN3: 252.38,8.52 254.62,10.75 258.26,10.75 258.55,11.05 258.55,11.84 259.04,12.34 260.92,12.34 262.16,11.1 262.16,9.59 262.42,9.59 262.42,9.58 262.84,9.17 262.84,6.9 262.61,6.68 261.9,6.68 261.76,6.82 261.76,7.03 261.07,7.71 253.76,7.71 253.2,7.16 252.57,7.16 252.38,7.34
+3VS_WLAN_MCU on TOP: 258.66,13.58 261.05,13.58 261.35,13.28 262.35,13.28 262.4,13.23 262.4,12.49 262.32,12.41 260.08,12.41 259.73,12.77 258.59,12.77 258.41,12.95 258.41,13.33
+3VS_WLAN_MCU on IN1: 260.11,13.05 261.3,13.05 264.17,10.18 264.17,8.37 264,8.2 263.18,8.2 262.98,8.4 262.98,9.85 260.64,12.18 260.14,12.18 259.98,12.34 259.98,12.92
+3VS_WLAN_R on BOTTOM (solid shape): 266.54,3.4 266.54,2.28 266.1,1.85 266.1,1.85 265.92,1.66 264.31,1.66 264.15,1.82 264.15,2.55 264.21,2.61 265.21,2.61 265.26,2.66 265.26,3.01 265.7,3.45 265.72,3.47 266.46,3.47
+5VALW on BOTTOM (solid shape): 34,30.04 34,27.75 33.87,27.63 32.22,27.63 32.09,27.75 32.09,30.04 32.35,30.29 33.75,30.29
+5VALW on BOTTOM (solid shape): 27.51,9.27 27.51,8.91 27.6,8.83 28.03,8.83 28.16,8.7 28.16,6.55 28.16,6.54 28.16,5.99 28.13,5.99 28.13,5.22 28.16,5.22 28.16,4.54 28.54,4.16 28.54,3.5 28.41,3.37 27.52,3.37 27.4,3.5 26.32,3.5 25.95,3.86 25.95,5.66 26.5,5.66 26.5,6.41 25.95,6.41 25.95,6.87 26.5,6.87 26.5,7.62 25.95,7.62 25.95,8.53 26.25,8.83 26.76,8.83 26.91,8.98 26.91,9.29 27.05,9.42 27.37,9.42
+5VALW on IN2 (solid shape): 33.49,29.91 33.49,28.01 32.98,27.5 32.35,27.5 32.09,27.75 32.09,29.79 32.35,30.04 33.36,30.04
+5VALW on IN3 (solid shape): 28.41,8.7 28.41,1.47 28.28,1.34 27.01,1.34 26.89,1.47 26.89,6.93 26,7.82 26,8.7 26.13,8.83 28.28,8.83
+5VALW on BOTTOM: 26.76,2.61 28.36,2.61 28.44,2.53 28.44,1.57 28.33,1.47 27.17,1.47 26.56,2.08 26.56,2.41

# Allegro board LAH811PR10-1121.brd (continued)
## Nets (continued)
GND: C37.2 C38.2 C41.2 C42.2 C46.2 C47.2 C48.2 C49.2 C50.2 C52.2 C58.2 C87.2 C92.2 C94.2 C95.2 C96.2 C97.2 C100.2 C112.2 C200.1 C216.2 C217.2 C218.2 C220.2 C227.2 C229.2 C230.2 C233.2 C234.2 C235.2 C237.2 C245.2 C246.2 C248.2 C252.2 C256.2 C276.2 C278.2 C285.2 C418.2 C419.2 C420.2 C421.2 C422.2 C451.2 C452.2 C453.2 C454.2 C455.2 C622.2 C628.2 C640.2 C750.2 C760.1 C761.1 C800.2 C801.2 C1040.2 C1124.1 C1125.1 C1131.2 C1132.2 C1223.2 C1387.2 C1467.2 C1468.2 C1469.2 C1539.2 C1540.2 C1544.2 C2990.2 C3011.1 C3315.2 C4180.2 C4181.1 C4182.1 C4183.2 C4186.2 C4189.2 C4195.2 C4197.2 C4198.2 C4199.2 C4201.2 C4202.2 C4203.2 C4204.2 C4205.2 C4207.2 C4212.2 C4213.2 C4216.2 C4217.2 C4221.2 C4222.2 C4227.2 C4230.2 C4232.1 C4233.2 C4234.2 C4235.2 C4236.2 C4237.2 C4238.2 C4239.2 C4240.2 C4241.2 C4245.2 C4247.2 CA1.2 CA13.2 CA26.2 CA30.2 CA32.2 CA33.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA46.2 CA47.2 CA48.2 CA52.2 CA54.2 CA55.2 CA57.2 CA64.2 CA78.1 CA79.1 CA80.1 CA81.1 CA82.1 CA83.1 CA86.2 CA87.2 CA90.2 CA91.2 CA92.2 CA93.2 CA94.2 CA97.2 CA98.2 CA99.2 CA100.2 CA101.1 CA102.1 CA103.2 CA104.2 CA105.2 CA106.2 CA107.2 CA108.2 CA109.2 CA110.2 CA111.2 CA112.2 CA113.2 CA114.2 CA115.2 CA116.2 CA117.1 CA118.1 CC1.2 CC17.2 CC23.2 CC30.2 CC77.1 CC129.2 CC130.2 CC131.2 CC132.2 CC133.2 CC134.2 CC135.2 CC136.2 CC137.2 CC138.2 CC139.2 CC140.2 CC141.2 CC142.2 CC144.2 CC145.2 CC147.2 CC148.2 CC153.2 CC154.2 CC155.2 CC156.2 CC164.2 CC167.1 CC168.1 CC170.2 CC171.2 CC173.2 CC174.2 CC175.2 CC176.2 CC177.2 CC180.2 CC181.2 CC182.2 CC183.2 CC184.2 CC185.2 CC188.2 CC189.2 CC191.2 CC260.2 CC308.2 CC386.2 CC394.2 CC395.2 CC511.2 CC620.2 CC621.2 CC622.2 CC625.2 CC629.2 CC632.2 CC633.2 CC638.2 CC643.2 CC644.2 CC645.2 CC646.2 CC647.2 CC648.2 CC649.2 CC650.2 CC651.2 CC652.1 CC653.2 CC654.2 CC655.2 CC656.2 CC657.2 CC658.2 CC659.2 CC660.2 CC661.2 CC662.2 CC663.2 CC664.2 CC665.2 CC666.2 CC667.2 CC668.2 CC707.2 CC721.2 CC727.2 CC735.2 CC736.2 CC737.2 CC738.2 CC739.2 CC740.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD303.2 CD304.2 CD305.2 CD306.2 CD307.2 CD308.2 CD309.2 CD310.2 CD311.2 CD312.2 CD313.2 CD314.2 CD315.2 CD316.2 CD317.2 CD318.2 CD319.2 CD320.2 CD321.2 CE42.2 CE43.2 CE44.2 CE45.2 CE46.2 CE49.2 CE50.2 CE51.2 CE52.2 CE53.2 CE54.2 CE56.2 CE61.2 CE63.2 CE64.2 CE65.2 CE66.2 CE68.1 CE79.1 CE88.2 CE89.2 CE104.2 CE105.2 CE106.2 CE107.2 CE108.2 CE109.2 CE312.2 CE413.2 CE429.2 CE430.2 CE432.2 CH10.1 CH11.1 CH12.2 CH13.2 CH35.2 CH40.2 CH46.2 CH47.1 CH48.2 CH49.2 CH50.2 CH51.2 CH52.1 CH53.1 CH54.1 CH55.1 CH56.1 CH57.1 CLIP5.1(TP-1) CLIP6.1(TP-1) CLIP7.1(TP-1) CM1.1 CM2.1 CP10.2 CPD1.2 CPD2.2 CPD3.2 CPD4.2 CPD5.2 CPD6.2 CPD7.2 CPD8.2 CPD11.2 CPD12.2 CPD13.2 CPD14.2 CPD16.2 CPD17.2 CPD18.2 CPD19.1 CPD40.1 CPD41.2 CPD42.2 CPD47.1 CPD48.1 CPD49.2 CPD51.2 CR5.2 CR6.2 CR7.2 CR8.2 CR9.1 CR10.2 CR11.2 CR13.2 CR15.2 CR16.2 CR17.2 CR18.2 CR19.2 CR20.2 CR21.2 CR22.2 CR23.2 CR24.2 CR25.1 CS89.2 CS90.2 CS91.2 CS92.2 CS93.2 CS94.2 CS95.2 CT34.1 CT37.1 CT42.2 CT43.2 CT44.2 CT45.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT82.2 CT84.2 CT200.2 CT201.2 CT206.1 CT207.1 CT210.2 CT211.2 CT212.1 CT302.2 CT303.2 CT304.2 CT305.2 CT306.1 CT307.1 CT310.1 CT311.1 CT312.1 CT313.1 CT314.1 CT315.1 CT316.1 CT317.1 CT318.2 CT319.2 CT325.2 CT338.2 CT339.2 CT340.2 CT341.2 CT342.2 CT343.2 CT344.2 CT345.2 CT346.2 CT347.1 CT348.2 CT349.2 CT350.2 CT351.2 CT352.2 CT353.2 CT354.2 CT355.2 CT356.2 CT357.2 CT361.2 CT362.2 CT363.1 CT365.2 CT366.2 CV633.2 CV651.2 CW1.2 CW2.2 CW3.2 CW4.2 CW9.2 CW10.2 CW11.2 CW12.2 CW123.1 CW125.2 CW126.2 CW223.2 CW225.2 CW226.1 CW227.1 CW228.1 CZ1.2 CZ2.2 CZ3.2 D13.2 D14.2 D16.1 D75.2 D76.1 D77.2 D78.1 D79.2 D80.1 D81.2 D82.1 D83.2 D84.1 D85.2 D86.1 D87.2 D88.1 D89.2 D90.1 D407.2 D408.1 D409.2 D410.1 D411.2 D412.1 D413.2 D414.1 D415.2 D416.1 D417.2 D418.1 D419.1 D420.2 D421.1 D422.2 D459.2 D460.2 D461.2 D462.2 D465.1 D466.1 D469.2 D470.2 D471.1 D482.1 D483.1 D484.2 D485.2 D486.1 DA1.2 DA3.2 DA4.2 DA5.2 DA8.1 DA9.1 DA11.2 DA13.2 DA14.1 DA15.1 DA16.2 DA17.2 DA18.2 DA19.2 H1.1(TP-1) H2.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H15.1(TP-1) H16.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) HCPU1.1(TP-1) HCPU2.1(TP-1) HCPU3.1(TP-1) HCPU4.1(TP-1) HSSD1.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JBATT1.8 JBATT1.9 JBATT1.10 JBATT1.11 JBATT1.12 JBATT1.13 JBATT1.14 JDB1.6 JDB1.11 JDB1.12 JDB2.6 JDB2.11 JDB2.12 JDB3.6 JDB3.7 JDB3.8 JDB4.6 JDB4.7 JDB4.8 JDEBUG1.5 JDEBUG1.8 JDEBUG1.11 JDEBUG1.12 JDEBUG2.9 JDEBUG2.11 JDEBUG2.12 JDEG1.10 JDEG1.11 JDEG1.12 JEDP1.13 JEDP1.14 JEDP1.19 JEDP1.20 JEDP1.25 JEDP1.26 JEDP1.31 JEDP1.32 JEDP1.38 JEDP1.46 JEDP1.47 JEDP1.48 JEDP1.49 JEDP1.50 JEDP1.51 JEDP1.52 JEDP1.53 JEDP1.54 JEDP1.55 JEDP1.56 JEDP1.57 JEDP1.58 JEDP1.59 JEDP1.60 JEDP1.61 JEDP1.62 JEDP1.63 JEDP1.64 JEDP1.65 JEDP1.66 JEDP1.67 JEDP1.68 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JFP1.4 JFP1.9 JFP1.10 JIO1.1 JIO1.5 JIO1.6 JIO1.7 JIO1.19 JIO1.20 JIO1.24 JIO1.25 JIO1.26 JIO1.46 JIO1.47 JMIPI60.14 JMIPI60.16 JMIPI60.57 JMIPI60.58 JMIPI60.60 JMIPI60.61 JMIPI60.62 JMIPI60.63 JMIPI60.64 JNGFF1.1 JNGFF1.3 JNGFF1.9 JNGFF1.15 JNGFF1.21 JNGFF1.27 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.71 JNGFF1.73 JNGFF1.75 JNGFF1.76 JNGFF1.77 JP1.6 JP1.12 JP1.15 JP1.18 JP1.19 JP1.20 JP1.21 JP1.22 JSPI1.10 JSPI1.11 JSPI1.12 JSPK1.4 JSPK1.5 JSPK1.6 JSPK2.4 JSPK2.5 JSPK2.6 JTAG2.2 JTP1.4 JTP1.9 JTP1.10 JUART1.5 JUART1.6 JUFC1.6 JUFC1.11 JUFC1.12 JUFC1.18 JUFC1.36 JUFC1.42 JUFC1.44 JUFC1.46 JUFC1.47 JUFC1.48 JUFC1.49 JUFC1.50 JUFC1.51 JUFC1.52 JUFC1.53 JUFC1.54 JUFC1.55 JUFC1.56 JUFC1.57 JUFC1.58 JUFC1.59 JUFC1.60 JUFC1.61 JUFC1.62 JUFC1.63 JUFC1.64 JUFC1.65 JUFC1.66 JUFC1.67 JUFC1.68 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 JUSBC2.5 JUSBC2.6 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JWLA1.3 JWLA1.5 JWLA1.6 JWLA2.3 JWLA2.5 JWLA2.6 PC132.2 PC133.2 PC134.2 PC135.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC207.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC223.2 PC224.2 PC226.2 PC227.1 PC228.2 PC229.1 PC231.2 PC232.2 PC233.2 PC234.2 PC235.2 PC236.2 PC237.2 PC238.1 PC240.2 PC241.2 PC243.2 PC244.2 PC245.2 PC246.2 PC247.2 PC249.2 PC335.2 PC336.2 PC337.2 PC338.2 PC339.2 PC340.2 PC341.2 PC342.1 PC344.2 PC345.2 PC346.2 PC347.2 PC348.2 PC349.2 PC350.2 PC351.2 PC401.2 PC402.2 PC403.2 PC404.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC412.2 PC414.2 PC415.2 PC417.2 PC418.2 PC419.2 PC420.2 PC422.2 PC423.2 PC424.2 PC425.2 PC426.2 PC428.2 PC430.2 PC431.2 PC432.2 PC433.2 PC501.2 PC502.2 PC503.2 PC504.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC512.2 PC600.2 PC701.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.2 PC713.2 PC714.2 PC715.2 PC750.2 PC751.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC900.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC911.2 PC912.2 PC1000.2 PC1001.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1100.2 PC1101.2 PC1102.2 PC1104.2 PC1105.1 PC1106.2 PC1107.2 PC1108.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1206.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1219.2 PC1221.2 PC1222.2 PC1223.2 PC1300.2 PC1301.2 PC1302.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PD104.1 PD105.1 PD200.2 PQ100.1 PQ100.4 PQ201.3 PQ201.4 PQ201.5 PQ203.3 PQ203.4 PQ203.5 PQ205.3 PQ600.3 PR110.1 PR185.2 PR204.2 PR212.1 PR224.1 PR225.2 PR226.2 PR227.2 PR232.2 PR303.2 PR306.1 PR400.1 PR401.1 PR409.2 PR411.2 PR412.1 PR413.1 PR421.2 PR423.2 PR504.2 PR604.2 PR605.2 PR607.1 PR704.2 PR706.1 PR707.2 PR805.2 PR901.1 PR906.2 PR907.2 PR908.2 PR1100.2 PR1101.2 PR1106.2 PR1115.2 PR1126.1 PR1133.2 PR1134.2 PR1300.2 PU200.33 PU302.2 PU302.10 PU400.2 PU400.4 PU400.5 PU400.6 PU400.7 PU401.2 PU401.4 PU401.5 PU401.6 PU401.7 PU500.2 PU500.3 PU500.4 PU500.9 PU600.4 PU600.6 PU700.2 PU700.4 PU800.2 PU800.3 PU800.4 PU800.9 PU900.1 PU900.3 PU900.4 PU900.19 PU1100.29 PU1200.5 PU1200.6 PU1200.7 PU1200.13 PU1201.5 PU1201.6 PU1201.7 PU1201.13 Q3.3 Q16.1 Q16.4 Q348.3 QC2.1 QC2.4 QC5.1 QC5.4 QE18.1 QE18.4 QE19.3 QE23.3 QE26.1 QE26.4 QM1.1 QM1.4 QR1.3 QV19.3 QV21.3 QW1.3 QZ11.3 R25.2 R29.2 R31.1 R32.2 R137.1 R140.1 R141.1 R142.1 R143.1 R144.1 R145.1 R146.1 R147.1 R148.1 R149.1 R150.1 R151.1 R152.1 R153.1 R154.1 R155.1 R374.1 R529.2 R600.1 R614.1 R623.2 R624.2 R660.1 R667.1 R677.2 R789.2 R2745.2 R6137.1 R6143.2 R6162.1 R6194.1 R6212.1 RA21.2 RA22.1 RA23.1 RA25.1 RA30.2 RA57.1 RA82.1 RC2.1 RC3.2 RC8.2 RC12.2 RC13.2 RC14.2 RC15.2 RC16.2 RC17.2 RC20.2 RC145.2 RC180.2 RC201.2 RC344.2 RC434.1 RC508.2 RC595.1 RC611.1 RC612.1 RC615.2 RC626.2 RC648.1 RC691.1 RC693.1 RC700.2 RC701.2 RC711.2 RC712.2 RC735.2 RC737.2 RC738.2 RC739.2 RC751.1 RD26.2 RD28.2 RD30.2 RD32.2 RD34.2 RD36.2 RD38.2 RD40.2 RD44.1 RD300.2 RE14.1 RE21.2 RE29.2 RE48.2 RE95.1 RE154.1 RE157.1 RE159.2 RE160.1 RE164.2 RE199.2 RE205.2 RE312.2 RE472.1 RE473.1 RE475.1 RE480.2 RE520.2 RE525.1 RE528.1 RH4.2 RH5.2 RH6.2 RH7.2 RH8.2 RH9.2 RH10.2 RH11.2 RH13.1 RH46.2 RH98.2 RH114.2 RH129.2 RH139.2 RH142.2 RH145.2 RH185.2 RH298.2 RH300.1 RH475.2 RH575.2 RH591.2 RH617.2 RH630.2 RH636.2 RH641.2 RH661.2 RH665.2 RH671.2 RH675.2 RH682.1 RH683.1 RH684.1 RH685.1 RH686.1 RH687.1 RH688.1 RH689.1 RH690.1 RH691.1 RH717.2 RH718.2 RH728.2 RH740.2 RH741.2 RH749.2 RM9.2 RM10.2 RM11.2 RM12.2 RPD88.2 RPD89.2 RPD91.2 RPD97.2 RPD100.2 RPD101.2 RPD128.2 RPD136.2 RPD167.2 RPD169.2 RPD177.2 RPD181.1 RPD182.1 RPD189.2 RPD190.2 RPD191.2 RPD192.2 RPD193.2 RR1.1 RT1.1 RT2.1 RT3.1 RT4.1 RT6.2 RT7.1 RT9.2 RT10.2 RT11.2 RT14.2 RT15.2 RT17.2 RT30.1 RT33.2 RT34.2 RT36.2 RT39.2 RT40.2 RT101.1 RT102.1 RT118.2 RT119.2 RT120.2 RT121.2 RT122.2 RT123.2 RT150.2 RT151.2 RT158.2 RT179.2 RT190.2 RT193.2 RT194.2 RT195.2 RT196.2 RTCR4.2 RW30.2 RW33.2 RW53.1 RW227.1 RW1237.2 SW1.2 SW1.4 U7.2 U15.3 U31.11 U31.15 U34.5 U34.9 U36.5 U36.9 U55.2 U60.5 U60.9 U712.2 U712.16 U712.23 U712.32 U712.33 U713.5 U713.9 U714.2 UA1.49 UA2.2 UA2.10 UA2.15 UA2.16 UA2.19 UA3.2 UA3.10 UA3.15 UA3.16 UC1.A3 UC1.A11 UC1.A16 UC1.A17 UC1.A31 UC1.A34 UC1.A36 UC1.A39 UC1.A42 UC1.A44 UC1.A46 UC1.A48 UC1.A49 UC1.AA45 UC1.AA47 UC1.AB3 UC1.AB5 UC1.AB6 UC1.AB11 UC1.AB38 UC1.AB39 UC1.AB41 UC1.AB42 UC1.AB43 UC1.AC45 UC1.AC49 UC1.AD10 UC1.AD11 UC1.AD34 UC1.AD37 UC1.AE6 UC1.AF37 UC1.AF45 UC1.AF47 UC1.AG1 UC1.AG3 UC1.AG5 UC1.AG9 UC1.AG11 UC1.AG38 UC1.AG39 UC1.AG41 UC1.AG42 UC1.AG43 UC1.AH2 UC1.AH37 UC1.AH45 UC1.AH49 UC1.AJ2 UC1.AJ3 UC1.AK37 UC1.AL2 UC1.AL6 UC1.AL45 UC1.AL47 UC1.AM2 UC1.AM37 UC1.AN2 UC1.AN6 UC1.AN38 UC1.AN39 UC1.AN41 UC1.AN42 UC1.AN43 UC1.AN45 UC1.AN49 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR7 UC1.AR9 UC1.AR11 UC1.AT3 UC1.AT5 UC1.AT6 UC1.AT7 UC1.AT45 UC1.AT47 UC1.AU37 UC1.AV3 UC1.AV7 UC1.AV11 UC1.AV38 UC1.AV39 UC1.AV41 UC1.AV42 UC1.AV43 UC1.AV45 UC1.AV49 UC1.AY3 UC1.AY7 UC1.B2 UC1.B3 UC1.B17 UC1.B21 UC1.B24 UC1.B31 UC1.B48 UC1.BA1 UC1.BA2 UC1.BA45 UC1.BA47 UC1.BB3 UC1.BB7 UC1.BB11 UC1.BC37 UC1.BD3 UC1.BD5 UC1.BD6 UC1.BD7 UC1.BD38 UC1.BD39 UC1.BD41 UC1.BD42 UC1.BD43 UC1.BD45 UC1.BD49 UC1.BE1 UC1.BE2 UC1.BF3 UC1.BF7 UC1.BF45 UC1.BF47 UC1.BG3 UC1.BG7 UC1.BG41 UC1.BH37 UC1.BJ1 UC1.BJ2 UC1.BJ3 UC1.BJ7 UC1.BJ41 UC1.BJ43 UC1.BJ45 UC1.BJ49 UC1.BM3 UC1.BM5 UC1.BM6 UC1.BM7 UC1.BM11 UC1.BM45 UC1.BM47 UC1.BP1 UC1.BP2 UC1.BP3 UC1.BP7 UC1.BP43 UC1.BR45 UC1.BR49 UC1.BT3 UC1.BT7 UC1.BT39 UC1.BT41 UC1.BT42 UC1.BT43 UC1.BU45 UC1.BU47 UC1.BV1 UC1.BV2 UC1.BV3 UC1.BV7 UC1.BV11 UC1.BW3 UC1.BW5 UC1.BW6 UC1.BW7 UC1.BW37 UC1.BY37 UC1.BY45 UC1.BY49 UC1.C6 UC1.C11 UC1.C13 UC1.C14 UC1.C16 UC1.C17 UC1.C21 UC1.C24 UC1.C31 UC1.C34 UC1.C39 UC1.C48 UC1.C49 UC1.CA3 UC1.CA7 UC1.CA38 UC1.CA41 UC1.CA42 UC1.CA43 UC1.CB37 UC1.CB45 UC1.CB47 UC1.CC3 UC1.CC7 UC1.CE9 UC1.CE37 UC1.CE45 UC1.CE49 UC1.CG9 UC1.CG37 UC1.CG39 UC1.CG43 UC1.CG45 UC1.CG47 UC1.CH3 UC1.CH5 UC1.CJ9 UC1.CJ37 UC1.CJ42 UC1.CK9 UC1.CK45 UC1.CK49 UC1.CL37 UC1.CL42 UC1.CL49 UC1.CM9 UC1.CM45 UC1.CM47 UC1.CN3 UC1.CN5 UC1.CN37 UC1.CN39 UC1.CP9 UC1.CR32 UC1.CR37 UC1.CR45 UC1.CR49 UC1.CT9 UC1.CT37 UC1.CT39 UC1.CT42 UC1.CU45 UC1.CU47 UC1.CU49 UC1.CV3 UC1.CV5 UC1.CV9 UC1.CV34 UC1.CV35 UC1.CY9 UC1.CY41 UC1.CY45 UC1.CY49 UC1.D13 UC1.D17 UC1.D31 UC1.D44 UC1.D49 UC1.DA9 UC1.DA10 UC1.DA33 UC1.DB32 UC1.DB35 UC1.DB38 UC1.DB45 UC1.DB47 UC1.DB49 UC1.DC3 UC1.DC5 UC1.DC6 UC1.DC49 UC1.DD37 UC1.DD42 UC1.DE6 UC1.DE10 UC1.DE13 UC1.DE15 UC1.DE17 UC1.DE18 UC1.DE20 UC1.DE22 UC1.DE23 UC1.DE26 UC1.DE28 UC1.DE29 UC1.DE33 UC1.DE45 UC1.DF13 UC1.DF22 UC1.DF28 UC1.DF33 UC1.DF35 UC1.DF39 UC1.DG6 UC1.DG10 UC1.DG12 UC1.DG13 UC1.DG15 UC1.DG22 UC1.DG23 UC1.DG47 UC1.DH1 UC1.DH3 UC1.DH5 UC1.DH45 UC1.DJ19 UC1.DJ21 UC1.DJ27 UC1.DJ31 UC1.DJ33 UC1.DJ36 UC1.DJ42 UC1.DK3 UC1.DK4 UC1.DK6 UC1.DK8 UC1.DK49 UC1.DL10 UC1.DL13 UC1.DL44 UC1.DL47 UC1.DM47 UC1.DN15 UC1.DN19 UC1.DN24 UC1.DN31 UC1.DN36 UC1.DN42 UC1.DP45 UC1.DR49 UC1.DT1 UC1.DT3 UC1.DT6 UC1.DT7 UC1.DT8 UC1.DT10 UC1.DT15 UC1.DT20 UC1.DT27 UC1.DT32 UC1.DT37 UC1.DT42 UC1.DT49 UC1.DU1 UC1.DU2 UC1.DU7 UC1.DU10 UC1.DU15 UC1.DU20 UC1.DU27 UC1.DU32 UC1.DU37 UC1.DU47 UC1.DU48 UC1.DU49 UC1.DV2 UC1.DV8 UC1.DV44 UC1.DV48 UC1.DW1 UC1.DW2 UC1.DW7 UC1.DW10 UC1.DW20 UC1.DW27 UC1.DW44 UC1.DW46 UC1.DW48 UC1.DW49 UC1.E6 UC1.E11 UC1.E34 UC1.E36 UC1.E39 UC1.E42 UC1.F8 UC1.F11 UC1.F31 UC1.F45 UC1.F47 UC1.G3 UC1.G5 UC1.G21 UC1.G24 UC1.G31 UC1.G36 UC1.G49 UC1.H17 UC1.H21 UC1.H24 UC1.H31 UC1.H33 UC1.H36 UC1.H45 UC1.H49 UC1.J6 UC1.J10 UC1.J13 UC1.J15 UC1.J16 UC1.J36 UC1.K8 UC1.K11 UC1.K15 UC1.K33 UC1.L36 UC1.L39 UC1.L41 UC1.L42 UC1.L43 UC1.L45 UC1.L47 UC1.M3 UC1.M5 UC1.M10 UC1.M36 UC1.N45 UC1.N49 UC1.P8 UC1.P11 UC1.P41 UC1.R3 UC1.R37 UC1.T11 UC1.T36 UC1.T41 UC1.T43 UC1.T45 UC1.T47 UC1.U3 UC1.U5 UC1.U37 UC1.V9 UC1.V11 UC1.V36 UC1.V45 UC1.V49 UC1.W37 UC1.Y9 UC1.Y36 UC1.Y38 UC1.Y43 UC2.3 UC4.3 UC5.3 UC6.3 UC7.3 UC8.2 UC9.3 UC10.3 UC11.2 UC12.5 UC13.5 UC22.5 UC23.5 UC24.5 UC24.9 UC25.5 UC25.9 UC27.5 UC28.5 UC28.9 UC29.3 UC30.5 UC30.9 UC31.2 UCR1.33 UD1.A3 UD1.A10 UD1.AB3 UD1.AB5 UD1.AB8 UD1.AB10 UD1.C1 UD1.C3 UD1.C5 UD1.C8 UD1.C10 UD1.C12 UD1.D2 UD1.D4 UD1.D9 UD1.D11 UD1.E1 UD1.E5 UD1.E8 UD1.E12 UD1.G1 UD1.G3 UD1.G5 UD1.G8 UD1.G10 UD1.G12 UD1.J1 UD1.J3 UD1.J10 UD1.J12 UD1.K2 UD1.K4 UD1.K9 UD1.K11 UD1.N2 UD1.N4 UD1.N9 UD1.N11 UD1.P1 UD1.P3 UD1.P10 UD1.P12 UD1.T1 UD1.T3 UD1.T5 UD1.T8 UD1.T10 UD1.T12 UD1.V1 UD1.V5 UD1.V8 UD1.V12 UD1.W2 UD1.W4 UD1.W9 UD1.W11 UD1.Y1 UD1.Y3 UD1.Y5 UD1.Y8 UD1.Y10 UD1.Y12 UD2.A3 UD2.A10 UD2.AB3 UD2.AB5 UD2.AB8 UD2.AB10 UD2.C1 UD2.C3 UD2.C5 UD2.C8 UD2.C10 UD2.C12 UD2.D2 UD2.D4 UD2.D9 UD2.D11 UD2.E1 UD2.E5 UD2.E8 UD2.E12 UD2.G1 UD2.G3 UD2.G5 UD2.G8 UD2.G10 UD2.G12 UD2.J1 UD2.J3 UD2.J10 UD2.J12 UD2.K2 UD2.K4 UD2.K9 UD2.K11 UD2.N2 UD2.N4 UD2.N9 UD2.N11 UD2.P1 UD2.P3 UD2.P10 UD2.P12 UD2.T1 UD2.T3 UD2.T5 UD2.T8 UD2.T10 UD2.T12 UD2.V1 UD2.V5 UD2.V8 UD2.V12 UD2.W2 UD2.W4 UD2.W9 UD2.W11 UD2.Y1 UD2.Y3 UD2.Y5 UD2.Y8 UD2.Y10 UD2.Y12 UD3.A3 UD3.A10 UD3.AB3 UD3.AB5 UD3.AB8 UD3.AB10 UD3.C1 UD3.C3 UD3.C5 UD3.C8 UD3.C10 UD3.C12 UD3.D2 UD3.D4 UD3.D9 UD3.D11 UD3.E1 UD3.E5 UD3.E8 UD3.E12 UD3.G1 UD3.G3 UD3.G5 UD3.G8 UD3.G10 UD3.G12 UD3.J1 UD3.J3 UD3.J10 UD3.J12 UD3.K2 UD3.K4 UD3.K9 UD3.K11 UD3.N2 UD3.N4 UD3.N9 UD3.N11 UD3.P1 UD3.P3 UD3.P10 UD3.P12 UD3.T1 UD3.T3 UD3.T5 UD3.T8 UD3.T10 UD3.T12 UD3.V1 UD3.V5 UD3.V8 UD3.V12 UD3.W2 UD3.W4 UD3.W9 UD3.W11 UD3.Y1 UD3.Y3 UD3.Y5 UD3.Y8 UD3.Y10 UD3.Y12 UD4.A3 UD4.A10 UD4.AB3 UD4.AB5 UD4.AB8 UD4.AB10 UD4.C1 UD4.C3 UD4.C5 UD4.C8 UD4.C10 UD4.C12 UD4.D2 UD4.D4 UD4.D9 UD4.D11 UD4.E1 UD4.E5 UD4.E8 UD4.E12 UD4.G1 UD4.G3 UD4.G5 UD4.G8 UD4.G10 UD4.G12 UD4.J1 UD4.J3 UD4.J10 UD4.J12 UD4.K2 UD4.K4 UD4.K9 UD4.K11 UD4.N2 UD4.N4 UD4.N9 UD4.N11 UD4.P1 UD4.P3 UD4.P10 UD4.P12 UD4.T1 UD4.T3 UD4.T5 UD4.T8 UD4.T10 UD4.T12 UD4.V1 UD4.V5 UD4.V8 UD4.V12 UD4.W2 UD4.W4 UD4.W9 UD4.W11 UD4.Y1 UD4.Y3 UD4.Y5 UD4.Y8 UD4.Y10 UD4.Y12 UE1.A6 UE1.A13 UE1.C4 UE1.E6 UE1.H4 UE6.1 UE6.4 UE6.6 UE8.3 UH1.3 UH6.3 UH8.4 UH8.9 ULID1.1 UM1.5 UM1.21 UM2.5 UM2.21 UPD1.20 UPD1.45 UPD1.46 UPD1.47 UPD1.51 UPD1.59 UPD2.20 UPD2.45 UPD2.46 UPD2.47 UPD2.51 UPD2.59 UPD3.4 UPD3.9 UPD4.4 UPD4.9 URT1.A11 URT1.B1 URT1.B2 URT1.B11 URT1.B12 URT1.D1 URT1.D2 URT1.D11 URT1.D12 URT1.F1 URT1.F2 URT1.F3 URT1.F5 URT1.F7 URT1.F9 URT1.F11 URT1.F12 URT1.G5 URT1.G7 URT1.H1 URT1.H2 URT1.H11 URT1.H12 URT1.J9 URT1.K1 URT1.K2 URT1.K11 URT1.K12 URT1.L12 URT1.M2 URT1.M3 URT1.M12 URT2.A11 URT2.B1 URT2.B2 URT2.B11 URT2.B12 URT2.D1 URT2.D2 URT2.D11 URT2.D12 URT2.F1 URT2.F2 URT2.F3 URT2.F5 URT2.F7 URT2.F9 URT2.F11 URT2.F12 URT2.G5 URT2.G7 URT2.H1 URT2.H2 URT2.H11 URT2.H12 URT2.J9 URT2.K1 URT2.K2 URT2.K11 URT2.K12 URT2.L12 URT2.M2 URT2.M3 URT2.M12 US1.5 US1.9 UT1.5 UT1.9 UT2.5 UT2.9 UT3.5 UT3.9 UTS1.4 UTS1.9 UTS2.4 UTS2.9 UW1.19 UW1.25 UWL1.6 UWL1.17 UWL1.20 UWL1.23 UWL1.26 UWL1.32 UWL1.35 UWL1.38 UWL1.41 UWL1.62 UWL1.68 UWL1.71 UWL1.74 UWL1.75 UWL1.76 UWL1.77 UWL1.78 UWL1.79 UWL1.80 UWL1.81 UWL1.82 UWL1.83 UWL1.84 UWL1.85 UWL1.86 UWL1.87 UWL1.88 UWL1.89 UWL1.90 UWL1.91 UWL1.92 UWL1.93 UWL1.94 UWL1.95 UWL1.96 UWL1.A07 UWL1.A15 UWL1.A26 UWL1.A31 UWL1.A50 UWL1.G1 UWL1.G2 UWL1.G3 UWL1.G4 UWL1.G5 UWL1.G6 UWL1.G7 UWL1.G8 UWL1.G9 UWL1.G10 UWL1.G11 UWL1.G12 UZ6.3 YH1.2 YH1.4 YT1.2 YT1.4 YT2.2 YT2.4
V3.3A_CPU_NOA_LA_VAL: JMIPI60.52 R138.2
VCC1P8A_EN: RC226.2 UC22.4
VCC_3V: PC335.1 PU302.9
VCC_SFR_OC_EN: RC640.2 UC27.4
VCCDSW_EN: CE108.1 RC697.1 UE1.M7
VCCDSW_EN_GPIO: DC1.2 R374.2 R375.2 RC651.1 RC657.1 RC697.2
VCCDSW_EN_Q: DC1.1 DC2.2 RC698.1
VCCIN_AUX_CORE_VID: RC624.2 RC735.1 UC9.2
VCCIN_AUX_VCCSENSE: PR903.2 PR915.2 RC685.1
VCCIN_AUX_VCCSENSE_R: RC685.2 UC1.BF9
VCCIN_AUX_VCCSENSE_VR: PR915.1 PU900.16
VCCIN_AUX_VR_PG: D474.1 PU900.9 RE461.2 RE488.1
VCCIN_AUX_VSSSENSE: PR906.1 PR916.2 RC686.1
VCCIN_AUX_VSSSENSE_R: RC686.2 UC1.BD9
VCCIN_AUX_VSSSENSE_VR: PR916.1 PU900.17
VCCIN_SENSE: PR1119.2 PR1122.1 RC683.2
VCCIN_SENSE_R: RC683.1 UC1.F17
VCCIN_SENSE_VR: PR1122.2 PU1100.6
VCCST_EN: RC627.2 UC13.4
VCCST_OVERRIDE: RH584.1 UC1.CE4
VCCST_OVERRIDE_R: QM1.5 RC615.1 RH584.2 RH586.2
VCCST_PWRGD: CC649.1 RC647.1 RH587.2 RH588.1 UE8.4
VCCST_PWRGD_CPU: RH587.1 UC1.CF2
VCCSTG_EN: RC634.2 RC636.2 RC640.1 UC12.4
VCCSTG_EN_MIPI: RC634.1 UC11.4
VCCSTG_EN_R: RC636.1 RC701.1 UC10.4 UC11.3
VCCSTPWRGOOD_TCSS: RH586.1 UC1.CE3
VDD: PC229.2 PR207.2 PR219.1 PU200.18
VDD18: PC1108.1 PU1100.11
VIN_AUX: PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PL902.2 PL903.2 PU900.2
VSSIN_SENSE: PR1124.1 PR1126.2 RC684.2
VSSIN_SENSE_R: RC684.1 UC1.G17
VSSIN_SENSE_VR: PR1124.2 PU1100.7
3.3_VCCST_OVERRIDE: QM1.6 RC617.2 UC7.2
32KHZ_OUT: CE105.1 UE1.F3
+BATT: JBATT1.1 JBATT1.2 JBATT1.3 PC134.1 PC135.1 PL102.2 PL103.2 PL104.2 PR185.1
+CAM_PWR: C1539.1 C4197.1 C4198.1 JUFC1.45 R6161.2
+CAM_PWR_R: R6161.1 U55.1
+CHG_SRC_20V: PC201.1 PC202.1 PC203.1 PC204.1 PC207.1 PC246.1 PC247.1 PQ201.2 PR200.4
+CHG_VIN_20V: CPD19.2 CPD40.2 CPD47.2 CPD48.2 PD200.1 PD201.2 PL200.1 PR206.1 UPD1.11 UPD1.12 UPD2.11 UPD2.12
+EC_DEBUG_VCC: JDEG1.1 RE200.1
+INV_PWR_SRC: C49.1 C50.1 C52.1 C58.1 C419.1 DV11.2 F3.1 JEDP1.43 TP128.1(TP-1)
+INV_PWR_SRC_R: C87.1 C1223.1 F3.2 Q15.1 Q15.2 Q15.5 Q15.6 R87.2 R931.1 R932.1
+LCDVDD: C38.1 C41.1 C46.1 C47.1 C48.1 C420.1 DV12.2 JEDP1.4 JEDP1.6 R24.2 R658.1 TP127.1(TP-1)
+LCDVDD_R: R24.1 U7.1
+P_VCC: F6.2 JUFC1.3
+P_VCC_R: F6.1 R6223.2 R6224.2
+PECI_VREF: CE56.1 RE147.1 UE1.J11
+RTC_CELL_VBAT: C4245.1 CE42.1 RE106.2 UE1.A2
+RTCVCC: C1040.1 Q349.1 R2751.1 R5768.1 RC696.2 RH64.2
+RTCVCC_R: C112.1 Q349.3 R2751.2 RE106.1 RE137.2 RE142.2 RE184.1 RE244.2 RH572.1 RH573.1 RTCD2.1 RTCD3.1 RTCD4.1 RTCD5.1
+SD_VDD1: CR21.1 CR25.2 JP1.4 UCR1.12
+SD_VDD2: CR22.1 CR24.1 JP1.10 UCR1.13
+TBT_L_SVR_IND: LT8.1 URT1.L1 URT1.M1
+TBT_R_SVR_IND: LT5.1 URT2.L1 URT2.M1
+TBT_VBUS_L: CT34.2 CT310.2 CT311.2 CT312.2 CT313.2 CT318.1 CT338.1 CT339.1 CT340.1 CT341.1 CT347.2 D459.1 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 LT11.1 LT13.1 TP110.1(TP-1)
+TBT_VBUS_L_PD: CPD42.1 CPD49.1 CT319.1 CT342.1 CT343.1 CT344.1 CT345.1 CT346.1 D461.1 LT11.2 LT13.2 RT150.1 UPD1.3 UPD1.4 UPD1.13 UPD1.14
+TBT_VBUS_R: C4227.1 CT37.2 CT314.2 CT315.2 CT316.2 CT317.2 CT348.1 CT349.1 CT350.1 CT351.1 CT357.1 D460.1 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 LT12.1 LT14.1 TP111.1(TP-1)
+TBT_VBUS_R_PD: CPD41.1 CPD51.1 CT325.1 CT352.1 CT353.1 CT354.1 CT355.1 CT356.1 D462.1 LT12.2 LT14.2 RT151.1 UPD2.3 UPD2.4 UPD2.13 UPD2.14
+UA2_VBAT: CA92.1 CA101.2 CA117.2 RA73.1 UA2.25
+UA3_VBAT: CA1.1 CA102.2 CA118.2 RA74.1 UA3.25
+VNN_BYPASS: RC648.2 UC1.CY34
+VR_CAP: CE64.1 UE1.C10 UE1.J1
A#: PR606.2 PR607.2 PU600.1
AC_DIS: PR223.1 UE1.H12
AC_DISC#: PR100.2 UE1.E13
AC_PRESENT: RH297.1 RH312.2 UE1.K8
AC_PRESENT_R: RH312.1 UC1.DE46
ACAV_IN: D481.1 PQ205.1 PR219.2 PR220.1 PR225.1 UE1.C7
ACC1_INT2#: JIO1.21 RC739.1 RC742.1 UC1.DW36
ADCIN1_L_PD: RPD91.1 RPD92.2 UPD1.6
ADCIN1_R_PD: RPD101.1 RPD102.2 UPD2.6
ADCIN2_L_PD: RPD90.2 RPD100.1 UPD1.10
ADCIN2_R_PD: RPD89.1 RPD99.2 UPD2.10
ALLSYS_PWRGD: D438.2 D474.2 D475.2 D487.2 LED1.1 RE1.1 RE448.2 RE464.1
ALLSYS_PWRGD_R: QE18.6 RE93.1 RE464.2
ALS_ALERT#: R6118.1 R6157.1 UC1.DU14
ALS_ALERT#_R: JUFC1.35 R6118.2 TP138.1(TP-1)
ALW_PWRGD_3V_5V: D438.1 DC2.1 R6204.1 RC702.2 RC703.2 RC704.2 UC2.2
ALWON: RE305.1 RE312.1 RE405.1 RE417.1 UE1.A5
ALWON_3VALW: CE312.1 PJTAG1.2 PR302.1 PR608.1 RE305.2
ALWON_5VALW: CE413.1 PJTAG2.2 PU400.15 RE405.2
ALWON_5VALWB: CE429.1 PU401.15 RE417.2
AMP_I2C_CLK: Q352.1 RA71.2 UA1.7 UA2.23 UA3.23
AMP_I2C_DAT: Q352.4 RA72.2 UA1.6 UA2.22 UA3.22
AMP_I2S_BCLK: RA76.1 UA1.10
AMP_I2S_BCLK_R: CA114.1 RA76.2 UA2.13 UA3.13
AMP_I2S_IN: CA116.1 RA78.1 UA1.8
AMP_I2S_IN_R: RA78.2 UA2.12 UA3.12
AMP_I2S_LRCK: RA75.1 UA1.12
AMP_I2S_LRCK_R: CA113.1 RA75.2 UA2.14 UA3.14
AMP_I2S_OUT: RA77.1 UA1.9
AMP_I2S_OUT_R: CA115.1 RA77.2 UA2.11 UA3.11
AUD_PWR_EN: R232.2 R600.2 U36.3 UC1.CE46 UC25.3
AUX_EN_WOWL: D23.3 R617.2 RE322.1 UE1.D3
B: PR601.2 PR608.2 PU600.2
B+: C1224.1 C3314.1 PC214.1 PC215.1 PC216.1 PC217.1 PC218.1 PC219.1 PC221.1 PC222.1 PC223.1 PC224.1 PD202.2 PL400.1 PL402.1 PL404.1 PL405.1 PL701.1 PL902.1 PL903.1 PL1202.1 PL1203.1 PL1204.1 PL1205.1 PQ203.2 PR211.1 PR218.2 PR307.1 PR308.1 PR511.1 PR603.1 PR806.1 Q15.4 QV18.3 QZ10.4 R87.1 R231.1 R5867.1 RA73.2 RA74.2 RC783.1 RD48.1
B+_1.1V_MEM: PC709.1 PC710.1 PC711.1 PC750.1 PL701.2 PU700.1
B+_3V: PC337.1 PC340.1 PC345.1 PC349.1 PR307.2 PR308.2 PU302.1
B+_CAM: JUFC1.43 RV75.2
B+_CAM_R: C3315.1 QZ10.1 QZ10.2 QZ10.5 QZ10.6 RV75.1
B+_FLAG: JIO1.3 R6222.2
B+_FLAG_R: PD600.2 PD601.2 PD602.2 PQ600.1 PR600.2 PU600.3 R6222.1
BAT1_LED#: JIO1.18 QZ20.3 RE102.2 UE1.D10
BAT1_LED#_Q: QE25.1 QZ20.2
BAT2_LED#: RE101.2 RE492.1 UE1.D11
BAT2_W_LED#: JIO1.9 RE492.2
BATBTN#: JIO1.17 PD602.1 RE137.1 UE1.B5
BATT_LED#_LV1: JIO1.16 RE100.2 UE1.F12
BATT_LED#_LV2: JIO1.14 RE99.2 UE1.G10
BATT_LED#_LV3: JIO1.12 RE98.2 UE1.C6
BATT_LED#_LV4: JIO1.10 RE97.2 UE1.J2
BATT_LED#_LV5: JIO1.8 RE96.2 UE1.M13
BC_CLK_ECE1117: JIO1.29 UE1.D13
BC_DAT_ECE1117: JIO1.30 RE130.2 UE1.D12
BC_INT#_ECE1117: JIO1.27 UE1.E2
BEEP: RA8.1 UE1.H11
BGPO0: TP58.1(TP-1) UE1.D6
BIA_PWM: C750.1 D3.1 LV1.1 R32.1
BIA_PWM_EC: D3.2 UE1.N1
BIA_PWM_R: JEDP1.1 LV1.2 TP120.1(TP-1)
BL_PWR_MONITOR: QV19.2 R627.1
BOARD_ID: C4240.1 RE194.2 UE1.J13
BST1_AUX: PR902.1 PU900.13
BST1_VCCIN: PC1220.1 PU1201.15
BST2_AUX: PR904.1 PU900.10
BST2_VCCIN: PC1207.1 PU1200.15
BST_0.6V: PR801.1 PU800.7
BST_1.1V_MEM: PR700.1 PU700.10
BST_1.1V_MEM_R: PC700.2 PR700.2
BST_1.8V: PR507.1 PU500.7
BST_3V: PR304.1 PU302.8
BST_3V_R: PC343.1 PR304.2
BST_5V: PR403.1 PU400.10
BST_5VB: PR415.1 PU401.10
BT_RADIO_DIS#: DZ3.1 RE133.2 RH751.1 UE1.C2
BT_RADIO_DIS#_R: DZ3.2 RW55.2 UWL1.63
CAM_DET#: R6208.1 RH747.2 UC1.CT49 UE1.L6
CAM_DET#_R: JUFC1.41 R6208.2 TP145.1(TP-1)
CBN: CA21.2 UA1.24
CBP: CA21.1 UA1.23
CD_WAKE#: RR11.2 RR12.2 UCR1.32
CFG_RCOM: RC2.2 UC1.AD6
CHG_ACIN: PC211.1 PR201.2 PR204.1 PU200.19
CHG_ADP: PC226.1 PR206.2 PU200.16
CHG_AMON: PR230.1 PU200.29
CHG_BGATE: PC233.1 PQ202.4 PU200.32
CHG_BST1: PR205.2 PU200.12
CHG_BST2: PC230.1 PU200.4
CHG_CLK: PR214.2 PU200.22
CHG_CMIN: PR212.2 PU200.20
CHG_COMP: PC241.1 PR231.1 PU200.28
CHG_CSIN: PC210.2 PC213.1 PR203.2 PU200.14
CHG_CSIP: PC210.1 PC212.1 PR202.2 PU200.15
CHG_CSON: PC239.2 PC240.1 PR222.2 PU200.1
CHG_CSOP: PC238.2 PC239.1 PR221.2 PU200.2
CHG_DAT: PR213.2 PU200.21
CHG_DCIN: PC227.2 PR208.2 PU200.17
CHG_LG1: PQ201.6 PU200.9
CHG_LG2: PQ203.6 PU200.7
CHG_LX1: PC225.1 PL250.1 PQ201.7 PR215.1 PU200.10
CHG_LX2: PL250.2 PQ203.7 PR210.1 PR216.1 PU200.6
CHG_PROCHOT#: PR102.2 PR105.2 PR217.2 PU200.23
CHG_PSYS: PR229.1 PU200.30
CHG_UG1: PQ201.1 PU200.11
CHG_UG2: PQ203.1 PU200.5
CHG_VBAT1: PC245.1 PR236.1 PU200.31
CHG_VDDP: PC228.1 PC249.1 PR207.1 PU200.8
CHG_VIN_20V: PC200.1 PL200.2 PR200.1 PR201.1 PT200.1(TP-1)
CLK_BIASREF: RH475.1 UC1.DU6
CLK_CNV_CRX_DTX_N: UC1.DK44 UWL1.A33
CLK_CNV_CRX_DTX_P: UC1.DJ44 UWL1.A32
CLK_CNV_CTX_DRX_N: UC1.DL42 UWL1.A20
CLK_CNV_CTX_DRX_P: UC1.DK42 UWL1.A19
CLK_PCIE_N0: RW7.1 UC1.CJ3
CLK_PCIE_N0_R: RW7.2 UWL1.33
CLK_PCIE_N1: RS207.1 UC1.CL2
CLK_PCIE_N1_R: JNGFF1.53 RS207.2
CLK_PCIE_N4: R6090.1 UC1.CJ2
CLK_PCIE_N4_R: R6090.2 UCR1.6
CLK_PCIE_P0: RW6.1 UC1.CJ5
CLK_PCIE_P0_R: RW6.2 UWL1.34
CLK_PCIE_P1: RS208.1 UC1.CL1
CLK_PCIE_P1_R: JNGFF1.55 RS208.2
CLK_PCIE_P4: R6089.1 UC1.CJ1
CLK_PCIE_P4_R: R6089.2 UCR1.5
CLK_SMB: JBATT1.4 PR195.1
CLK_TP_SIO_I2C_DAT: RE467.2 UE1.E10
CLKREQ_CNV#: RH728.1 RW17.1 UC1.CT47
CLKREQ_CNV#_R: DR16.2 RW17.2 UWL1.59 UWL1.A43
CLKREQ_PCIE#0: RH40.2 UC1.DK33 UWL1.30
CLKREQ_PCIE#1: JNGFF1.52 RH727.2 UC1.DN34
CLKREQ_PCIE#4: RH39.2 UC1.DN40 UCR1.2
CNV_BRI_CRX_DTX: RH724.1 RW28.2 UC1.DL29
CNV_BRI_CRX_R_DTX: RW28.1 UWL1.55 UWL1.A39
CNV_BRI_CTX_DRX: RC504.1 UC1.DL31
CNV_BRI_CTX_R_DRX: RC504.2 RW32.1 RW33.1 UWL1.54 UWL1.A38
CNV_CRX_DTX_N0: UC1.DP44 UWL1.A35
CNV_CRX_DTX_N1: UC1.DG42 UWL1.A37
CNV_CRX_DTX_P0: UC1.DN44 UWL1.A34
CNV_CRX_DTX_P1: UC1.DG44 UWL1.A36
CNV_CTX_DRX_N0: UC1.DV45 UWL1.A22
CNV_CTX_DRX_N1: UC1.DU44 UWL1.A24
CNV_CTX_DRX_P0: UC1.DU45 UWL1.A21
CNV_CTX_DRX_P1: UC1.DT44 UWL1.A23
CNV_DET#_EC: RE471.2 UE1.L12
CNV_RF_RESET#: DR17.2 QW1.2 RH114.1 RW13.1 UC1.CT48 UWL1.58
CNV_RF_RESET#_R: RW13.2 UWL1.A42
CNV_RF_RST: QW1.1 RE471.1 RW19.1 RW46.1
CNV_RGI_CRX_DTX: RH725.1 RW31.2 UC1.DN29
CNV_RGI_CRX_R_DTX: RW31.1 UWL1.57 UWL1.A41
CNV_RGI_CTX_DRX: RC503.1 UC1.DP31
CNV_RGI_CTX_R_DRX: RC503.2 RW29.1 RW30.1 UWL1.56 UWL1.A40
CNV_WT_RCOMP: RC15.1 UC1.DT45
CNVI_EN#: Q350.2 R529.1 RH729.2 RW46.2
CNVI_EN#_R: RH729.1 UC1.CC45
CORE_VID0: PU900.6 RC609.2 RC611.2 RC663.2 RC690.2 UC6.1
CORE_VID0_R: RC690.1 UC1.CL38
CORE_VID1: PU900.5 RC610.2 RC612.2 RC664.2 RC689.2 UC6.2
CORE_VID1_R: RC689.1 UC1.CJ38
CPU_B+: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PC1222.1 PC1223.1 PC1341.1 PC1342.1 PC1343.1 PL1202.2 PL1203.2 PL1204.2 PL1205.2 PR1104.1 PU1200.1 PU1200.8 PU1201.1 PU1201.8
CPU_C10_GATE#: RC226.1 RC631.2 RH280.2 UC10.1
CPU_C10_GATE#_R: RH280.1 UC1.DU40
CPU_EOPIO_RCOMP: RH7.1 UC1.B14
CPU_POPI_RCOMP: RH4.1 UC1.CJ41
CPU_RC_ID: CE432.1 RE530.2 UE1.F2
CPU_TCP0_HPD: RH717.1 UC1.CV39
CPUPWRGD: CC650.1 UC1.CF1
CPVEE: CA18.1 UA1.25
CS1: PR1116.1 PU1201.12
CS2: PR1110.1 PU1200.12
CSI_RCOMP: RC8.1 UC1.B4
CSSUM: PR1107.1 PR1108.1 PU1100.8
CTRL0: L73.1 UW1.13
CTRL0_R: CW227.2 DA16.1 JWLA2.1 L73.2
CTRL1: RW1241.1 UW1.15
CTRL1_R: DA17.1 JWLA2.4 RW57.1 RW1241.2 UE1.F13
CTRL2: L71.1 UW1.18
CTRL2_R: CW226.2 DA18.1 JWLA1.1 L71.2
CTRL3: RW1240.1 UW1.23
CTRL3_R: DA19.1 JWLA1.4 RW58.1 RW1240.2 UE1.E12
DAR_INT#: DR3.1 RW59.2 UE1.K12
DAT_SMB: JBATT1.5 PR196.1
DAT_TP_SIO_I2C_CLK: RE468.2 UE1.C12
DBC_EN: RH622.1 UC1.DW24
DBC_EN_R: JEDP1.40 RH622.2 TP115.1(TP-1)
DBG_PMODE: R270.1 R545.2 R6143.1 UC1.DL15
DBG_PMODE_MIPI60_RST#: JMIPI60.7 R544.1 R545.1
DDR_A_CA0: UC1.BG48 UD1.H2 UD1.R2
DDR_A_CA1: UC1.BE47 UD1.J2 UD1.P2
DDR_A_CA2: UC1.BE45 UD1.H9 UD1.R9
DDR_A_CA3: UC1.BG47 UD1.H10 UD1.R10
DDR_A_CA4: UC1.BG45 UD1.H11 UD1.R11
DDR_A_CA5: UC1.BB49 UD1.J11 UD1.P11
DDR_A_CKE0: UC1.BG49 UD1.J4 UD1.P4
DDR_A_CKE1: UC1.BJ47 UD1.J5 UD1.P5
DDR_A_CLK: UC1.BL47 UD1.J8 UD1.P8
DDR_A_CLK#: UC1.BL48 UD1.J9 UD1.P9
DDR_A_CS#0: UC1.BM38 UD1.H4 UD1.R4
DDR_A_CS#1: UC1.BM42 UD1.H3 UD1.R3
DDR_A_D0_0: UC1.CA48 UD1.Y4
DDR_A_D0_1: UC1.CA47 UD1.Y2
DDR_A_D0_2: UC1.CA49 UD1.V4
DDR_A_D0_3: UC1.BV49 UD1.U2
DDR_A_D0_4: UC1.CA45 UD1.AA4
DDR_A_D0_5: UC1.BV47 UD1.V2
DDR_A_D0_6: UC1.BV45 UD1.AA2
DDR_A_D0_7: UC1.BV48 UD1.U4
DDR_A_D1_0: UC1.CC42 UD1.V9
DDR_A_D1_1: UC1.CC39 UD1.U11
DDR_A_D1_2: UC1.CC43 UD1.V11
DDR_A_D1_3: UC1.CE38 UD1.AA11
DDR_A_D1_4: UC1.CC38 UD1.U9
DDR_A_D1_5: UC1.CE39 UD1.Y9
DDR_A_D1_6: UC1.CE42 UD1.Y11
DDR_A_D1_7: UC1.CE43 UD1.AA9
DDR_A_D2_0: UC1.BT48 UD1.C9
DDR_A_D2_1: UC1.BT47 UD1.C11
DDR_A_D2_2: UC1.BT49 UD1.B9
DDR_A_D2_3: UC1.BN49 UD1.E11
DDR_A_D2_4: UC1.BT45 UD1.B11
DDR_A_D2_5: UC1.BN47 UD1.E9
DDR_A_D2_6: UC1.BN45 UD1.F11
DDR_A_D2_7: UC1.BN48 UD1.F9
DDR_A_D3_0: UC1.BV42 UD1.C2
DDR_A_D3_1: UC1.BV39 UD1.E2
DDR_A_D3_2: UC1.BV43 UD1.B2
DDR_A_D3_3: UC1.BW38 UD1.F4
DDR_A_D3_4: UC1.BV38 UD1.F2
DDR_A_D3_5: UC1.BW39 UD1.E4
DDR_A_D3_6: UC1.BW42 UD1.C4
DDR_A_D3_7: UC1.BW43 UD1.B4
DDR_A_DQS0: UC1.BY46 UD1.W3
DDR_A_DQS1: UC1.CE41 UD1.W10
DDR_A_DQS2: UC1.BR46 UD1.D10
DDR_A_DQS3: UC1.BW41 UD1.D3
DDR_A_DQS#0: UC1.BY47 UD1.V3
DDR_A_DQS#1: UC1.CC41 UD1.V10
DDR_A_DQS#2: UC1.BR47 UD1.E10
DDR_A_DQS#3: UC1.BV41 UD1.E3
DDR_A_ODTA: RD25.1 RD26.1 UD1.G2
DDR_A_ODTB: RD27.1 RD28.1 UD1.T2
DDR_B_CA0: UC1.BM39 UD2.H2 UD2.R2
DDR_B_CA1: UC1.BJ42 UD2.J2 UD2.P2
DDR_B_CA2: UC1.BG43 UD2.H9 UD2.R9
DDR_B_CA3: UC1.BM41 UD2.H10 UD2.R10
DDR_B_CA4: UC1.BM43 UD2.H11 UD2.R11
DDR_B_CA5: UC1.BG38 UD2.J11 UD2.P11
DDR_B_CKE0: UC1.BF38 UD2.J4 UD2.P4
DDR_B_CKE1: UC1.BF41 UD2.J5 UD2.P5
DDR_B_CLK: UC1.BF43 UD2.J8 UD2.P8
DDR_B_CLK#: UC1.BF42 UD2.J9 UD2.P9
DDR_B_CS#0: UC1.BP42 UD2.H4 UD2.R4
DDR_B_CS#1: UC1.BG42 UD2.H3 UD2.R3
DDR_B_D0_0: UC1.AY48 UD2.B9
DDR_B_D0_1: UC1.AY47 UD2.C11
DDR_B_D0_2: UC1.AY49 UD2.C9
DDR_B_D0_3: UC1.AU45 UD2.E9
DDR_B_D0_4: UC1.AY45 UD2.B11
DDR_B_D0_5: UC1.AU47 UD2.F11
DDR_B_D0_6: UC1.AU48 UD2.E11
DDR_B_D0_7: UC1.AU49 UD2.F9
DDR_B_D1_0: UC1.AY42 UD2.E4
DDR_B_D1_1: UC1.AY38 UD2.F4
DDR_B_D1_2: UC1.AY43 UD2.E2
DDR_B_D1_3: UC1.BB39 UD2.C4
DDR_B_D1_4: UC1.AY39 UD2.F2
DDR_B_D1_5: UC1.BB38 UD2.B4
DDR_B_D1_6: UC1.BB42 UD2.C2
DDR_B_D1_7: UC1.BB43 UD2.B2
DDR_B_D2_0: UC1.AR48 UD2.V9
DDR_B_D2_1: UC1.AR47 UD2.U9
DDR_B_D2_2: UC1.AR49 UD2.V11
DDR_B_D2_3: UC1.AM45 UD2.Y9
DDR_B_D2_4: UC1.AR45 UD2.U11
DDR_B_D2_5: UC1.AM47 UD2.AA11
DDR_B_D2_6: UC1.AM48 UD2.Y11
DDR_B_D2_7: UC1.AM49 UD2.AA9
DDR_B_D3_0: UC1.AT42 UD2.V2
DDR_B_D3_1: UC1.AT39 UD2.U2
DDR_B_D3_2: UC1.AR43 UD2.Y2
DDR_B_D3_3: UC1.AT38 UD2.U4
DDR_B_D3_4: UC1.AR38 UD2.AA4
DDR_B_D3_5: UC1.AR39 UD2.Y4
DDR_B_D3_6: UC1.AR42 UD2.AA2
DDR_B_D3_7: UC1.AT43 UD2.V4
DDR_B_DQS0: UC1.AV47 UD2.D10
DDR_B_DQS1: UC1.BB41 UD2.D3
DDR_B_DQS2: UC1.AN47 UD2.W10
DDR_B_DQS3: UC1.AT41 UD2.W3
DDR_B_DQS#0: UC1.AV46 UD2.E10
DDR_B_DQS#1: UC1.AY41 UD2.E3
DDR_B_DQS#2: UC1.AN46 UD2.V10
DDR_B_DQS#3: UC1.AR41 UD2.V3
DDR_B_ODTA: RD29.1 RD30.1 UD2.G2
DDR_B_ODTB: RD31.1 RD32.1 UD2.T2
DDR_C_CA0: UC1.R49 UD3.H2 UD3.R2
DDR_C_CA1: UC1.R47 UD3.J2 UD3.P2
DDR_C_CA2: UC1.U49 UD3.H9 UD3.R9
DDR_C_CA3: UC1.M45 UD3.H10 UD3.R10
DDR_C_CA4: UC1.M47 UD3.H11 UD3.R11
DDR_C_CA5: UC1.R45 UD3.J11 UD3.P11
DDR_C_CKE0: UC1.U45 UD3.J4 UD3.P4
DDR_C_CKE1: UC1.V46 UD3.J5 UD3.P5
DDR_C_CLK: UC1.Y47 UD3.J8 UD3.P8
DDR_C_CLK#: UC1.Y48 UD3.J9 UD3.P9
DDR_C_CS#0: UC1.V42 UD3.H4 UD3.R4
DDR_C_CS#1: UC1.V39 UD3.H3 UD3.R3
DDR_C_D0_0: UC1.AK48 UD3.AA2
DDR_C_D0_1: UC1.AK45 UD3.V2
DDR_C_D0_2: UC1.AK49 UD3.Y2
DDR_C_D0_3: UC1.AG47 UD3.U4
DDR_C_D0_4: UC1.AK47 UD3.U2
DDR_C_D0_5: UC1.AG45 UD3.AA4
DDR_C_D0_6: UC1.AG48 UD3.Y4
DDR_C_D0_7: UC1.AG49 UD3.V4
DDR_C_D1_0: UC1.AJ38 UD3.U9
DDR_C_D1_1: UC1.AL39 UD3.Y9
DDR_C_D1_2: UC1.AJ39 UD3.U11
DDR_C_D1_3: UC1.AL43 UD3.Y11
DDR_C_D1_4: UC1.AL38 UD3.AA9
DDR_C_D1_5: UC1.AJ42 UD3.V9
DDR_C_D1_6: UC1.AL42 UD3.AA11
DDR_C_D1_7: UC1.AJ43 UD3.V11
DDR_C_D2_0: UC1.AB49 UD3.C9
DDR_C_D2_1: UC1.AB48 UD3.E9
DDR_C_D2_2: UC1.AE49 UD3.F11
DDR_C_D2_3: UC1.AE47 UD3.B11
DDR_C_D2_4: UC1.AE48 UD3.E11
DDR_C_D2_5: UC1.AB47 UD3.F9
DDR_C_D2_6: UC1.AB45 UD3.B9
DDR_C_D2_7: UC1.AE45 UD3.C11
DDR_C_D3_0: UC1.AD38 UD3.F2
DDR_C_D3_1: UC1.AD39 UD3.E2
DDR_C_D3_2: UC1.AE39 UD3.E4
DDR_C_D3_3: UC1.AE43 UD3.B4
DDR_C_D3_4: UC1.AE38 UD3.F4
DDR_C_D3_5: UC1.AD43 UD3.B2
DDR_C_D3_6: UC1.AD42 UD3.C2
DDR_C_D3_7: UC1.AE42 UD3.C4
DDR_C_DQS0: UC1.AH47 UD3.W3
DDR_C_DQS1: UC1.AL41 UD3.W10
DDR_C_DQS2: UC1.AC46 UD3.D10
DDR_C_DQS3: UC1.AD41 UD3.D3
DDR_C_DQS#0: UC1.AH46 UD3.V3
DDR_C_DQS#1: UC1.AJ41 UD3.V10
DDR_C_DQS#2: UC1.AC47 UD3.E10
DDR_C_DQS#3: UC1.AE41 UD3.E3
DDR_C_ODTA: RD33.1 RD34.1 UD3.G2
DDR_C_ODTB: RD35.1 RD36.1 UD3.T2
DDR_CHA_EN: RH738.1 RH740.1 UC1.CC47
DDR_CHB_EN: RH739.1 RH741.1 UC1.CF45
DDR_COMP_0: RC12.1 UC1.D47
DDR_COMP_1: RC13.1 UC1.E46
DDR_COMP_2: RC14.1 UC1.C47
DDR_D_CA0: UC1.Y41 UD4.H2 UD4.R2
DDR_D_CA1: UC1.Y42 UD4.J2 UD4.P2
DDR_D_CA2: UC1.V41 UD4.H9 UD4.R9
DDR_D_CA3: UC1.V47 UD4.H10 UD4.R10
DDR_D_CA4: UC1.T38 UD4.H11 UD4.R11
DDR_D_CA5: UC1.U48 UD4.J11 UD4.P11
DDR_D_CKE0: UC1.M41 UD4.J4 UD4.P4
DDR_D_CKE1: UC1.P43 UD4.J5 UD4.P5
DDR_D_CLK: UC1.M42 UD4.J8 UD4.P8
DDR_D_CLK#: UC1.M43 UD4.J9 UD4.P9
DDR_D_CS#0: UC1.Y39 UD4.H4 UD4.R4
DDR_D_CS#1: UC1.T39 UD4.H3 UD4.R3
DDR_D_D0_0: UC1.J48 UD4.Y9
DDR_D_D0_1: UC1.J45 UD4.AA9
DDR_D_D0_2: UC1.J49 UD4.Y11
DDR_D_D0_3: UC1.G47 UD4.U9
DDR_D_D0_4: UC1.J47 UD4.AA11
DDR_D_D0_5: UC1.G45 UD4.V11
DDR_D_D0_6: UC1.G48 UD4.U11
DDR_D_D0_7: UC1.E48 UD4.V9
DDR_D_D1_0: UC1.J38 UD4.U4
DDR_D_D1_1: UC1.G39 UD4.AA2
DDR_D_D1_2: UC1.G38 UD4.AA4
DDR_D_D1_3: UC1.G42 UD4.Y4
DDR_D_D1_4: UC1.J39 UD4.U2
DDR_D_D1_5: UC1.J42 UD4.V4
DDR_D_D1_6: UC1.G43 UD4.Y2
DDR_D_D1_7: UC1.J43 UD4.V2
DDR_D_D2_0: UC1.B43 UD4.F11
DDR_D_D2_1: UC1.D43 UD4.E11
DDR_D_D2_2: UC1.A43 UD4.B11
DDR_D_D2_3: UC1.C40 UD4.E9
DDR_D_D2_4: UC1.C43 UD4.C11
DDR_D_D2_5: UC1.D40 UD4.F9
DDR_D_D2_6: UC1.B40 UD4.B9
DDR_D_D2_7: UC1.A40 UD4.C9
DDR_D_D3_0: UC1.B35 UD4.B2
DDR_D_D3_1: UC1.D35 UD4.F2
DDR_D_D3_2: UC1.A35 UD4.C2
DDR_D_D3_3: UC1.D38 UD4.F4
DDR_D_D3_4: UC1.C35 UD4.E2
DDR_D_D3_5: UC1.C38 UD4.E4
DDR_D_D3_6: UC1.B38 UD4.C4
DDR_D_D3_7: UC1.A38 UD4.B4
DDR_D_DQS0: UC1.H46 UD4.W10
DDR_D_DQS1: UC1.J41 UD4.W3
DDR_D_DQS2: UC1.D42 UD4.D10
DDR_D_DQS3: UC1.C36 UD4.D3
DDR_D_DQS#0: UC1.H47 UD4.V10
DDR_D_DQS#1: UC1.G41 UD4.V3
DDR_D_DQS#2: UC1.C42 UD4.E10
DDR_D_DQS#3: UC1.D36 UD4.E3
DDR_D_ODTA: RD37.1 RD38.1 UD4.G2
DDR_D_ODTB: RD39.1 RD40.1 UD4.T2
DDR_DRAMRST#: RH12.1 RH42.1 UC1.DK47
DDR_DRAMRST#_R: CC740.1 RH42.2 UD1.T11 UD2.T11 UD3.T11 UD4.T11
DEBUG_TX: JDEG1.9 RE203.2 RE209.2
DISP_UTILS: TP69.1(TP-1) UC1.D2
DISPOFF#: C761.2 D2.1 JEDP1.3 R31.2 RH744.1 TP119.1(TP-1)
DISPOFF_R#: QC2.2 RH744.2
DMIC_CLK12: CA57.1 JUFC1.20 R634.2 RA62.1
DMIC_CLK12_R: RA62.2 UA1.5
DMIC_DATA12: CA64.1 JUFC1.22 R655.2 RA58.1
DMIC_DATA12_R: RA58.2 UA1.4
DP_RCOMP: RC3.1 UC1.R2
EAPD: CA55.1 DA10.2 RA21.1 RA83.2 RA84.2 RE531.2 UA2.21 UA3.21
EAPD_R: RE531.1 UE1.L2
EC_AMP_I2C_CLK: Q352.6 RE527.2 UE1.B3
EC_AMP_I2C_DAT: Q352.3 RE526.2 UE1.E5
EDP_AUXN: C10.1 UC1.W4
EDP_AUXN_C: C10.2 JEDP1.10
EDP_AUXP: C9.1 UC1.W3
EDP_AUXP_C: C9.2 JEDP1.12
EDP_BIA_PWM: D3.3 UC1.DU19
EDP_HPD: JEDP1.7 RH675.1 TP117.1(TP-1) UC1.DW11 UE1.C13
EDP_TXN0: C2.1 UC1.Y5
EDP_TXN0_C: C2.2 JEDP1.18
EDP_TXN1: C4.1 UC1.Y1
EDP_TXN1_C: C4.2 JEDP1.24
EDP_TXN2: C6.1 UC1.V2
EDP_TXN2_C: C6.2 JEDP1.30
EDP_TXN3: C8.1 UC1.V3
EDP_TXN3_C: C8.2 JEDP1.36
EDP_TXP0: C1.1 UC1.Y3
EDP_TXP0_C: C1.2 JEDP1.16
EDP_TXP1: C3.1 UC1.Y2
EDP_TXP1_C: C3.2 JEDP1.22
EDP_TXP2: C5.1 UC1.V1
EDP_TXP2_C: C5.2 JEDP1.28
EDP_TXP3: C7.1 UC1.V5
EDP_TXP3_C: C7.2 JEDP1.34
EDRAM_OPIO_RCOMP: RH6.1 UC1.A14
EMMC_RCOMP: RC17.1 UC1.DU28
EN1_1.1V_MEM: PR706.2 PU700.16
EN2_1.1V_MEM: PR709.2 PU700.15
EN_3V: PR302.2 PR303.1 PU302.11
EN_INVPWR: Q16.2 R29.1 UE1.B2
EN_INVPWR_R: C1224.2 Q15.3 R30.1 R231.2
ENBKL_TS: RH732.2 UC1.DL21
ENCLK_3V: PR306.2 PU302.12
ENVDD: C760.2 D1.1 R25.1 U7.4
ENVDD_PCH: D1.3 UC1.DN21
ESPI_ALERT#: TP74.1(TP-1) UE1.H7
ESPI_CLK: RC569.2 UC1.CR47
ESPI_CLK_5105: CC658.1 JDEBUG2.10 RC569.1 RE172.1 UE1.G7
ESPI_CS#: JDEBUG2.7 RC712.1 UC1.CT45 UE1.H6
ESPI_IO0: JDEBUG2.3 RC336.2 UE1.K5
ESPI_IO0_R: RC336.1 UC1.CN45
ESPI_IO1: JDEBUG2.4 RC367.2 UE1.L4
ESPI_IO1_R: RC367.1 UC1.CN48
ESPI_IO2: JDEBUG2.5 RC368.2 UE1.G6
ESPI_IO2_R: RC368.1 UC1.CN49
ESPI_IO3: JDEBUG2.6 RC369.2 UE1.L5
ESPI_IO3_R: RC369.1 UC1.CN47
ESPI_RESET#: RC711.1 RE428.1 UC1.CR46 UE1.K6
FB_0.6V: PC812.2 PR803.2 PR805.1 PU800.10
FB_1.1V_MEM: PC702.2 PR703.2 PR704.1 PU700.13
FB_1.8V: PR501.2 PR502.2 PR504.1 PU500.10
FB_5V: PR404.2 PR407.2 PR409.1 PU400.13
FB_5VB: PR416.2 PR419.2 PR421.1 PU401.13
FPR_DET#: R800.2 RE470.1 UE1.D9
FPR_DET#_R: D16.3 JFP1.1 R800.1
FPR_SCAN#_R: D16.2 JFP1.2 QF3.3 R629.1 R801.2
FPR_SCAN_INT#: QF3.1 R801.1 RE469.1 UE1.L8
GPD7: TP101.1(TP-1) UC1.DC47
GPIO011: TP84.1(TP-1) UE1.K7
GPIO100: RE487.1 UE1.M1
GPP_A23: RH715.2 UC1.DC45
GPP_B23: RH647.1 UC1.CL48
GPP_C2: RH692.1 UC1.DL24
GPP_C5: RH98.1 RH666.1 UC1.DP22
GPP_E6: RH660.1 RH661.1 UC1.DT12
GPP_F4: RC746.1 UC1.DJ29
GPP_F5: RC746.2 UC1.DK29
GPP_F19: RH749.1 UC1.DL27
GPP_H2: RH617.1 RH618.1 UC1.DJ38
GPP_H8: RH714.1 UC1.DT40
GPP_H9: RH714.2 UC1.DW40
GPP_S4: RH716.1 UC1.DF38
GPP_S5: RH716.2 UC1.DD39
H_CATERR#: RH80.1 UC1.J4
H_PROCHOT#: D21.2 PR702.1 PR1109.2 PR1123.2 RC614.1 RE158.2 RH96.1
H_PROCHOT#_R: CC739.1 RC614.2 UC1.C3
H_THERMTRIP#: CC738.1 QE16.3 RH95.1 UC1.E3
HDA_BIT_CLK: RH113.2 RH688.2 UC1.CY46
HDA_BIT_CLK_R: CA37.1 CH40.1 RH113.1 UA1.14
HDA_SDIN0: CC727.1 RA17.2 UC1.CV45
HDA_SDIN0_R: RA17.1 UA1.16
HDA_SDOUT: RH112.2 RH217.2 UC1.CY47
HDA_SDOUT_R: CH50.1 RH112.1 UA1.17
HDA_SYNC: RH111.2 UC1.CV49
HDA_SYNC_R: CH51.1 RH111.1 UA1.15
HOST_DEBUG_TX: JDEG1.8 RE202.2 RE206.2 UE1.G11
HOST_SD_WP#: QR1.2 RC717.2 UC1.CE47
HP_PLUG#: DA13.1 JHP1.3 RA14.2
HPOL_CONN: CA84.1 DA5.1 JHP1.2 LA19.2
HPOR_CONN: CA85.1 DA4.1 JHP1.4 LA18.2
HPOUT-L: CA11.1 CA12.2 RA6.1 UA1.27
HPOUT-L_L: LA19.1 RA6.2
HPOUT-R: CA9.1 CA10.2 RA3.1 UA1.26
HPOUT-R_L: LA18.1 RA3.2
HRESET_L_PD: RPD88.1 UPD1.44
HRESET_R_PD: RPD97.1 UPD2.44
I2C1_PD_L_CLK: JDB1.7 RPD163.1 UPD1.27
I2C1_PD_L_DAT: JDB1.8 RPD164.1 UPD1.28
I2C1_PD_L_INT#: RPD17.1 UPD1.29
I2C1_PD_R_CLK: JDB2.7 RPD165.1 UPD2.27
I2C1_PD_R_DAT: JDB2.8 RPD166.1 UPD2.28
I2C1_PD_R_INT#: RPD109.1 UPD2.29
I2C2_PD_L_CLK: JDB1.9 RPD21.1 UPD1.32
I2C2_PD_L_DAT: JDB1.10 RPD22.1 UPD1.33
I2C2_PD_L_INT#: RPD112.1 UPD1.34
I2C2_PD_R_CLK: JDB2.9 RPD105.1 UPD2.32
I2C2_PD_R_DAT: JDB2.10 RPD106.1 UPD2.33
I2C2_PD_R_INT#: RPD113.1 UPD2.34
I2C3_PD_L_CLK: RPD194.2 UPD1.21
I2C3_PD_L_DAT: RPD142.2 UPD1.22
I2C3_PD_L_INT#: RPD155.2 UPD1.23
I2C3_PD_R_CLK: RPD199.2 UPD2.21
I2C3_PD_R_DAT: RPD146.2 UPD2.22
I2C3_PD_R_INT#: RPD131.2 UPD2.23
I2C_0_SCL: R1015.1 UC1.DT23
I2C_0_SCL_R: JEDP1.37 R239.1 R1015.2 TP122.1(TP-1)
I2C_0_SDA: R1016.1 UC1.DT24
I2C_0_SDA_R: JEDP1.35 R238.1 R1016.2 TP121.1(TP-1)
I2C_1_SCL: R6219.1 UC1.DU23
I2C_1_SCL_R: D483.3 JTP1.3 R6215.2 R6219.2
I2C_1_SDA: R6220.1 UC1.DW23
I2C_1_SDA_R: D483.2 JTP1.2 R6216.2 R6220.2
I2C_RT_L_INT#: RT152.1 URT1.A10
I2C_RT_L_SCL: RT124.1 URT1.C9
I2C_RT_L_SDA: RT125.1 URT1.E7
I2C_RT_R_INT#: RT199.1 URT2.A10
I2C_RT_R_SCL: RT197.1 URT2.C9
I2C_RT_R_SDA: RT198.1 URT2.E7
I_ADP: PR234.2 UE1.B11
I_BATT: PR233.2 RE125.2
I_BATT_R: CE106.1 RE125.1 UE1.J4
I_SYS: PR229.2 PR232.1 PR1103.1 RE126.2
I_SYS_R: CE107.1 RE126.1 RE159.1 UE1.J5
IMON: PC1107.1 PR1133.1 PU1100.9
IMVP_SMBCLK: PR1118.2 RE458.1 UE1.F7
IMVP_SMBCLK_VR: PR1112.2 PR1118.1 PU1100.18
IMVP_SMBDAT: PR1121.2 RE459.1 UE1.B6
IMVP_SMBDAT_VR: PR1113.2 PR1121.1 PU1100.17
IMVP_VR_ON_EC: RE10.1 RE473.2 U15.2 UE1.N7
IMVP_VR_ON_EN: CE430.1 PJTAG8.2 PU1100.21 RE489.2
IMVP_VR_ON_P: RE10.2 RE29.1 RE489.1 U15.4 UE8.2 UH6.2
INPUT3VSEL: RH298.1 RH301.1 UC1.DN49
INTRUDER#: CC653.1 RH64.1 RH671.1 UC1.DR47
IRCAM_EN: QZ11.2 RE528.2 UE1.G5
ISH_I2C_1_SCL: JIO1.22 R6116.1 RC668.2 UC1.CL43
ISH_I2C_1_SCL_R: JUFC1.8 JUFC1.34 R6116.2 TP134.1(TP-1)
ISH_I2C_1_SDA: JIO1.23 R6117.1 RC667.2 UC1.CN41
ISH_I2C_1_SDA_R: JUFC1.10 JUFC1.32 R6117.2 TP135.1(TP-1)
ISH_TABLE_MODE#: RC750.2 RC751.2 UC1.DU34 UE1.H8
IST_TP_0: TP62.1(TP-1) UC1.BF11
IST_TP_1: TP61.1(TP-1) UC1.BD11
IST_TRIG_0: TP64.1(TP-1) UC1.BE10
IST_TRIG_1: TP63.1(TP-1) UC1.BF10
JACK_PLUG#: CA40.1 RA13.1 RA14.1 UA1.48
JTAG_CLK: JDEG1.4 RE211.1 UE1.C8
JTAG_RST#: CE63.1 JTAG2.1 RE156.1 RE164.1 UE1.G13
JTAG_TDI: JDEG1.2 RE213.1 UE1.E9
JTAG_TDO: JDEG1.5 RE210.1 UE1.F6
JTAG_TMS: JDEG1.3 RE212.1 UE1.C5
KB_DET#: JIO1.32 RH672.1 UC1.CV41
LAN_WAKE#: RH600.2 RH601.1 UE1.L3
LAN_WAKE#_R: RH600.1 UC1.DE47
LCD_TST: JEDP1.2 RE160.2 TP116.1(TP-1) UE1.M2
LCD_VCC_TEST_EN: D1.2 UE1.E1
LCDVDD_MONITOR: QV21.2 R628.1
LDO2_CAP: CA51.1 UA1.21
LDO3_CAP: CA32.1 UA1.19
LDO_3V: PC342.2 PR305.2 PU302.6
LID_CL_SIO#: DE1.2 RE122.2 UE1.N11
LID_CL_TS_FP#: DE3.2 R808.2 RE237.2 RH743.1
LID_POWER_ON#: PD601.1 QE19.1 RE142.1 UE1.D4
LINE2-L: CA12.1 UA1.36
LINE2-R: CA10.1 UA1.35
LX1_AUX: PC901.2 PL900.1 PR910.1 PU900.12
LX1_VCCIN: PC1220.2 PL1201.1 PL1201.2 PR1203.1 PU1201.2 PU1201.3 PU1201.4
LX2_AUX: PC910.2 PL901.1 PU900.11
LX2_VCCIN: PC1207.2 PL1200.1 PL1200.2 PR1201.1 PU1200.2 PU1200.3 PU1200.4
LX_0.6V: PC801.2 PL801.1 PR804.1 PU800.6
LX_1.1V_MEM: PC700.1 PL702.1 PR701.1 PU700.9
LX_1.8V: PC500.2 PL555.1 PR506.1 PR510.1 PU500.6
LX_3V: PC343.2 PL308.1 PR301.1 PU302.7
LX_5V: PC400.2 PL401.1 PR406.1 PR410.1 PU400.9
LX_5VB: PC416.2 PL403.1 PR418.1 PR422.1 PU401.9
M_0_ALERT_N: RH11.1 UC1.BD46
M_1_ALERT_N: RH13.2 UC1.M49
M_BIST: R273.1 UE1.N8
M_BITS_R: C92.1 D481.2 QE25.2 R272.2 R273.2 R283.2
MBP2#: RC723.2 UC1.T10
MBP3#: RC724.2 UC1.T6
ME_FWP: RH218.1 UE1.G12
ME_FWP_PCH: RH217.1 RH218.2
ME_RESET#: RC433.2 RC434.2 UC29.2
MEC_XTAL1: CE66.1 UE1.A1 YE2.1
MEC_XTAL2: CE89.1 RE178.2 YE2.2
MEC_XTAL2_R: RE178.1 UE1.A3
MEDIACARD_IRQ#: RC682.2 RH645.2 UC1.CH49
MEDIACARD_IRQ#_R: RH645.1 RR12.1
MEM_CONFIG0: RH129.1 RH612.2 UC1.DP27
MEM_CONFIG1: RH139.1 RH613.2 UC1.DU30
MEM_CONFIG2: RH145.1 RH614.2 UC1.DT30
MEM_CONFIG3: RH185.1 RH615.2 UC1.DT29
MEM_CONFIG4: RH616.2 RH665.1 UC1.DV30
MEM_INTERLEAVED: RH629.1 RH630.1 UC1.DV11
MERGED_TRST_PD: JMIPI60.8 R137.2
MIC2-VREFO-L: RA2.1 UA1.28
MIC2-VREFO-R: RA1.1 UA1.29
MIPI60_CFG0#: JMIPI60.19 R140.2 R160.2 R230.2 UC1.AG6
MIPI60_CFG1#: JMIPI60.21 R141.2 R161.2 UC1.AE7
MIPI60_CFG2#: JMIPI60.23 R142.2 R162.1 UC1.AG7
MIPI60_CFG3#: JMIPI60.25 R143.2 R163.1 UC1.AD9
MIPI60_CFG4#: JMIPI60.27 R144.2 R164.1 UC1.AE9
MIPI60_CFG5#: JMIPI60.29 R145.2 R165.1 UC1.AB9
MIPI60_CFG6#: JMIPI60.31 R146.2 R166.1 UC1.AJ6
MIPI60_CFG7#: JMIPI60.33 R147.2 R167.1 UC1.AB7
MIPI60_CFG8#: JMIPI60.35 R148.2 R168.2 UC1.V10
MIPI60_CFG9#: JMIPI60.37 R149.2 R169.2 UC1.AJ5
MIPI60_CFG10#: JMIPI60.39 R150.2 R170.2 UC1.Y10
MIPI60_CFG11#: JMIPI60.41 R151.2 R171.1 UC1.AJ7
MIPI60_CFG12#: JMIPI60.43 R152.2 R172.2 UC1.AB10
MIPI60_CFG13#: JMIPI60.45 R153.2 R173.2 UC1.AL7
MIPI60_CFG14#: JMIPI60.47 R154.2 R174.1 UC1.AL9
MIPI60_CFG15#: JMIPI60.49 R155.2 R175.1 UC1.AJ9
MIPI60_CFG_STB0_DN: R614.2 UC1.V6
MIPI60_CFG_STB0_DP: JMIPI60.13 UC1.V7
MIPI60_CFG_STB1_DN: R660.2 UC1.Y6
MIPI60_CFG_STB1_DP: JMIPI60.59 UC1.Y7
MIPI60_CPU_JTAG_TCLK: R190.2 RC145.1 UC1.P3
MIPI60_CPU_JTAG_TDI: R191.2 RC146.1 UC1.K5
MIPI60_CPU_JTAG_TDO: R201.2 RC150.1 UC1.K3
MIPI60_CPU_JTAG_TMS: R300.2 RC181.1 UC1.P4
MIPI60_CPU_JTAG_TRST#: R192.2 UC1.N1
MIPI60_DBRESET#: JMIPI60.6 R236.2
MIPI60_DBRESET#_R: C200.2 R176.2 R236.1 RC430.1 UC29.1
MIPI60_HOOK2_CPU_BOOT_STALL: JMIPI60.38 R230.1 R246.2
MIPI60_MBP0#: R195.2 R274.2 UC1.T9
MIPI60_MBP0#_R: JMIPI60.55 R195.1
MIPI60_MBP1#: R178.2 R194.2 UC1.T7
MIPI60_MBP1#_R: JMIPI60.53 R194.1
MIPI60_OVERRIDE#: R335.1 R410.2 UC8.6 UC11.6
MIPI60_PCH_JTAG_TCLK: R193.2 RC180.1 UC1.R5
MIPI60_PCH_JTAG_TDI: CC736.1 R312.2 RC151.1 UC1.K1
MIPI60_PCH_JTAG_TDO: CC735.1 R156.2 RC202.1 UC1.K2
MIPI60_PCH_JTAG_TMS: R247.2 RC203.1 UC1.N3
MIPI60_PCH_JTAG_TRST#: R213.2 RC201.1 UC1.N5
MIPI60_PCH_JTAGX: CC737.1 R244.2 RC344.1 UC1.N2
MIPI60_PRDY#: JMIPI60.11 UC1.P6
MIPI60_PREQ#: JMIPI60.10 R112.2 UC1.M6
MIPI60_PRESENT1#: JMIPI60.15 R188.2
MIPI60_PRESENT2#: JMIPI60.17 R335.2
MIPI60_SPI0_IO2: R188.1 RH634.1
MIPI60_SPI0_MOSI: R260.1 R261.2 RH640.1
MIPI60_TCLK: JMIPI60.3 R190.1 R244.1
MIPI60_TCLK1: JMIPI60.51 R193.1
MIPI60_TDI: JMIPI60.5 R191.1 R312.1
MIPI60_TDO: JMIPI60.4 R156.1 R201.1
MIPI60_TMS: JMIPI60.2 R247.1 R300.1
MIPI60_TRST#: JMIPI60.9 R192.1 R213.1
MODE_1.1V_MEM: PR707.1 PU700.14
MONO_IN: CA14.2 UA1.34
MSCLK: JDEG1.6 RE201.2 RE209.1 UE1.H10
MSDATA: JDEG1.7 RE204.2 RE205.1 UE1.G9
MUX_L_ENA_R: RM2.2 UM1.16
MUX_L_ENB_R: RM1.2 UM1.10
MUX_L_FLIP#: RM13.1 RM14.1 RPD127.1 RPD128.1 RPD129.1
MUX_L_FLIP#_R: RPD127.2 UPD1.41
MUX_L_SAI: RM13.2 UM1.14
MUX_L_SBI: RM14.2 UM1.12
MUX_R_ENA_R: RM18.2 UM2.16
MUX_R_ENB_R: RM17.2 UM2.10
MUX_R_FLIP#: RM15.1 RM16.1 RPD135.1 RPD136.1 RPD137.1
MUX_R_FLIP#_R: RPD135.2 UPD2.41
MUX_R_SAI: RM15.2 UM2.14
MUX_R_SBI: RM16.2 UM2.12
NB_LID#: DE1.1 DE3.1 UE6.2 ULID1.3
NB_LID#_FPR: JFP1.3 R808.1
NB_MUTE#: DA10.1 UE1.A4
NRB_BIT: RH621.1 RH751.2 UC1.CF48
OT_1.1V_MEM: PR702.2 PU700.11
P_DET#: JUFC1.9 RC749.2 UC1.CH45
P_INT#: JUFC1.13 RC738.1 RC741.1 UC1.DW34
P_SENSOR_PWR_SAVE#: JUFC1.7 RC748.2 UC1.DJ22
PANEL_BKEN_EC: D2.2 UE1.J9
PANEL_BKLEN: D2.3 RH732.1 UC1.DL19
PANEL_MONITOR: R651.1 UE1.M8
PANEL_PWRGD: C418.1 QV19.1 QV21.1 R651.2 R658.2 R677.1
PBAT_CHARGER_SMBCLK: PD104.2 PR195.2 PR214.1 RE112.1 UE1.N2
PBAT_CHARGER_SMBDAT: PD104.3 PR196.2 PR213.1 RE111.1 UE1.M3
PBAT_PRES#: QE23.1 RE521.2 UE1.F9
PCH_3.3V_TS_EN: R672.1 UC1.CK46
PCH_3.3V_TS_EN_R: R220.2 R672.2 R6168.2 R6194.2 U714.4
PCH_BATLOW#: RH460.1 UC1.DH48
PCH_DMIC_CLK12: CC654.1 R634.1 RH705.2
PCH_DMIC_DATA12: R655.1 RH706.2
PCH_DPWROK: CH48.1 RE248.1 RH575.1 UC1.DR48
PCH_DPWROK_EC: RE248.2 UE1.F8
PCH_IST_TP_0: TP66.1(TP-1) UC1.CW33
PCH_IST_TP_1: TP65.1(TP-1) UC1.CY32
PCH_OPI_RCOMP: RH5.1 UC1.DU3
PCH_PCIE_WAKE#: RE186.2 RH207.2 RH653.1 UE1.L1
PCH_PLTRST#: RH690.2 UC1.CM49 UH1.1 UH1.2
PCH_PLTRST#_EC: JNGFF1.50 LED2.1 R544.2 RE193.1 RH46.1 RT162.2 RT163.2 U712.17 UCR1.1 UH1.4 UWL1.31
PCH_PRIM_EN: CC511.1 PJTAG7.2 PU500.11 RC505.2 RC508.1
PCH_PRIM_EN_R: RC505.1 RC698.2 RC699.2
PCH_PWROK: RH625.2 UC1.DN47 UH6.4
PCH_PWROK_P: PR1125.2 RH625.1 RH733.1 UH6.1
PCH_RSMRST#: R466.2 RC644.1 RE472.2 UC2.1 UE1.M5
PCH_RSMRST#_AND: R272.1 RC247.1 RC644.2 RH591.1 RH592.1 UC1.DG49 UC2.4
PCH_RTCRST#: CH47.2 JAPS1.9 R271.1 RH573.2 UC1.DT47
PCH_RTCX1: CH12.1 RH16.1 UC1.DL48 YC1.1
PCH_RTCX2: RH16.2 RH637.2 UC1.DL49
PCH_RTCX2_R: CH13.1 RH637.1 YC1.2
PCH_TBT_PERST#: RH300.2 RH646.2 RH713.2 RT59.2 RT62.2 UC1.DP21
PCH_TOUCHPAD_INTR#: Q351.6 RH631.2 UC1.CR38
PCIE_CRX_C_DTX_N3: DR18.2 UWL1.36
PCIE_CRX_C_DTX_N16: CR4.2 UCR1.8
PCIE_CRX_C_DTX_P3: DR19.2 UWL1.37
PCIE_CRX_C_DTX_P16: CR3.2 UCR1.7
PCIE_CRX_DTX_N3: DR18.1 UC1.DE7
PCIE_CRX_DTX_N9: JNGFF1.5 UC1.CP7
PCIE_CRX_DTX_N10: JNGFF1.17 UC1.CM7
PCIE_CRX_DTX_N11: JNGFF1.29 UC1.CK7
PCIE_CRX_DTX_N12: JNGFF1.43 UC1.CJ6
PCIE_CRX_DTX_N16: CR4.1 UC1.CA6
PCIE_CRX_DTX_P3: DR19.1 UC1.DE9
PCIE_CRX_DTX_P9: JNGFF1.7 UC1.CP6
PCIE_CRX_DTX_P10: JNGFF1.19 UC1.CM6
PCIE_CRX_DTX_P11: JNGFF1.31 UC1.CK6
PCIE_CRX_DTX_P12: JNGFF1.41 UC1.CJ7
PCIE_CRX_DTX_P16: CR3.1 UC1.CA5
PCIE_CTX_C_DRX_N3: CH3.2 UWL1.39
PCIE_CTX_C_DRX_N9: CS26.2 JNGFF1.11
PCIE_CTX_C_DRX_N10: CS25.2 JNGFF1.23
PCIE_CTX_C_DRX_N11: CS98.2 JNGFF1.35
PCIE_CTX_C_DRX_N12: CS96.2 JNGFF1.47
PCIE_CTX_C_DRX_N16: CR2.2 UCR1.4
PCIE_CTX_C_DRX_P3: CH4.2 UWL1.40
PCIE_CTX_C_DRX_P9: CS27.2 JNGFF1.13
PCIE_CTX_C_DRX_P10: CS24.2 JNGFF1.25
PCIE_CTX_C_DRX_P11: CS99.2 JNGFF1.37
PCIE_CTX_C_DRX_P12: CS97.2 JNGFF1.49
PCIE_CTX_C_DRX_P16: CR1.2 UCR1.3
PCIE_CTX_DRX_N3: CH3.1 UC1.DF3
PCIE_CTX_DRX_N9: CS26.1 UC1.DA2
PCIE_CTX_DRX_N10: CS25.1 UC1.CY3
PCIE_CTX_DRX_N11: CS98.1 UC1.CW2
PCIE_CTX_DRX_N12: CS96.1 UC1.CW5
PCIE_CTX_DRX_N16: CR2.1 UC1.CP1
PCIE_CTX_DRX_P3: CH4.1 UC1.DF5
PCIE_CTX_DRX_P9: CS27.1 UC1.DA1
PCIE_CTX_DRX_P10: CS24.1 UC1.CY4
PCIE_CTX_DRX_P11: CS99.1 UC1.CW1
PCIE_CTX_DRX_P12: CS97.1 UC1.CW3
PCIE_CTX_DRX_P16: CR1.1 UC1.CP2
PCIE_RCOMPN: RH1.1 UC1.DN1
PCIE_RCOMPP: RH1.2 UC1.DN3
PCIE_WAKE#: RE185.2 RE186.1 RS381.2 UWL1.29
PCIE_WAKE#_R: RE185.1 RE481.1 UE1.N13
PCM_CLK: DR15.1 UC1.DP33
PCM_CLK_R: DR15.2 UWL1.61
PCM_IN: DR16.1 UC1.DA45
PCM_OUT: DR14.1 UC1.DA48
PCM_OUT_R: DR14.2 UWL1.60
PCM_SYNC: DR17.1 UC1.DA49
PD_EE_CLK_L: JDB1.2 UPD1.38 UPD3.6
PD_EE_CLK_R: JDB2.2 UPD2.38 UPD4.6
PD_EE_CS#_L: JDB1.5 RPD11.2 UPD1.39 UPD3.1
PD_EE_CS#_R: JDB2.5 RPD59.2 UPD2.39 UPD4.1
PD_EE_MISO_L: JDB1.4 RPD12.2 RPD181.2 UPD1.36 UPD3.2
PD_EE_MISO_R: JDB2.4 RPD60.2 RPD182.2 UPD2.36 UPD4.2
PD_EE_MOSI_L: JDB1.3 UPD1.37 UPD3.5
PD_EE_MOSI_R: JDB2.3 UPD2.37 UPD4.5
PD_EE_WP#_L: RPD14.2 UPD3.3
PD_EE_WP#_R: RPD62.2 UPD4.3
PD_HOLD#_L: RPD13.2 UPD3.7
PD_HOLD#_R: RPD61.2 UPD4.7
PD_ID: RE486.1 UE1.J10
PD_L_DDM_MUX1_EN: RM2.1 RPD123.1
PD_L_DDM_MUX1_EN_R: RPD123.2 RPD191.1 UPD1.42
PD_L_DRAIN1: UPD1.8 UPD1.15 UPD1.19 UPD1.58
PD_L_DRAIN2: UPD1.7 UPD1.52 UPD1.56 UPD1.57
PD_L_GPIO2: RPD139.2 UPD1.18
PD_L_GPIO4: RPD141.1 UPD1.31
PD_L_GPIO16: RPD141.2 UPD1.48
PD_L_GPIO17: RPD139.1 UPD1.49

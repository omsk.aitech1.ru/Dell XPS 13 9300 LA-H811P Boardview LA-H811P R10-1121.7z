# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CA4: length 41.7
  IN1 w0.094: v3(146.97,38.04) 147,38.01 147,33.25 147.26,32.98 147.26,32.83 147.01,32.57 147.01,32.42 147.12,32.31 147.27,32.31 147.53,32.56 147.68,32.56 147.86,32.39 147.86,32.23 147.15,31.53 147.15,31.37 147.26,31.26 147.42,31.26 148.12,31.97 148.28,31.97 148.74,31.5 148.74,31.35 148.02,30.62 148.02,30.5 148.16,30.35 148.28,30.35 149.01,31.08 149.17,31.08 154.25,26 154.25,24.36 154.05,24.17 153.5,24.17 153.39,24.06 153.39,23.9 153.5,23.79 154.15,23.79 154.25,23.7 154.25,23.04 154.14,22.93 153.51,22.93 153.4,22.82 153.4,22.67 153.51,22.56 154.14,22.56 154.25,22.45 154.25,21.8 154.14,21.69 153.49,21.69 153.38,21.58 153.38,21.43 153.49,21.32 154.14,21.32 154.25,21.21 154.25,20.41 154.14,20.3 153.5,20.3 153.39,20.19 153.39,20.03 153.5,19.92 154.14,19.92 154.25,19.81 154.25,19.19 154.13,19.08 153.82,19.08 153.75,19 153.75,18.83 153.99,18.6 153.99,18.47 153.32,17.8 153.05,17.8 v3(152.92,17.92)
  IN3 w0.094: v3(151.65,15.57) 152.04,15.97 152.04,17.04 v3(152.92,17.92) 152.59,18.25 152.59,19.44 151.91,20.12 v3(151.65,20.12) ; v3(146.97,38.04) v4(147.24,38.31)
DDR_B_CA5: length 43.9
  IN1 w0.094: v3(145.06,40.62) 145.36,40.62 145.45,40.53 145.45,38.02 145.69,37.78 145.69,36.64 145.53,36.49 145.53,32.91 146.01,32.44 146.01,31.11 148.72,28.4 148.87,28.4 149.58,29.11 149.74,29.11 150.21,28.63 150.21,28.48 149.51,27.77 149.51,27.62 149.62,27.51 149.77,27.51 150.48,28.21 150.63,28.21 151.11,27.74 151.11,27.59 150.4,26.88 150.4,26.72 150.51,26.61 150.66,26.61 151.37,27.32 151.53,27.32 152.46,26.39 152.46,25.76 152.35,25.65 151.76,25.65 151.65,25.54 151.65,25.39 151.76,25.28 152.35,25.28 152.46,25.17 152.46,25.01 152.35,24.9 151.2,24.9 151.1,24.8 151.1,24.62 151.2,24.52 152.35,24.52 152.46,24.41 152.46,24.26 152.35,24.15 152.14,24.15 152.03,24.04 152.03,23.88 152.14,23.77 152.35,23.77 152.46,23.66 152.46,23.51 152.35,23.4 152.07,23.4 151.96,23.29 151.96,23.13 152.07,23.02 152.35,23.02 152.46,22.91 152.46,22.76 152.35,22.65 151.92,22.65 151.81,22.54 151.81,22.38 151.92,22.27 152.35,22.27 152.46,22.16 152.46,21.2 152.33,21.06 151.69,21.06 151.58,20.95 151.58,20.8 151.69,20.69 151.92,20.69 152.03,20.58 152.03,18.43 152.01,18.41 151.93,18.41 v3(151.89,18.45)
  IN3 w0.094: v3(151.65,19.47) 151.84,19.67 152.1,19.67 152.37,19.4 152.37,18.64 152.18,18.45 v3(151.89,18.45) 151.66,16.77 151.65,16.64 v3(151.65,16.22) ; v3(145.06,40.62) v4(145.41,40.91)
DDR_B_CKE0: length 42.4
  IN1 w0.094: v3(146.64,17.89) 146.71,17.83 146.74,17.83 147.6,16.96 149.23,16.96 149.84,17.57 149.99,17.57 150.47,18.05 151.4,18.05 151.53,17.92 152.11,17.92 152.57,18.38 152.57,18.65 152.95,19.03 152.95,26.6 149.72,29.83 149.57,29.83 148.86,29.12 148.7,29.12 146.5,31.32 146.5,32.94 146.39,33.05 146.14,33.05 146.03,33.16 146.03,33.31 146.14,33.42 146.39,33.42 146.5,33.53 146.5,33.69 146.39,33.8 146.14,33.8 146.03,33.91 146.03,34.06 146.14,34.17 146.39,34.17 146.5,34.28 146.5,34.51 146.03,34.99 146.03,36.2 146.14,36.31 146.14,36.85 146.39,37.1 146.39,40.81 145.92,41.28 144.49,41.28 v3(144.04,40.84)
  IN3 w0.094: v3(146.04,19.47) 146.33,19.19 146.74,18.23 146.74,17.98 v3(146.64,17.89) 146.61,17.89 146.29,17.38 146.04,16.59 v3(146.04,16.22) ; v3(144.04,40.84) v4(144.49,40.91)
DDR_B_CKE1: length 43.2
  TOP w0.107: UD2.P5 147.03,16.18 v3(147.29,16.11)
  IN1 w0.094: v3(144.04,39.57) 143.6,39.12 143.6,37.51 143.83,37.28 143.83,36.89 143.72,36.79 143.72,34.97 143.83,34.87 143.83,28.95 144.58,28.2 144.73,28.2 144.9,28.37 145.09,28.37 145.3,28.15 145.3,27.96 144.82,27.47 144.82,27.32 145,27.14 145.15,27.14 145.66,27.65 145.8,27.65 145.89,27.56 145.89,27.4 145.01,26.52 145.01,26.37 145.18,26.2 145.28,26.2 146.44,27.37 146.6,27.37 146.71,27.26 146.71,27.11 145.59,25.99 145.59,25.84 145.71,25.73 145.86,25.73 147.21,27.07 147.36,27.07 147.48,26.95 147.48,26.81 146.01,25.35 146.01,25.19 146.12,25.08 146.28,25.08 146.41,25.21 147.3,26.1 147.46,26.1 147.56,26 147.56,25.56 147.45,25.44 147.21,25.44 146.93,25.16 146.93,24.74 147.15,24.52 147.28,24.52 147.51,24.29 147.51,23.79 147.28,23.56 147.28,20.41 147.61,20.08 147.61,18.99 147.43,18.81 147.2,18.81 147.09,18.7 147.09,18.54 147.2,18.43 147.58,18.43 147.61,18.4 147.61,17.95 v3(147.77,17.8)
  IN3 w0.094: v3(146.85,19.47) 147.3,19.47 147.6,19.17 147.6,17.96 v3(147.77,17.8) 147.56,17.59 147.56,16.94 147.35,16.73 147.35,16.43 v3(147.29,16.11) ; v3(144.04,39.57) v4(144.49,39.61)
DDR_B_CLK: length 38.8
  IN1 w0.097: v3(144.01,37.69) 144.09,37.69 144.23,37.55 144.23,37.12 144.45,36.9 144.45,36.76 144.18,36.5 144.18,36.15 144.42,35.92 144.42,35.78 144.17,35.53 144.17,35.22 144.34,35.05 144.34,32.31 144.57,32.08 144.67,32.08 144.81,31.94 144.81,31.61 144.72,31.51 144.55,31.51 144.34,31.29 144.34,30.8 144.9,30.24 144.9,30.09 144.39,29.58 144.39,29.17 144.69,28.87 145.11,28.87 145.75,29.51 145.92,29.51 146.19,29.23 146.19,29.1 145.78,28.69 145.78,28.38 146.19,27.97 146.5,27.97 146.91,28.38 147.05,28.38 148.07,27.36 148.07,26.62 148.29,26.4 149.02,26.4 149.17,26.24 149.17,26.07 149.08,25.98 148.28,25.98 148.07,25.76 148.07,25.33 148.3,25.1 148.87,25.1 148.98,24.99 148.98,24.83 148.87,24.71 148.2,24.71 147.97,24.48 147.97,24.15 148.2,23.92 148.93,23.92 149.01,23.85 149.01,23.61 148.93,23.54 148.07,23.54 147.8,23.27 147.8,22.87 148.08,22.59 148.28,22.59 148.39,22.48 148.39,22.32 148.28,22.2 148.08,22.2 147.85,21.97 147.85,21.65 148.22,21.27 148.22,21.14 147.85,20.77 147.85,18.88 148.6,18.13 148.6,17.9 148.49,17.79 148.47,17.77 v3(148.37,17.77)
  IN3 w0.097: v3(144.01,37.69) 144.49,37.69 144.71,37.91 144.71,38.19 144.59,38.31 v4(144.49,38.31) ; v3(149.25,16.22) 149.55,16.53 149.55,16.69 149.3,16.94 148.96,16.94 148.55,17.35 148.55,17.59 v3(148.37,17.77) 148.44,17.84 148.58,17.98 148.58,18.43 149.05,18.91 149.22,18.91 149.37,19.06 149.47,19.16 149.47,19.3 149.29,19.47 v3(149.25,19.47)
DDR_B_CLK#: length 38.8
  IN1 w0.097: v3(144.04,38.34) 144.43,37.76 144.43,37.2 144.65,36.98 144.65,36.68 144.39,36.41 144.39,36.24 144.62,36 144.62,35.69 144.37,35.44 144.37,35.3 144.54,35.14 144.54,32.4 144.65,32.29 144.75,32.29 145.02,32.02 145.02,31.52 144.8,31.31 144.64,31.31 144.54,31.21 144.54,30.89 145.1,30.33 145.1,30 144.6,29.5 144.6,29.25 144.77,29.07 145.02,29.07 145.67,29.71 146,29.71 146.4,29.32 146.4,29.01 145.98,28.6 145.98,28.47 146.28,28.17 146.41,28.17 146.82,28.59 147.13,28.59 148.27,27.45 148.27,26.71 148.37,26.6 149.1,26.6 149.38,26.33 149.38,25.99 149.16,25.77 148.37,25.77 148.27,25.68 148.27,25.42 148.38,25.3 148.95,25.3 149.19,25.07 149.19,24.74 148.95,24.51 148.29,24.51 148.18,24.4 148.18,24.24 148.29,24.12 149.02,24.12 149.21,23.93 149.21,23.53 149.02,23.33 148.15,23.33 148,23.18 148,22.96 148.17,22.79 148.36,22.79 148.6,22.56 148.6,22.23 148.36,22 148.17,22 148.06,21.89 148.06,21.73 148.43,21.36 148.43,21.05 148.06,20.68 148.06,18.96 148.8,18.22 148.8,17.88 v3(148.9,17.78)
  IN3 w0.097: v3(150.05,19.47) 150.05,19.45 149.52,18.92 149.3,18.7 149.14,18.7 148.78,18.35 148.78,17.9 v3(148.9,17.78) 148.76,17.63 148.76,17.43 149.04,17.14 149.39,17.14 149.75,16.78 149.75,16.47 150,16.22 v3(150.05,16.22) ; v4(144.49,38.96) v3(144.04,38.34)
DDR_B_CS#0: length 40.7
  IN1 w0.094: v3(147.71,39.26) 147.72,39.26 147.82,39.16 147.82,38.98 148.03,38.77 148.03,38.06 147.49,37.51 147.49,33.45 154.74,26.2 154.74,18.52 153.44,17.22 152.48,17.22 152.47,17.2 149.99,17.2 149.36,16.58 147.04,16.58 v3(147.02,16.6)
  IN3 w0.094: v3(146.04,20.12) 146.3,19.74 146.93,18.24 147.04,17.71 147.04,16.6 v3(147.02,16.6) 146.88,16.6 146.69,16.41 146.69,16.28 146.99,15.97 146.99,15.85 146.82,15.67 146.82,15.52 146.98,15.36 146.98,15.02 146.89,14.93 146.29,14.93 146.27,14.91 146.08,14.91 145.97,15.02 145.97,15.5 v3(146.04,15.57) ; v4(148.15,38.96) v3(147.71,39.26)
DDR_B_CS#1: length 41.5
  IN1 w0.094: v3(145.98,17.96) 145.98,18.26 146.48,18.75 146.78,18.75 146.91,18.63 146.91,18.44 147.35,18 147.35,17.73 147.73,17.36 148.95,17.36 149.34,17.75 149.34,18.14 148.24,19.24 148.24,20.48 148.56,20.8 148.95,20.8 149.1,20.95 149.1,21.86 148.83,22.13 148.83,22.88 148.94,22.99 149.44,22.99 149.5,23.05 149.5,24.24 150.16,24.9 150.16,25.03 150.06,25.13 149.78,25.13 149.68,25.22 149.68,25.45 149.78,25.54 150.17,25.54 150.28,25.43 150.42,25.43 150.53,25.54 150.95,25.54 151.68,26.27 151.68,26.47 151.53,26.62 151.37,26.62 150.67,25.92 150.01,25.92 149.91,26.01 149.91,26.5 149.31,27.1 148.9,27.1 148.77,27.23 148.77,27.65 145.52,30.91 145.52,32.23 145.04,32.71 145.04,36.9 145.19,37.05 145.19,37.65 144.51,38.32 144.51,39.11 144.59,39.18 144.68,39.18 v3(145.05,38.81)
  IN3 w0.094: v3(145.24,20.12) 145.24,19.08 146.02,18.3 146.02,18 v3(145.98,17.96) 145.67,16.85 145.52,16.25 v3(145.24,15.57) ; v3(145.05,38.81) v4(145.41,38.96)
DDR_B_D0_0: length 16.5
  IN3 w0.094: v4(141.59,35.93) 141.66,36.01 142.08,36.01 142.2,35.88 142.2,34.44 142.73,33.91 142.73,32.05 150.11,24.67 150.11,24.53 150.02,24.44 149.77,24.44 149.68,24.35 149.68,24.12 149.77,24.02 v3(150.05,24.02)
DDR_B_D0_1: length 18
  IN3 w0.094: v3(151.65,23.37) 151.03,23.37 150.86,23.54 150.86,24.1 150.87,24.11 150.87,24.39 150.86,24.39 150.86,24.42 150.06,25.22 149.91,25.22 142.98,32.15 142.98,34.02 142.39,34.61 142.39,36.11 141.92,36.59 v4(141.59,36.59)
DDR_B_D0_2: length 16
  IN3 w0.094: v3(150.05,23.37) 149.91,23.24 149.72,23.24 149.49,23.47 149.49,24.94 142.49,31.95 142.49,33.8 142.01,34.27 142.01,35.19 141.92,35.28 v4(141.59,35.28)
DDR_B_D0_3: length 19.7
  IN1 w0.094: v2(150.05,22.07) 149.68,22.07 v3(149.65,22.04)
  IN3 w0.094: v3(149.65,22.04) 149.32,22.04 148.4,22.95 148.4,24.33 141.28,31.45 141.28,33.83 141.24,33.88 141.24,34.69 140.92,35.01 140.92,35.76 140.6,36.09 140.6,36.96 v4(140.33,37.24)
DDR_B_D0_4: length 18.3
  IN3 w0.094: v4(141.59,37.24) 141.59,37.18 142.14,36.63 142.86,36.63 142.96,36.54 142.96,36.18 142.87,36.09 142.69,36.09 142.58,35.99 142.58,34.78 143.23,34.13 143.23,32.25 150.01,25.47 150.12,25.47 150.12,25.47 150.2,25.47 v3(151.65,24.02)
DDR_B_D0_5: length 22.3
  IN3 w0.094: v4(140.33,36.59) 140.14,36.26 140.04,35.86 140.04,35.22 140.13,35.02 140.31,34.85 140.54,34.35 140.54,31.14 146.39,25.29 146.42,25.21 146.55,24.88 146.83,24.17 146.83,23.98 147.01,23.58 147.31,23.28 147.46,22.94 147.75,22.36 149.24,20.87 149.99,20.45 150.65,20.45 150.83,20.63 151.16,20.77 151.2,20.77 151.4,20.84 151.52,20.97 v3(151.65,21.42)
DDR_B_D0_6: length 20.6
  IN3 w0.094: v3(151.65,22.07) 151.34,22.07 150.85,21.58 150.36,21.58 150.2,21.73 150.2,21.73 150.18,21.75 149.91,21.75 149.84,21.68 149.32,21.68 148.15,22.85 148.15,24.23 141.03,31.34 141.03,34.64 140.64,35.03 140.64,35.62 v4(140.33,35.93)
DDR_B_D0_7: length 18.4
  IN3 w0.094: v3(150.05,21.42) 149.14,21.42 147.92,22.65 147.92,24.11 140.79,31.24 140.79,34.63 140.33,35.08 v4(140.33,35.28)
DDR_B_D1_0: length 21.6
  IN1 w0.094: v2(146.04,22.07) 146.04,22 145.81,21.76 144.31,21.76 144.21,21.66 143.57,21.66 143.37,21.86 143.37,22.73 142.82,23.28 142.82,24.38 140.82,26.37 140.82,38.11 141.3,38.58 v3(141.3,38.77)
  IN3 w0.094: v3(141.3,38.77) v4(141.75,38.96)
DDR_B_D1_1: length 25.3
  IN1 w0.094: v2(146.04,21.42) 145.65,21.03 145.14,21.03 145.04,20.93 143.85,20.93 143.72,21.05 143.46,21.05 142.71,21.8 142.71,22.68 142.33,23.06 142.33,24.17 140.32,26.18 140.32,36.77 140.36,36.81 140.36,38.28 140.75,38.67 140.75,40.42 140.92,40.59 140.92,40.99 141.1,41.17 v3(141.28,41.17)
  IN3 w0.094: v4(141.75,40.91) 141.49,41.17 v3(141.28,41.17)
DDR_B_D1_2: length 17.9
  IN1 w0.094: v2(144.44,22.07) 144.43,22.07 143.62,22.88 143.07,23.44 143.07,24.48 141.08,26.47 141.08,37.67 v3(141.33,37.92)
  IN3 w0.094: v3(141.33,37.92) v4(141.75,38.31)
DDR_B_D1_3: length 19.8
  IN1 w0.094: v3(142.21,40.63) 142.59,40.25 142.59,38.51 142.98,38.13 142.98,36.62 142.84,36.48 142.84,28.39 143.01,28.22 143.36,28.22 143.95,27.63 143.95,26.02 145.05,24.92 145.05,24.76 145.61,24.2 145.61,23.81 v2(146.04,23.37)
  IN3 w0.094: v3(142.21,40.63) v4(142.66,40.26)
DDR_B_D1_4: length 22.3
  IN1 w0.094: v3(141.3,40.63) 140.94,40.28 140.94,38.5 140.57,38.14 140.57,26.28 142.57,24.27 142.57,23.17 142.96,22.78 142.96,21.91 143.44,21.42 v2(144.44,21.42)
  IN3 w0.094: v3(141.3,40.63) v4(141.75,40.26)
DDR_B_D1_5: length 19.2
  IN1 w0.094: v2(146.04,24.02) 146.04,24.28 145.62,24.7 145.46,24.7 145.3,24.86 145.3,25.18 145.1,25.38 144.94,25.38 144.72,25.6 144.72,25.76 144.53,25.94 144.37,25.94 144.19,26.13 144.19,27.74 143.46,28.47 143.23,28.47 143.08,28.62 143.08,36.33 143.16,36.41 143.16,38.21 142.78,38.59 142.78,40.29 143.07,40.57 v3(143.13,40.57)
  IN3 w0.094: v4(142.66,40.91) 142.68,40.85 v3(143.13,40.57)
DDR_B_D1_6: length 18.5
  IN1 w0.094: v3(142.21,38.77) 142.21,38.63 142.78,38.06 142.78,36.94 142.54,36.71 142.54,28.05 142.64,27.96 143,27.96 143.27,27.96 143.6,27.63 143.6,27.46 143.41,27.27 143.41,27.15 143.62,26.94 143.62,26.74 143.31,26.44 143.31,26.3 144.69,24.92 144.69,24.15 145.03,23.81 145.03,23.58 144.94,23.49 144.56,23.49 v2(144.44,23.37)
  IN3 w0.094: v3(142.21,38.77) v4(142.66,38.96)
DDR_B_D1_7: length 17.8
  IN1 w0.094: v3(142.23,37.97) 142.23,37.94 142.57,37.6 142.57,37 142.29,36.72 142.29,27.82 142.4,27.71 142.9,27.71 143.01,27.6 143.01,27.45 142.9,27.34 142.4,27.34 142.29,27.23 142.29,26.97 142.54,26.72 142.69,26.72 142.99,27.02 143.15,27.02 143.26,26.9 143.26,26.75 142.96,26.45 142.96,26.3 144.44,24.81 v2(144.44,24.02)
  IN3 w0.094: v4(142.66,38.31) 142.61,38.31 v3(142.23,37.97)
DDR_B_D2_0: length 35.8
  IN1 w0.094: v3(149.62,13.34) 149.76,13.34 v2(150.05,13.62)
  IN3 w0.094: v4(139.09,35.93) 139.38,35.64 139.38,34.99 139.7,34.68 139.7,30.79 141.54,28.95 141.54,25.8 141.65,25.69 141.95,25.69 142.06,25.58 142.06,25.43 141.95,25.32 141.65,25.32 141.54,25.21 141.54,25.05 141.65,24.94 141.95,24.94 142.06,24.83 142.06,24.68 141.95,24.57 141.65,24.57 141.54,24.46 141.54,24.3 141.65,24.19 141.95,24.19 142.06,24.08 142.06,23.93 141.95,23.82 141.65,23.82 141.54,23.71 141.54,18.81 141.86,18.5 141.86,15.63 141.97,15.52 142.78,15.52 142.88,15.42 142.88,15.22 142.78,15.12 141.97,15.12 141.86,15.01 141.86,14.84 141.99,14.7 142.88,14.7 143.33,14.26 143.38,14.26 143.75,13.89 144.97,13.89 145.31,13.56 145.81,13.56 146.19,13.18 148.06,13.18 148.57,13.69 149.27,13.69 v3(149.62,13.34)
DDR_B_D2_1: length 36.3
  IN3 w0.094: v4(139.09,36.59) 139.57,36.59 139.66,36.49 139.66,36.09 139.61,36.04 139.61,35.02 139.95,34.69 139.95,30.89 142.31,28.53 142.31,22.71 142.29,22.68 142.29,21.75 142.18,21.64 141.9,21.64 141.79,21.53 141.79,21.37 141.9,21.26 142.18,21.26 142.29,21.15 142.29,21 142.18,20.89 141.9,20.89 141.79,20.78 141.79,20.62 141.9,20.51 142.18,20.51 142.29,20.4 142.29,20.25 142.18,20.14 141.9,20.14 141.79,20.03 141.79,19.87 141.9,19.76 142.18,19.76 142.29,19.65 142.29,19.45 142.17,19.33 141.89,19.33 141.79,19.23 141.79,18.92 142.11,18.6 142.11,15.87 142.21,15.77 142.81,15.77 142.89,15.85 142.89,16.43 143.04,16.58 143.42,16.58 143.61,16.39 143.61,15.1 144.09,14.62 145.12,14.62 145.4,14.33 145.74,14.33 145.97,14.1 145.97,13.82 146.34,13.45 147.85,13.45 148.34,13.94 148.98,13.94 149.32,14.27 v3(150.05,14.27)
DDR_B_D2_2: length 35
  IN3 w0.094: v4(139.09,35.28) 139.08,35.27 139.08,35.02 139.45,34.64 139.45,30.69 141.27,28.87 141.27,22.58 141.16,22.47 141.03,22.47 140.92,22.36 140.92,22.2 141.03,22.09 141.16,22.09 141.27,21.98 141.27,21.82 141.16,21.71 141.03,21.71 140.92,21.6 140.92,21.45 141.03,21.34 141.16,21.34 141.27,21.23 141.27,21.07 141.16,20.96 141.03,20.96 140.92,20.85 140.92,20.7 141.03,20.59 141.16,20.59 141.27,20.48 141.27,18.73 141.6,18.39 141.6,15.56 141.49,15.45 141.2,15.45 141.1,15.35 141.1,15.15 141.2,15.05 141.49,15.05 141.6,14.93 141.6,14.57 141.72,14.45 141.91,14.45 143.25,13.11 145.34,13.11 145.38,13.15 145.96,13.15 146.12,13 149.8,13 150.08,13.28 150.08,13.48 150.28,13.68 150.92,13.68 150.99,13.61 151.63,13.61 v3(151.65,13.62)
DDR_B_D2_3: length 36.6
  IN1 w0.094: v2(150.05,12.32) 150.05,12.29 v3(150.3,12.03)
  IN3 w0.094: v3(150.3,12.03) 150.14,11.87 149.72,11.87 149.2,11.35 147.41,11.35 147.15,11.08 142.59,11.08 139.71,13.97 139.71,28.73 138.25,30.19 138.25,34.99 138.08,35.15 138.08,36.98 v4(137.83,37.24)
DDR_B_D2_4: length 36.6
  IN3 w0.094: v3(151.65,14.27) 151.25,14.67 148.96,14.67 148.92,14.63 148.49,14.63 147.78,13.92 147.09,13.92 146.77,14.24 146.21,14.24 145.94,14.52 145.48,14.52 145.08,14.92 144.25,14.92 143.84,15.33 143.84,16.65 143.63,16.86 143.63,17.78 143.53,17.88 142.63,17.88 142.54,17.98 142.54,21.37 142.56,21.39 142.56,21.81 142.67,21.92 143.08,21.92 143.19,22.03 143.19,22.19 143.08,22.3 142.67,22.3 142.56,22.41 142.56,22.56 142.67,22.67 143.08,22.67 143.19,22.78 143.19,22.94 143.08,23.05 142.67,23.05 142.56,23.16 142.56,23.32 142.67,23.43 143.08,23.43 143.19,23.54 143.19,23.69 143.08,23.8 142.67,23.8 142.56,23.91 142.56,28.63 140.19,31 140.19,34.66 140.16,34.74 139.8,35.1 139.8,35.97 139.84,36.01 139.84,36.57 139.74,36.67 139.74,37.03 139.54,37.24 v4(139.09,37.24)
DDR_B_D2_5: length 38.6
  IN3 w0.094: v3(151.65,11.67) 151.65,11.36 150.43,10.15 142.47,10.15 138.92,13.69 138.92,28.47 137.51,29.88 137.51,34.54 137.51,34.54 137.51,36.27 v4(137.83,36.59)
DDR_B_D2_6: length 38
  IN3 w0.094: v3(151.65,12.32) 151.64,12.32 150.93,12.32 150.84,12.22 150.84,11.32 149.91,10.39 142.58,10.39 139.17,13.79 139.17,28.56 137.75,29.98 137.75,34.61 137.7,34.67 137.7,35.37 137.83,35.5 v4(137.83,35.93)
DDR_B_D2_7: length 34.8
  IN1 w0.094: v3(149.68,11.37) 149.64,11.37 149.64,11.41 149.78,11.41 v2(150.05,11.67)
  IN3 w0.094: v3(149.68,11.37) 149.68,10.91 149.41,10.64 142.68,10.64 139.43,13.9 139.43,28.66 138,30.09 138,34.86 v4(137.97,34.89)
  BOTTOM w0.089: v4(137.97,34.89) 137.83,35.04 UC1.AM49
DDR_B_D3_0: length 33.5
  TOP w0.107: UD2.V2 144.32,13.62 144.16,13.78 144.16,13.8 v2(144.14,13.8)
  IN1 w0.094: v3(139.47,38.77) 139.58,38.65 139.58,38.3 139.79,38.09 139.79,37.04 139.46,36.71 139.46,25.85 140.51,24.8 140.51,20.48 140.66,20.33 141.14,20.33 142.19,19.28 142.19,18.08 142.3,17.97 142.43,17.97 142.54,17.86 142.54,17.7 142.43,17.59 142.3,17.59 142.19,17.48 142.19,17.33 142.3,17.22 142.43,17.22 142.54,17.11 142.54,16.95 142.43,16.84 142.3,16.84 142.19,16.73 142.19,16.57 142.3,16.46 142.82,16.46 142.93,16.35 142.93,16.2 142.82,16.09 142.3,16.09 142.19,15.98 142.19,15.82 142.3,15.71 142.74,15.71 142.85,15.6 142.85,15.4 142.75,15.3 142.26,15.3 142.19,15.23 142.19,14.43 142.28,14.34 142.48,14.34 142.58,14.44 142.58,14.79 142.69,14.9 142.82,14.9 142.95,14.76 142.95,14.41 143.05,14.32 143.29,14.32 143.37,14.39 143.53,14.39 143.63,14.3 143.63,14.09 143.93,13.78 144.16,13.78 144.16,13.8 v2(144.14,13.8)
  IN3 w0.094: v3(139.47,38.77) v4(139.92,38.96)
DDR_B_D3_1: length 34.1
  IN1 w0.094: v3(139.47,40.63) 139.82,40.28 139.82,38.41 139.98,38.25 139.98,36.96 139.72,36.69 139.72,25.94 141.32,24.34 141.32,23.23 141.17,23.08 141.17,22.67 141.45,22.4 141.45,22.12 141.34,22.02 140.91,22.02 140.8,21.91 140.8,21.48 140.89,21.38 142.04,21.38 142.11,21.31 142.11,21.07 142.04,20.99 141.19,20.99 141.1,20.9 141.1,20.69 141.17,20.62 141.53,20.62 141.63,20.52 141.63,20.2 141.7,20.12 141.84,20.12 142.3,20.59 142.43,20.59 142.66,20.36 142.66,20.13 142.53,20 142.32,20 142.14,19.82 142.14,19.68 142.28,19.54 142.49,19.54 142.65,19.38 142.65,18.38 143.58,17.45 143.58,16.8 143.92,16.47 143.92,14.8 v2(144.44,14.27)
  IN3 w0.094: v3(139.47,40.63) v4(139.92,40.26)
DDR_B_D3_2: length 32.3
  IN1 w0.094: v3(138.55,37.92) 138.52,37.89 138.52,36.85 138,36.33 138,25.17 139,24.16 139,19.92 139.51,19.42 139.51,19.15 139.4,19.04 139.12,19.04 139.01,18.93 139.01,18.78 139.12,18.67 139.4,18.67 139.51,18.56 139.51,18.4 139.4,18.29 139.12,18.29 139.01,18.18 139.01,18.03 139.12,17.92 139.4,17.92 139.51,17.81 139.51,14.53 141.9,12.14 144.26,12.14 v2(144.44,12.32)
  IN3 w0.094: v3(138.55,37.92) v4(139,38.31)
DDR_B_D3_3: length 33
  IN1 w0.094: v3(140.38,40.63) 140.02,40.28 140.02,38.54 140.17,38.4 140.17,36.88 139.97,36.68 139.97,26.04 141.57,24.44 141.57,24.06 141.68,23.95 141.89,23.95 141.98,23.86 141.98,23.66 141.89,23.58 141.68,23.58 141.57,23.47 141.57,22.62 141.66,22.54 142.21,22.54 142.36,22.39 142.36,22.12 142.25,22.01 141.68,22.01 141.57,21.9 141.57,21.74 141.68,21.63 142.25,21.63 142.36,21.52 142.36,21 142.9,20.46 142.9,18.48 143.9,17.48 143.9,17.05 144.11,16.85 144.11,15.34 144.34,15.11 144.34,14.85 144.45,14.74 144.61,14.74 144.69,14.82 144.84,14.82 145.06,14.6 145.36,14.6 145.55,14.79 145.77,14.79 145.89,14.67 145.89,14.43 v2(146.04,14.27)
  IN3 w0.094: v3(140.38,40.63) v4(139.92,40.91)
DDR_B_D3_4: length 38.2
  IN1 w0.094: v3(138.55,41.37) 137.99,40.81 137.99,38.57 137.83,38.42 137.83,37.02 137.24,36.42 137.24,24.88 138.25,23.87 138.25,14.63 142.09,10.79 145.26,10.79 146.04,11.58 v2(146.04,11.67)
  IN3 w0.094: v4(139,40.91) 139,40.96 138.6,41.37 v3(138.55,41.37)
DDR_B_D3_5: length 37.2
  IN1 w0.094: v2(146.04,12.32) 146.04,12.03 145.79,11.78 145.79,11.59 145.24,11.04 142.25,11.04 138.5,14.79 138.5,23.97 137.49,24.97 137.49,36.36 138.03,36.9 138.03,38.14 138.19,38.29 138.19,40.27 v3(138.55,40.63)
  IN3 w0.094: v3(138.55,40.63) v4(139,40.26)
DDR_B_D3_6: length 32.3
  IN1 w0.094: v3(138.55,38.77) 138.51,38.73 138.51,38.35 138.22,38.06 138.22,36.82 137.75,36.34 137.75,25.07 138.75,24.07 138.75,17.75 138.87,17.63 139.15,17.63 139.26,17.52 139.26,14.43 141.8,11.89 144.23,11.89 v2(144.44,11.67)
  IN3 w0.094: v3(138.55,38.77) v4(139,38.96)
DDR_B_D3_7: length 32
  IN1 w0.094: v3(139.47,37.92) 139.47,36.97 139.21,36.72 139.21,25.75 140.26,24.7 140.26,20.38 140.56,20.08 141.04,20.08 141.93,19.19 141.93,16.85 141.84,16.76 141.62,16.76 141.52,16.66 141.52,16.46 141.61,16.36 141.87,16.36 141.93,16.3 141.93,16.08 141.82,15.97 141.63,15.97 141.52,15.86 141.52,15.7 141.63,15.59 141.82,15.59 141.93,15.48 141.93,14.32 142.22,14.04 142.22,13.54 142.4,13.35 144.06,13.35 144.54,13.84 144.98,13.84 145.23,13.59 146.01,13.59 v2(146.04,13.62)
  IN3 w0.094: v3(139.47,37.92) v4(139.92,38.31)
DDR_B_DQS0: length 19.5
  IN3 w0.097: v4(141.19,36.52) 141.18,36.52 141.09,36.52 141.01,36.44 141.01,36.31 141.33,35.99 141.33,35.18 141.66,34.85 141.66,34.17 141.98,33.85 141.98,31.74 149.01,24.71 149.01,23.59 150.25,22.36 150.48,22.36 v3(150.85,22.72)
  BOTTOM w0.089: v4(141.19,36.52) 141.12,36.58 140.99,36.58 140.9,36.49 140.9,36.32 UC1.AV47
DDR_B_DQS1: length 19.7
  IN1 w0.097: v3(142.21,39.52) 141.87,39.17 141.87,37.71 141.79,37.62 141.79,26.76 143.75,24.79 143.75,23.46 144.81,22.4 145.17,22.4 145.27,22.5 145.27,22.7 v2(145.24,22.72)
  IN3 w0.097: v4(142.66,39.61) v3(142.21,39.52)
DDR_B_DQS2: length 35.7
  IN1 w0.097: v3(151.12,13.28) 151.12,13.25 v2(150.85,12.97)
  IN3 w0.097: v4(138.46,36.26) 138.63,36.09 138.63,34.82 138.75,34.7 138.75,30.4 140.22,28.93 140.22,14.2 142.13,12.28 145.5,12.28 145.51,12.27 145.96,12.27 145.97,12.28 146.62,12.28 146.83,12.07 149.84,12.07 150.3,12.52 150.67,12.52 150.89,12.74 150.89,13.04 v3(151.12,13.28)
DDR_B_DQS3: length 33.3
  TOP w0.099: UD2.W3 145.18,12.91 144.99,12.91 144.89,13.01 144.89,13.15 v2(145.01,13.27)
  IN1 w0.097: v3(139.47,39.52) 139.18,39.52 139.08,39.42 139.08,36.86 138.71,36.48 138.71,25.46 139.71,24.46 139.71,20.22 140.21,19.71 140.21,14.83 142.19,12.84 145.05,12.84 145.23,13.03 145.23,13.24 145.2,13.27 v2(145.01,13.27)
  IN3 w0.097: v3(139.47,39.52) v4(139.92,39.61)
DDR_B_DQS#0: length 19.4
  IN3 w0.097: v4(140.96,36.91) 140.96,36.68 140.81,36.53 140.81,36.22 141.13,35.9 141.13,35.1 141.46,34.77 141.46,34.09 141.78,33.76 141.78,31.65 148.81,24.63 148.81,23.51 150.16,22.16 150.76,22.16 v3(150.85,22.07)
DDR_B_DQS#1: length 19.8
  IN1 w0.097: v2(145.24,22.07) 145.12,22.2 144.72,22.2 143.55,23.37 143.55,24.71 141.58,26.67 141.58,37.71 141.67,37.79 141.67,39.14 v3(141.3,39.52)
  IN3 w0.097: v4(141.75,39.61) v3(141.3,39.52)
DDR_B_DQS#2: length 35.8
  IN1 w0.089: v2(150.85,13.62) 150.53,13.31 v3(150.53,13.3)
  IN3 w0.097: v4(138.46,36.91) 138.83,36.54 138.83,34.91 138.95,34.79 138.95,30.48 140.42,29.01 140.42,14.28 142.22,12.48 145.59,12.48 145.6,12.47 145.88,12.47 145.89,12.48 146.71,12.48 146.92,12.27 149.76,12.27 150.21,12.73 150.59,12.73 150.68,12.82 150.68,13.15 v3(150.53,13.3)
DDR_B_DQS#3: length 33.4
  TOP w0.099: UD2.V3 145.48,13.39 v2(145.48,13.3)
  IN1 w0.097: v3(138.55,39.52) 138.88,39.18 138.88,36.94 138.5,36.57 138.5,25.37 139.5,24.37 139.5,20.13 140.01,19.63 140.01,14.74 142.11,12.64 144.97,12.64 145.14,12.64 145.44,12.94 145.44,13.25 145.47,13.29 145.47,13.3 v2(145.48,13.3)
  IN3 w0.097: v3(138.55,39.52) v4(139,39.61)
DDR_B_ODTA: length 3.9
  TOP w0.069: RD29.1 RD30.1 142.81,20.23 143.03,20.45 143.18,20.45
  TOP w0.102: UD2.G2 144.12,20.45 143.18,20.45
DDR_B_ODTB: length 3.8
  TOP w0.069: 143.18,15.25 142.27,15.25 142.05,15.47 RD31.1 RD32.1
  TOP w0.102: UD2.T2 144.12,15.25 143.18,15.25
DDR_C_CA0: length 37.1
  IN1 w0.094: v2(126.03,20.12) 125.75,19.68 125.59,19.29 125.59,19.08 125.45,18.64 125.35,18.55 125.07,18.07 125.04,17.97 125.04,17.78 125.09,17.61 v3(125.37,17.3) 125.52,17.14 125.52,16.79 125.37,16.64 125.37,16.5 125.44,16.43 125.64,16.43 125.73,16.34 125.73,16.22 125.41,15.9 125.41,15.77 125.51,15.68 125.61,15.68 125.83,15.89 126.06,15.89 126.11,15.84 126.11,15.67 126.03,15.59 v2(126.03,15.57)
  IN3 w0.094: v3(125.37,17.3) 125.7,17.3 125.94,17.53 125.99,17.53 126.27,17.82 126.27,18.77 126.07,18.97 126.07,19.16 125.96,19.27 125.94,19.27 125.83,19.38 125.83,19.54 125.94,19.65 125.96,19.65 126.07,19.76 126.07,19.91 125.96,20.02 125.94,20.02 125.83,20.13 125.83,20.29 125.94,20.4 125.96,20.4 126.07,20.51 126.07,20.67 125.96,20.78 125.94,20.78 125.83,20.89 125.83,21.04 125.94,21.15 126.13,21.15 126.22,21.24 126.22,21.46 126.07,21.61 126.07,22.25 126.1,22.28 126.1,22.77 126.24,22.91 126.24,23.15 126.1,23.29 125.92,23.29 125.81,23.4 125.81,23.57 125.94,23.71 126.14,23.71 126.24,23.81 126.24,26.46 126.42,26.64 127.03,26.64 127.15,26.75 127.15,26.88 127.05,26.98 126.31,26.98 126.25,27.04 126.25,27.24 126.32,27.32 127.05,27.32 127.15,27.42 127.15,27.73 127.36,27.93 127.36,28.11 127.29,28.18 125.77,28.18 125.68,28.27 125.68,28.4 126.09,28.82 126.25,28.82 126.53,28.54 127.65,28.54 127.75,28.64 127.75,29.32 127.64,29.43 127.1,29.43 126.99,29.54 126.99,29.69 127.1,29.8 127.64,29.8 127.75,29.91 127.75,33.25 127.86,33.36 128.38,33.36 128.49,33.47 128.49,33.63 128.38,33.74 127.86,33.74 127.75,33.85 127.75,34.45 127.89,34.59 128.04,34.59 128.33,34.31 128.48,34.31 128.66,34.49 128.66,34.69 128.39,34.97 128.39,35.09 128.58,35.28 v4(129.07,35.28)
DDR_C_CA1: length 36.6
  IN1 w0.089: v3(125.89,17.9) 126.07,18.08 126.07,18.41 125.77,18.71 125.77,19.21 v2(126.03,19.47)
  IN1 w0.094: v3(125.89,17.9) 125.89,17.47 125.71,17.28 125.71,16.74 126.03,16.41 v2(126.03,16.22)
  IN3 w0.094: v3(125.89,17.9) 125.95,17.9 126.08,18.03 126.08,18.64 125.98,18.74 125.74,18.74 125.65,18.83 125.65,21.05 125.58,21.12 125.58,21.27 125.26,21.58 125.26,22.14 125.37,22.25 125.79,22.25 125.88,22.34 125.88,22.53 125.79,22.63 125.37,22.63 125.25,22.74 125.25,24.42 125.36,24.53 125.88,24.53 125.99,24.64 125.99,24.8 125.88,24.91 125.36,24.91 125.25,25.02 125.25,25.17 125.36,25.28 125.92,25.28 125.99,25.35 125.99,25.59 125.92,25.66 125.36,25.66 125.25,25.77 125.25,25.93 125.36,26.04 125.91,26.04 125.99,26.12 125.99,26.33 125.91,26.41 125.36,26.41 125.25,26.52 125.25,26.72 125.34,26.81 125.92,26.81 125.99,26.88 125.99,27.1 125.92,27.17 125.35,27.17 125.25,27.26 125.25,27.47 125.35,27.56 126.75,27.56 126.82,27.63 126.82,27.86 126.75,27.93 125.39,27.93 125.25,28.07 125.25,28.32 126.09,29.16 126.26,29.16 126.63,28.79 127.43,28.79 127.5,28.86 127.5,29.09 127.41,29.18 126.84,29.18 126.75,29.27 126.75,29.82 126.98,30.05 127.38,30.05 127.47,30.14 127.47,34.54 128.53,35.6 129,35.6 129.33,35.92 129.33,36.47 129.21,36.59 v4(129.07,36.59)
DDR_C_CA2: length 37.7
  IN1 w0.094: v2(131.63,15.57) 132.05,15.57 132.17,15.7 132.17,16.08 131.99,16.25 131.99,17.11 131.9,17.21 131.69,17.21 131.62,17.14 131.54,17.14 v3(131.33,17.35) 131.33,18.11 131.46,18.62 131.89,19.26 131.89,19.52 v2(131.63,20.12)
  IN3 w0.094: v3(131.33,17.35) 131.33,17.32 131.05,17.04 127.64,17.04 127.45,17.22 127.24,17.22 127.06,17.04 126.71,17.04 126.55,17.2 126.55,17.36 126.47,17.44 126.47,18.65 126.98,19.16 126.98,19.26 126.76,19.48 126.76,19.78 126.98,20 126.98,20.16 126.76,20.38 126.76,20.7 127.14,21.07 127.14,21.27 126.83,21.58 126.83,22.04 126.96,22.17 126.96,22.35 126.42,22.9 126.42,23.55 126.6,23.72 126.6,23.98 126.42,24.15 126.42,24.8 126.49,24.87 126.49,25.48 126.6,25.59 126.87,25.59 126.96,25.49 126.96,25.06 127.06,24.96 127.33,24.96 127.4,25.03 127.4,25.85 127.29,25.96 126.6,25.96 126.49,26.07 126.49,26.27 126.61,26.39 127.31,26.39 127.4,26.48 127.4,27.62 127.67,27.89 127.87,27.89 128,27.75 128.67,27.75 128.72,27.8 128.72,28.07 128.64,28.14 128.14,28.14 127.99,28.29 127.99,33.04 128.06,33.11 128.27,33.11 128.44,32.94 128.63,32.94 128.74,33.05 128.74,34.28 129.75,35.3 130.31,35.3 v4(130.32,35.28)
DDR_C_CA3: length 36
  IN1 w0.094: v2(132.43,20.12) 132.43,19.58 132.12,18.86 132.12,18.7 132.16,18.22 132.17,18.08 132.19,17.9 v3(132.37,17.45) 132.37,17.23 132.47,17.14 132.7,17.14 133.05,16.79 133.05,16.67 132.96,16.58 132.86,16.58 132.77,16.48 132.77,16.19 132.68,16.1 132.45,16.1 132.35,16 132.35,15.65 v2(132.43,15.57)
  IN3 w0.094: v4(127.77,37.24) 128.03,36.97 128.25,36.97 128.43,36.79 128.43,36.14 128.36,36.06 128.19,36.06 128.12,36.12 127.97,36.12 127.86,36.01 127.86,35.86 127.98,35.74 127.98,35.58 127.21,34.82 127.21,30.63 125.01,28.43 125.01,21.43 125.46,20.97 125.46,18.76 125.3,18.6 125.3,18.55 125.01,18.26 125.01,17.19 125.36,16.83 131.48,16.83 131.95,17.3 132.22,17.3 v3(132.37,17.45)
DDR_C_CA4: length 36.4
  IN1 w0.094: v2(133.23,20.12) 133.57,19.79 133.57,17.63 v3(133.25,17.32) 133.49,17.08 133.49,16.28 133.58,16.2 133.58,15.29 133.5,15.21 133.15,15.21 133.06,15.3 133.06,15.43 133.2,15.57 v2(133.23,15.57)
  IN3 w0.094: v4(127.77,36.59) 127.4,36.22 127.13,35.34 126.72,34.93 126.72,30.84 124.51,28.63 124.51,16.97 125.11,16.38 131.61,16.38 132.32,16.83 132.67,16.83 132.83,16.94 v3(133.25,17.32)
DDR_C_CA5: length 36.6
  IN1 w0.094: v2(133.23,19.47) 133.23,19.26 132.91,18.94 132.91,17.9 v3(133.01,17.8) 132.8,17.59 132.8,17.29 133.23,16.86 v2(133.23,16.22)
  IN3 w0.094: v4(129.07,37.24) 127.95,37.49 127.66,37.49 127.51,37.34 127.51,37.13 127.73,36.92 127.79,36.92 128.02,36.69 128.02,36.47 127.57,36.02 127.57,35.46 126.97,34.86 126.97,30.73 124.76,28.53 124.76,21.24 125.24,20.77 125.24,18.84 124.76,18.36 124.76,17.08 125.21,16.63 131.6,16.63 132.05,17.09 132.53,17.09 132.83,17.39 v3(133.01,17.8)
DDR_C_CKE0: length 33.2
  IN1 w0.094: v2(127.63,16.22) 128.4,17.15 128.56,17.41 128.62,17.53 128.62,17.8 128.56,17.96 v3(128.46,18.15) 128.43,18.18 128.43,18.44 128.5,18.51 128.59,18.51 128.65,18.58 128.65,18.87 128.59,18.93 127.9,18.93 127.63,19.2 v2(127.63,19.47)
  IN3 w0.094: v3(128.46,18.15) 128.39,18.22 127.99,18.22 127.4,18.81 127.4,19.17 127.51,19.28 127.62,19.28 127.73,19.38 127.73,19.54 127.62,19.65 127.51,19.65 127.4,19.76 127.4,19.92 127.51,20.03 127.59,20.03 127.69,20.13 127.69,20.29 127.58,20.4 127.51,20.4 127.4,20.51 127.4,20.72 127.74,21.07 127.92,21.07 128.01,21.16 128.01,21.35 127.95,21.42 127.76,21.42 127.5,21.68 127.5,22.12 127.6,22.22 127.88,22.22 127.98,22.32 127.98,22.58 127.66,22.89 127.22,22.89 127.13,22.99 127.13,23.24 127.22,23.33 127.7,23.33 127.77,23.39 127.96,23.39 128.05,23.48 128.05,23.72 127.96,23.81 127.6,23.81 127.51,23.91 127.51,24.11 127.6,24.2 127.67,24.2 127.89,24.42 127.89,26.28 129.23,27.62 129.23,28.5 129.09,28.64 128.58,28.64 128.49,28.73 128.49,30.26 128.61,30.39 128.61,30.52 128.49,30.65 128.49,32.3 128.63,32.44 129.1,32.44 129.23,32.57 129.23,34.21 129.61,34.59 130.27,34.59 130.98,35.3 130.98,35.86 130.67,36.16 130.44,36.16 130.29,36.31 130.29,36.72 130.49,36.92 130.77,36.92 131.08,37.23 131.08,37.46 130.9,37.64 130.72,37.64 v4(130.32,37.24)
DDR_C_CKE1: length 33.9
  IN1 w0.094: v2(128.43,19.47) 128.43,19.74 128.52,19.83 129.31,19.83 129.4,19.74 129.4,19.59 129.32,19.51 129.31,19.51 129.25,19.44 129.25,19.24 129.32,19.16 129.38,19.16 129.48,19.07 129.48,18.69 v3(129.44,18.65) 128.48,16.27 v2(128.43,16.22)
  IN3 w0.094: v4(131.31,36.92) 131.32,36.91 131.62,36.91 131.84,36.69 131.84,35.77 131.7,35.63 131.7,35.13 131.08,34.51 131.08,34.07 130.98,33.98 130.8,33.98 130.71,33.89 130.71,33.75 130.8,33.66 130.94,33.66 131.08,33.53 131.08,33.21 130.59,32.73 130.59,26.73 129.85,25.99 129.85,24.41 129.29,23.85 129.29,23.34 129.49,23.14 129.49,23 129.31,22.81 129.31,22.6 129.4,22.51 129.66,22.51 129.77,22.4 129.77,22.24 129.66,22.13 129.06,22.13 129,22.06 129,21.84 129.07,21.76 129.66,21.76 129.77,21.65 129.77,21.49 129.66,21.38 129.37,21.38 129.26,21.27 129.26,21.12 129.37,21.01 129.66,21.01 129.77,20.9 129.77,20.74 129.66,20.63 129.37,20.63 129.26,20.52 129.26,20.36 129.37,20.25 129.99,20.25 130.1,20.14 130.1,19.99 129.99,19.88 129.04,19.88 129,19.83 129,19.6 129.07,19.53 130.51,19.53 130.67,19.37 130.67,19.07 130.52,18.92 130.37,18.92 130.12,19.16 129.27,19.16 129.18,19.07 129.18,18.92 v3(129.44,18.65)
  BOTTOM w0.107: UC1.V46 v4(131.31,36.92)
DDR_C_CLK: length 35.2
  IN1 w0.097: v2(130.83,19.47) 130.98,19.47 131.08,19.37 131.08,19.23 130.99,19.14 130.79,19.14 130.39,18.74 130.39,18.07 v3(130.22,17.9) 130.44,17.67 130.44,17.42 131.1,16.76 131.1,16.34 130.98,16.22 v2(130.83,16.22)
  IN3 w0.097: v3(130.22,17.9) 130.06,18.06 129.63,18.06 129.36,17.79 129,17.79 128.79,18 128.79,18.45 128.4,18.85 128.4,24.54 128.59,24.73 128.88,24.73 129.01,24.59 129.15,24.59 129.28,24.73 129.28,25.15 129.19,25.25 128.49,25.25 128.28,25.46 128.28,25.91 128.49,26.13 128.99,26.13 129.1,26.23 129.1,26.36 128.98,26.48 128.98,26.78 129.24,27.04 129.79,27.04 129.89,27.14 129.89,27.39 129.73,27.54 129.73,28.01 129.89,28.17 129.89,28.4 129.73,28.56 129.73,28.92 129.89,29.08 129.89,29.28 129.79,29.38 129.71,29.38 129.5,29.18 129.16,29.18 129,29.35 129,30.06 129.26,30.32 129.79,30.32 129.89,30.42 129.89,30.76 129.79,30.85 129.22,30.85 128.99,31.08 128.99,31.52 129.2,31.74 130.07,31.74 130.17,31.84 130.17,32.11 130.07,32.2 129.66,32.2 129.45,32.42 129.45,32.8 129.66,33.01 130.3,33.01 130.4,33.11 130.4,33.38 130.29,33.49 129.63,33.49 129.42,33.7 129.42,34.12 129.7,34.39 130.59,34.39 130.69,34.49 130.69,34.67 131.23,35.21 131.23,35.89 131.32,35.98 131.32,36.05 131.58,36.31 v4(131.58,36.59)
DDR_C_CLK#: length 35.2
  IN1 w0.097: v2(131.63,19.47) 131.62,19.47 131.08,18.93 130.87,18.93 130.6,18.65 130.6,18.1 v3(130.82,17.88) 130.65,17.71 130.65,17.5 131.31,16.84 131.31,16.37 131.45,16.22 v2(131.63,16.22)
  IN3 w0.097: v3(130.82,17.88) 130.6,18.1 130.6,18.4 130.5,18.5 130.23,18.5 130.16,18.43 130.16,18.35 130.08,18.26 129.55,18.26 129.27,17.99 129.09,17.99 128.99,18.09 128.99,18.54 128.6,18.93 128.6,24.45 128.67,24.53 128.79,24.53 128.93,24.39 129.23,24.39 129.49,24.64 129.49,25.23 129.27,25.45 128.58,25.45 128.48,25.55 128.48,25.83 128.58,25.92 129.08,25.92 129.3,26.15 129.3,26.44 129.18,26.56 129.18,26.7 129.32,26.84 129.88,26.84 130.09,27.06 130.09,27.47 129.93,27.63 129.93,27.92 130.09,28.08 130.09,28.49 129.93,28.64 129.93,28.84 130.09,29 130.09,29.37 129.88,29.58 129.62,29.58 129.42,29.38 129.25,29.38 129.2,29.43 129.2,29.97 129.34,30.12 129.87,30.12 130.09,30.33 130.09,30.84 129.87,31.06 129.31,31.06 129.19,31.17 129.19,31.44 129.29,31.54 130.15,31.54 130.37,31.75 130.37,32.19 130.15,32.41 129.75,32.41 129.65,32.5 129.65,32.71 129.75,32.81 130.38,32.81 130.6,33.03 130.6,33.46 130.37,33.69 129.72,33.69 129.62,33.78 129.62,34.03 129.78,34.19 130.68,34.19 130.89,34.41 130.89,34.59 131.43,35.13 131.43,35.81 131.56,35.93 131.58,35.93 v4(131.58,35.93)
DDR_C_CS#0: length 35.9
  IN1 w0.094: v2(127.63,20.12) 127.33,19.82 127.33,19.12 127.32,19.12 127.32,18.59 127.78,18.12 v3(127.78,17.73) 127.32,17.27 127.32,17.18 127.15,17 127.15,16.6 127.33,16.42 127.33,15.74 127.5,15.57 v2(127.63,15.57)
  IN3 w0.094: v3(127.78,17.73) 127.78,18.08 127.04,18.82 127.04,18.96 127.16,19.09 127.16,19.34 126.94,19.56 126.94,19.7 127.16,19.92 127.16,20.23 126.94,20.45 126.94,20.62 127.32,21 127.32,21.38 127.02,21.68 127.02,21.95 127.22,22.15 127.22,22.55 127.12,22.64 126.93,22.64 126.78,22.8 126.78,23.01 126.61,23.18 126.61,23.42 126.9,23.71 126.9,23.99 126.71,24.19 126.71,24.59 126.82,24.71 127.21,24.71 127.41,24.52 127.59,24.52 127.65,24.58 127.65,26.62 127.74,26.72 127.98,26.72 128.12,26.85 128.12,27.02 128.02,27.11 127.74,27.11 127.65,27.21 127.65,27.41 127.74,27.5 128.77,27.5 128.98,27.72 128.98,28.3 128.9,28.39 128.34,28.39 128.24,28.48 128.24,32.54 128.39,32.69 128.77,32.69 128.98,32.91 128.98,34.27 129.5,34.79 130.19,34.79 130.6,35.2 130.6,35.4 130.42,35.58 129.81,35.58 129.6,35.78 129.6,36.06 129.99,36.44 129.99,36.82 129.86,36.95 129.73,36.95 129.48,37.2 129.48,37.53 129.96,38 129.96,38.42 129.78,38.6 129.78,38.8 129.91,38.93 130.11,38.93 130.27,38.78 v4(130.44,38.78)
  BOTTOM w0.107: UC1.V42 v4(130.44,38.78)
DDR_C_CS#1: length 35.2
  IN1 w0.094: v2(126.83,20.12) 126.95,20.12 127.12,19.96 127.12,19.3 126.97,19.15 126.77,19.15 126.39,18.77 126.39,18.4 v3(126.86,17.93) 126.86,17.91 126.51,17.56 126.51,16.76 126.65,16.61 126.82,16.61 127.14,16.29 127.14,16.05 126.83,15.73 v2(126.83,15.57)
  IN3 w0.094: v4(130.77,40.26) 131.04,39.98 131.04,39.53 130.85,38.83 130.85,38.41 130.99,38.09 131.68,37.24 131.8,36.99 132.07,36.72 132.07,35.73 131.89,35.55 131.89,34.99 131.26,34.36 131.26,33.14 130.84,32.72 130.84,26.63 130.09,25.88 130.09,24.31 129.78,24 129.78,23.19 129.95,22.93 129.95,20.95 130.01,20.75 130.16,20.54 130.26,20.46 130.4,20.38 130.54,20.38 130.67,20.31 130.8,20.17 130.84,20.08 130.88,19.68 131.28,18.52 131.28,18.24 131.23,17.93 131.15,17.74 130.95,17.55 130.27,17.38 129.78,17.33 128.06,17.33 127.75,17.39 127.49,17.49 v3(126.86,17.93)
DDR_C_D0_0: length 38.1
  IN1 w0.094: v2(126.03,11.67) 126.03,11.64 v3(125.79,11.41)
  IN3 w0.094: v4(136.59,35.93) 136.85,35.67 136.85,34.83 136.67,34.65 136.67,29.53 137.55,28.65 137.55,20.62 137.43,20.51 137.22,20.51 137.1,20.39 137.1,20.23 137.22,20.11 137.43,20.11 137.55,20 137.55,19.83 137.43,19.72 137.22,19.72 137.1,19.6 137.1,19.44 137.22,19.32 137.43,19.32 137.55,19.2 137.55,19.04 137.43,18.92 137.22,18.92 137.1,18.81 137.1,18.64 137.22,18.53 137.43,18.53 137.55,18.41 137.55,14.04 134.2,10.7 126.44,10.7 125.79,11.35 v3(125.79,11.41)
DDR_C_D0_1: length 41.8
  IN1 w0.094: v2(126.03,13.62) 125.85,13.62 v3(125.66,13.44)
  IN3 w0.094: v4(136.59,37.24) 136.89,36.93 136.89,36.42 137.29,36.02 137.29,34.75 137.16,34.61 137.16,29.74 138.05,28.85 138.05,13.82 134.42,10.19 126.18,10.19 125.15,11.23 125.15,12.92 v3(125.66,13.44)
DDR_C_D0_2: length 37.5
  IN1 w0.094: v2(126.03,12.32) 126.02,12.32 v3(125.72,12.01)
  IN3 w0.094: v3(125.72,12.01) 126.12,11.61 126.12,11.55 126.13,11.54 126.13,11.31 126.48,10.96 134.11,10.96 136.85,13.7 136.85,16.85 136.97,16.96 137.18,16.96 137.29,17.08 137.29,17.24 137.18,17.36 136.97,17.36 136.85,17.47 136.85,17.64 136.97,17.75 137.18,17.75 137.29,17.87 137.29,18.03 137.18,18.15 136.97,18.15 136.85,18.27 136.85,20.79 136.97,20.91 137.18,20.91 137.3,21.03 137.3,22.77 137.18,22.89 136.97,22.89 136.85,23.01 136.85,23.17 136.97,23.29 137.18,23.29 137.3,23.4 137.3,28.56 136.42,29.43 136.42,34.67 136.59,34.84 v4(136.59,35.28)
DDR_C_D0_3: length 34.8
  IN1 w0.094: v3(127.95,14.58) 127.64,14.27 v2(127.63,14.27)
  IN3 w0.094: v3(127.95,14.58) 127.61,14.92 127.1,14.92 126.82,15.21 126.82,16.09 126.92,16.19 129.33,16.19 129.44,16.08 129.44,15.62 129.55,15.51 129.7,15.51 129.81,15.62 129.81,16.08 129.92,16.19 131.76,16.19 131.86,16.09 131.86,15.88 131.95,15.79 132.14,15.79 132.24,15.9 132.24,16.07 132.32,16.15 132.57,16.15 133.61,17.19 133.61,17.96 133,18.57 133,18.83 132.89,18.94 131.84,18.94 131.73,19.05 131.73,19.21 131.84,19.32 132.89,19.32 133,19.43 133,19.68 134.05,20.73 134.05,23.7 134.8,24.45 134.8,28.3 134.48,28.63 134.48,34.04 134.73,34.29 134.73,34.74 134.74,34.75 134.74,34.76 134.99,35.02 134.99,36.25 v4(135.32,36.59)
DDR_C_D0_4: length 41.1
  IN1 w0.094: v3(126.33,14.01) 126.28,14.01 126.03,14.27 v2(126.03,14.27)
  IN3 w0.094: v4(136.59,36.58) 136.59,36.33 137.04,35.87 137.04,34.76 136.91,34.63 136.91,29.64 137.8,28.75 137.8,13.93 134.32,10.45 126.28,10.45 125.34,11.4 125.34,12.79 125.58,13.03 125.73,13.03 126.1,13.41 126.1,13.78 v3(126.33,14.01)
DDR_C_D0_5: length 35
  IN1 w0.094: v3(128.03,12.07) 127.64,11.67 v2(127.63,11.67)
  IN3 w0.094: v3(128.03,12.07) 128.03,12.26 128.18,12.42 128.43,12.42 128.68,12.67 128.95,12.67 129.38,12.24 131.39,12.24 131.59,12.44 131.59,13.63 131.89,13.94 132.61,13.94 132.94,14.27 134.58,14.27 134.86,14.56 134.86,16.88 134.97,16.99 135.33,16.99 135.44,17.1 135.44,17.25 135.33,17.36 134.97,17.36 134.86,17.47 134.86,17.63 134.97,17.74 135.33,17.74 135.44,17.85 135.44,18 135.33,18.11 134.97,18.11 134.86,18.22 134.86,18.57 135.63,19.34 135.63,28.51 135.21,28.93 135.21,34 135.28,34.06 135.28,34.52 135.51,34.75 135.52,34.75 135.83,35.06 135.83,35.76 135.58,36.01 135.58,36.98 v4(135.32,37.24)
DDR_C_D0_6: length 34.3
  IN1 w0.094: v3(128,12.7) 127.63,12.33 v2(127.63,12.32)
  IN3 w0.094: v4(135.32,35.93) 135.62,35.64 135.62,35.1 135.45,34.93 135.43,34.93 135.09,34.59 135.09,34.14 134.97,34.01 134.97,28.83 135.38,28.41 135.38,19.45 134.61,18.67 134.61,16.75 133.91,16.05 133.91,15.35 133.88,15.32 133.88,15.32 133.77,15.22 133.25,15.22 133.17,15.14 133.17,14.79 133.01,14.62 132.58,14.62 132.49,14.71 132.49,15.1 132.38,15.21 132.22,15.21 132.11,15.1 132.11,14.71 131.96,14.55 131.38,14.55 131.21,14.71 131.21,15.06 131.12,15.15 130.84,15.15 130.75,15.06 130.75,14.12 130.41,13.78 129.96,13.78 129.89,13.85 129.89,14.96 129.8,15.04 129.49,15.04 129.42,14.96 129.42,13.46 129.32,13.37 128.67,13.37 v3(128,12.7)
DDR_C_D0_7: length 33.2
  IN1 w0.094: v2(127.63,13.62) 127.77,13.62 v3(128.02,13.88)
  IN3 w0.094: v4(135.32,35.28) 135.32,35.09 134.98,34.74 134.98,34.74 134.91,34.67 134.91,34.21 134.72,34.02 134.72,28.73 135.04,28.41 135.04,24.35 134.77,24.08 134.77,23.7 134.66,23.59 134.5,23.59 134.39,23.48 134.39,23.32 134.5,23.21 134.66,23.21 134.77,23.1 134.77,22.94 134.66,22.83 134.5,22.83 134.39,22.72 134.39,22.57 134.5,22.46 134.66,22.46 134.77,22.35 134.77,22.19 134.66,22.08 134.5,22.08 134.39,21.97 134.39,21.82 134.5,21.71 134.66,21.71 134.77,21.6 134.77,21.44 134.66,21.33 134.5,21.33 134.39,21.22 134.39,21.06 134.5,20.95 134.66,20.95 134.77,20.85 134.77,19.19 134.7,19.12 134.41,19.12 133.64,19.89 133.51,19.89 133.28,19.66 133.28,19.55 133.52,19.3 133.52,19.15 133.31,18.93 133.31,18.78 133.42,18.66 133.57,18.66 133.79,18.88 133.94,18.88 134.36,18.47 134.36,16.86 133.29,15.79 133.29,15.64 133.05,15.4 130.16,15.4 130.03,15.26 128.64,15.26 128.34,14.96 128.34,14.2 v3(128.02,13.88)
DDR_C_D1_0: length 31.7
  IN1 w0.094: v2(131.63,14.27) 131.98,14.63 132.96,14.63 133.3,14.97 133.61,14.97 133.76,15.12 133.76,16.47 134.51,17.21 134.51,19.15 133.6,20.06 133.6,20.46 132.75,21.3 132.75,28.47 134.16,29.88 134.16,36.29 135.09,37.22 135.09,38.35 135.26,38.52 135.26,40.82 v3(135.81,41.37)
  IN3 w0.094: v3(135.81,41.37) 136.26,40.92 v4(136.26,40.91)
DDR_C_D1_1: length 36.1
  IN1 w0.094: v2(131.63,12.32) 131.97,11.98 132.52,11.98 133.14,11.37 135.69,11.37 137.64,13.33 137.64,23.64 136.64,24.64 136.64,36.35 137.43,37.14 137.43,38.25 137.08,38.6 137.08,40.28 v3(136.72,40.63)
  IN3 w0.094: v3(136.72,40.63) v4(137.17,40.26)
DDR_C_D1_2: length 29.8
  IN1 w0.094: v2(133.23,14.27) 133.7,14.27 133.97,14.55 134.53,14.55 135.08,15.09 135.08,17.7 135.08,20.28 134.42,20.95 134.42,24.85 133.59,25.67 133.59,28.96 134.42,29.78 134.42,36.2 135.28,37.06 135.28,38.17 135.44,38.34 135.44,40.27 v3(135.81,40.63)
  IN3 w0.094: v3(135.81,40.63) v4(136.26,40.26)
DDR_C_D1_3: length 31.2
  IN1 w0.094: v3(136.69,38.17) 137.04,37.82 137.04,37.29 136.13,36.38 136.13,21.82 137.14,20.82 137.14,13.54 137,13.39 136.8,13.39 136.67,13.52 136.48,13.52 136.34,13.38 136.34,13.18 136.46,13.06 136.46,12.86 136.07,12.46 134.28,12.46 134.15,12.59 133.5,12.59 v2(133.23,12.32)
  IN3 w0.081: v3(136.69,38.17) 136.83,38.31 v4(137.17,38.31)
DDR_C_D1_4: length 36.5
  IN1 w0.094: v3(137.64,40.63) 137.29,40.29 137.29,38.65 137.63,38.31 137.63,37.08 136.89,36.34 136.89,24.74 137.89,23.73 137.89,13.22 135.79,11.13 131.96,11.13 131.63,11.45 v2(131.63,11.67)
  IN3 w0.094: v3(137.64,40.63) v4(137.17,40.91)
DDR_C_D1_5: length 29.9
  IN1 w0.094: v3(135.8,38.75) 135.69,38.64 135.69,38.32 135.46,38.1 135.46,36.98 134.67,36.18 134.67,30.1 134.67,30.1 134.67,29.69 133.95,28.96 133.95,25.66 134.67,24.94 134.67,21.04 135.33,20.38 135.33,14.99 134.58,14.24 134,14.24 133.77,14.01 132.64,14.01 132.55,13.92 131.93,13.92 v2(131.63,13.62)
  IN3 w0.094: v4(136.26,38.96) 136.05,38.75 v3(135.8,38.75)
DDR_C_D1_6: length 31.8
  IN1 w0.094: v3(136.72,38.78) 136.72,38.64 137.22,38.14 137.22,37.2 136.39,36.37 136.39,21.92 137.39,20.92 137.39,13.43 135.58,11.63 133.28,11.63 v2(133.23,11.67)
  IN3 w0.094: v4(137.17,38.96) 136.99,38.78 v3(136.72,38.78)
DDR_C_D1_7: length 29.8
  TOP w0.107: UD3.V11 v2(133.63,13.62)
  IN1 w0.094: v2(133.63,13.62) 133.66,13.62 134.02,13.99 134.73,13.99 135.63,14.89 135.63,20.43 134.92,21.14 134.92,25.36 134.78,25.5 134.57,25.5 134.43,25.64 134.43,25.84 134.57,25.98 134.78,25.98 134.92,26.12 134.92,26.31 134.78,26.45 134.57,26.45 134.43,26.59 134.43,26.79 134.57,26.93 134.78,26.93 134.92,27.07 134.92,27.26 134.78,27.4 134.57,27.4 134.43,27.54 134.43,27.74 134.57,27.88 134.78,27.88 134.92,28.02 134.92,28.21 134.78,28.35 134.57,28.35 134.43,28.49 134.43,28.69 134.57,28.83 134.78,28.83 134.92,28.97 134.92,36.17 135.79,37.04 135.79,37.91 135.79,37.96 v3(135.79,37.96)
  IN3 w0.094: v3(135.79,37.96) v4(136.26,38.31)
DDR_C_D2_0: length 13.2
  IN1 w0.094: v2(131.63,23.37) 131.63,23.37 131.31,23.69 v3(131.28,23.69)
  IN3 w0.094: v3(131.28,23.69) 131.28,23.72 130.94,24.06 130.94,24.5 131.04,24.6 131.04,25.28 131.94,26.17 131.94,34.17 132.52,34.76 v4(132.52,35.29)
  BOTTOM w0.089: UC1.AB49 132.52,35.28 v4(132.52,35.29)
DDR_C_D2_1: length 15.5
  TOP w0.107: UD3.E9 131.25,22.43 131.24,22.43 131.24,22.43 v3(131.24,22.43)
  IN3 w0.094: v3(131.24,22.43) 130.95,22.72 130.95,22.89 130.27,23.57 130.27,23.94 130.64,24.31 130.64,25.23 131.69,26.28 131.69,34.26 132.26,34.84 132.26,35.4 132.8,35.93 v4(132.82,35.93)
DDR_C_D2_2: length 14.7
  IN3 w0.094: v3(133.23,21.42) 132.63,22.03 132.63,24.79 133.39,25.55 133.39,34.05 133.99,34.65 133.99,35.19 v4(134.08,35.28)
DDR_C_D2_3: length 13.5
  IN1 w0.094: v2(133.23,24.02) v3(133.59,24.38)
  IN3 w0.094: v4(134.08,36.59) 134.52,36.15 134.52,35.11 134.36,34.95 134.36,34.44 133.88,33.96 133.88,28.38 134.14,28.12 134.14,24.94 v3(133.59,24.38)
DDR_C_D2_4: length 14.7
  IN3 w0.094: v3(133.23,22.07) 132.9,22.4 132.9,24.71 133.63,25.44 133.63,33.97 134.18,34.52 134.18,35.02 134.33,35.18 134.33,35.69 v4(134.09,35.93)
DDR_C_D2_5: length 17.3
  IN3 w0.094: v3(131.63,21.42) 131.06,21.42 130.73,21.75 130.73,22.84 130.06,23.51 130.06,23.99 130.39,24.32 130.39,25.33 131.44,26.38 131.44,34.28 132.08,34.92 132.08,35.47 132.57,35.97 132.57,36.05 132.82,36.3 v4(132.82,36.59)
DDR_C_D2_6: length 14.3
  IN1 w0.094: v3(131.28,24.28) 131.54,24.02 v2(131.63,24.02)
  IN3 w0.094: v4(132.82,37.24) 133.11,36.94 133.11,35.81 132.81,35.5 132.81,34.71 132.18,34.09 132.18,26.07 131.28,25.17 v3(131.28,24.28)
DDR_C_D2_7: length 14.9
  IN3 w0.094: v4(134.08,37.24) 134.66,36.66 134.66,36.27 134.7,36.23 134.7,35.03 134.54,34.87 134.54,34.36 134.13,33.95 134.13,28.48 134.39,28.22 134.39,24.53 v3(133.23,23.37)
DDR_C_D3_0: length 25.6
  IN1 w0.094: v2(126.03,21.42) 125.66,21.05 124.98,21.05 124.47,21.56 124.47,26.32 129.94,31.79 129.94,34.42 130.89,35.37 130.89,36.05 131.31,36.47 131.31,37.43 132.5,38.62 132.5,40.56 v3(133.06,41.11)
  IN3 w0.094: v4(133.51,40.91) 133.26,40.91 v3(133.06,41.11)
DDR_C_D3_1: length 23.4
  IN1 w0.094: v2(126.03,22.07) 125.71,22.4 125.24,22.4 124.72,22.91 124.72,26.21 130.34,31.83 130.34,34.46 131.08,35.2 131.08,35.96 131.57,36.45 131.57,37.42 132.69,38.55 132.69,40.24 v3(133.03,40.58)
  IN3 w0.094: v4(133.51,40.26) 133.43,40.25 v3(133.03,40.58)
DDR_C_D3_2: length 23.1
  IN1 w0.094: v3(133.98,40.63) 134.33,40.28 134.33,38.54 134.68,38.19 134.68,37.42 133.57,36.31 133.57,30.56 129.39,26.38 129.39,22.59 129.15,22.34 127.9,22.34 v2(127.63,22.07)
  IN3 w0.094: v3(133.98,40.63) v4(134.43,40.26)
DDR_C_D3_3: length 23.3
  IN1 w0.094: v2(127.63,24.02) 127.45,24.21 127.45,25.23 127.77,25.56 127.77,25.72 127.58,25.91 127.58,26.07 127.69,26.18 127.84,26.18 128.04,25.98 128.19,25.98 128.3,26.09 128.3,26.25 128.11,26.44 128.11,26.6 128.22,26.71 128.37,26.71 128.57,26.51 128.73,26.51 128.84,26.62 128.84,26.78 128.64,26.98 128.64,27.13 128.75,27.24 128.91,27.24 129.1,27.04 129.26,27.04 129.37,27.16 129.37,27.31 129.17,27.51 129.17,27.66 129.28,27.77 129.44,27.77 129.63,27.58 129.79,27.58 129.9,27.69 129.9,27.84 129.7,28.04 129.7,28.19 129.81,28.3 129.97,28.3 130.17,28.11 130.32,28.11 130.43,28.22 130.43,28.37 130.24,28.57 130.24,28.73 130.35,28.84 130.5,28.84 130.7,28.64 130.85,28.64 130.96,28.75 130.96,28.91 130.77,29.1 130.77,29.26 130.88,29.37 131.03,29.37 131.23,29.17 131.39,29.17 131.5,29.28 131.5,29.44 131.3,29.63 131.3,29.79 131.41,29.9 131.57,29.9 131.76,29.7 131.92,29.7 132.6,30.39 132.6,36 133.8,37.19 133.8,38.02 v3(133.95,38.17)
  IN3 w0.094: v3(133.95,38.17) 134.09,38.31 v4(134.43,38.31)
DDR_C_D3_4: length 23.7
  IN1 w0.094: v2(127.63,21.42) 128.05,21.42 128.14,21.52 128.14,21.52 128.34,21.72 128.34,21.72 128.44,21.81 129.18,21.81 129.64,22.28 129.64,26.28 133.82,30.45 133.82,36.21 134.89,37.28 134.89,38.25 134.52,38.62 134.52,40.27 v3(134.89,40.63)
  IN3 w0.094: v3(134.89,40.63) v4(134.43,40.91)
DDR_C_D3_5: length 20.8
  IN1 w0.094: v3(133.06,37.92) 133.04,37.9 133.04,37.35 132.85,37.15 131.46,35.76 131.46,34.86 131.39,34.79 131.39,31.68 130.83,31.13 130.67,31.13 130.61,31.19 130.45,31.19 130.34,31.08 130.34,30.93 130.41,30.86 130.41,30.7 130.3,30.59 130.14,30.59 130.08,30.66 129.92,30.66 129.81,30.55 129.81,30.39 129.88,30.33 129.88,30.17 129.77,30.06 129.61,30.06 129.54,30.13 129.39,30.13 129.28,30.02 129.28,29.86 129.34,29.8 129.34,29.64 129.23,29.53 129.08,29.53 129.01,29.6 128.86,29.6 128.75,29.49 128.75,29.33 128.81,29.26 128.81,29.11 128.7,29 128.55,29 128.48,29.06 128.33,29.06 128.21,28.95 128.21,28.8 128.28,28.73 128.28,28.58 128.17,28.47 128.02,28.47 127.95,28.53 127.79,28.53 127.68,28.42 127.68,28.27 127.75,28.2 127.75,28.04 127.64,27.93 127.48,27.93 127.42,28 127.26,28 127.15,27.89 127.15,27.73 127.22,27.67 127.22,27.51 127.11,27.4 126.95,27.4 126.89,27.47 126.73,27.47 126.62,27.36 126.62,27.2 126.69,27.14 126.69,26.98 126.58,26.87 126.42,26.87 126.35,26.94 126.2,26.94 126.09,26.83 126.09,26.67 126.15,26.6 126.15,26.45 125.96,26.26 125.96,24.09 v2(126.03,24.02)
  IN3 w0.094: v3(133.06,37.92) v4(133.51,38.31)

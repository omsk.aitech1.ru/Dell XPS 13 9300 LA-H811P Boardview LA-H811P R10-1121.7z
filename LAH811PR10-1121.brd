# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO0_R: length 4.9
  BOTTOM w0.069: UC1.CN45 157.84,37.11 158.37,36.58 158.63,36.58 158.74,36.46 158.74,35.12 158.92,34.94 158.92,33.85 159.31,33.45 RC336.1
ESPI_IO1: length 66.1
  TOP w0.069: v2(160.97,6.6) 160.97,5.9 v1(160.95,5.88) 160.44,5.37 157.85,5.37 157.36,4.88 153.02,4.88 152.51,5.39 JDEBUG2.4
  IN1 w0.061: v2(160.97,6.6) 161.23,6.34 161.53,6.34 161.76,6.57 168.55,6.57 169.98,7.99 171.06,7.99 172.12,9.06 172.98,9.06 175.65,11.72 176.54,11.72 178.93,14.12 v3(178.93,14.17) 179.12,14.36 179.12,14.58 v2(179.13,14.59)
  IN3 w0.061: v3(178.93,14.17) 178.88,14.22 177.85,14.22 177.04,15.03 175.29,15.03 173.25,17.07 173.25,18.16 172.25,19.16 171.67,19.16 170.79,20.05 170.79,24.66 169.09,26.36 168.29,26.36 167.88,26.77 v4(167.88,27.02)
  BOTTOM w0.069: v4(167.88,27.02) 167.83,27.07 164.83,27.07 163.89,28.01 163.89,29.81 163.67,30.04 163.67,30.57 163.36,30.88 160.88,30.88 160.15,31.61 158.56,31.61 157.64,32.53 RC367.2
ESPI_IO1_R: length 3.3
  BOTTOM w0.069: RC367.1 157.64,33.64 158,34 158,34.69 157.5,35.2 157.5,35.59 UC1.CN48
ESPI_IO2: length 73.8
  TOP w0.069: UE1.G6 180.73,17.47 181.09,17.11 v3(181.09,16.73) ; v2(160.21,6.44) 160.21,5.83 159.94,5.56 157.77,5.56 157.28,5.07 153.49,5.07 153.01,5.55 JDEBUG2.5
  IN1 w0.061: v3(181.09,16.73) 180.82,17.01 180.3,17.01 179.87,16.58 179.63,16.58 178.38,15.33 178.04,15.33 177.5,14.79 177.5,13.75 176.23,12.47 175.33,12.47 172.67,9.81 171.81,9.81 170.74,8.74 169.66,8.74 168.24,7.32 160.36,7.32 160,6.96 160,6.65 v2(160.21,6.44)
  IN3 w0.061: v3(181.09,16.73) 180.82,16.46 180.82,14.81 180.58,14.57 179.54,14.57 178.88,15.23 175.35,15.23 173.44,17.14 173.44,18.68 171.62,20.5 171.3,20.5 170.97,20.82 170.97,24.74 169.17,26.54 168.49,26.54 168.25,26.78 168.25,27.15 v4(168.01,27.4)
  BOTTOM w0.069: v4(168.01,27.4) 167.96,27.35 164.83,27.35 164.11,28.07 164.11,30.1 v1(163.97,30.24) 163.97,30.55 163.44,31.08 160.96,31.08 160.23,31.81 158.65,31.81 158.2,32.26 RC368.2
ESPI_IO2_R: length 2.3
  BOTTOM w0.069: RC368.1 158.2,33.64 158.23,33.67 158.23,34.9 UC1.CN49
ESPI_IO3: length 65.5
  TOP w0.069: JDEBUG2.6 153.51,5.61 153.85,5.27 157.2,5.27 157.69,5.76 159.53,5.76 v1(159.66,5.89) 159.86,6.1 v2(159.86,6.37)
  IN1 w0.061: v2(159.86,6.37) 160.08,6.15 161.61,6.15 161.83,6.38 168.63,6.38 170.05,7.8 171.13,7.8 172.2,8.87 173.06,8.87 175.72,11.53 176.62,11.53 178.79,13.71 179.26,13.71 179.93,14.38 v2(179.93,14.59) v3(179.93,14.92)
  IN3 w0.061: v4(168.72,27.37) 169.57,27.37 170.14,26.8 170.14,25.83 171.16,24.82 171.16,20.9 171.38,20.69 171.7,20.69 173.63,18.76 173.63,17.22 175.41,15.44 179.42,15.44 v3(179.93,14.92)
  BOTTOM w0.069: RC369.2 158.76,32.08 158.83,32 160.31,32 161.04,31.27 163.53,31.27 164.31,30.49 164.31,28.15 164.8,27.66 168.43,27.66 v4(168.72,27.37)
ESPI_IO3_R: length 3.8
  BOTTOM w0.069: UC1.CN47 157.84,36.37 158.23,35.98 158.23,35.4 158.65,34.98 158.65,33.23 RC369.1
ESPI_RESET#: length 68.3
  TOP w0.069: RE428.1 156.3,7.18 156.57,7.45 v1(159.72,7.45) 160.03,7.45 160.6,6.89 v2(160.6,6.69)
  IN1 w0.061: v2(180.73,15.39) 180.44,15.68 v3(180.44,15.71) 180.08,16.07 179.66,16.07 178.54,14.95 178.19,14.95 177.87,14.63 177.87,13.59 176.38,12.1 175.49,12.1 172.82,9.43 171.97,9.43 170.9,8.36 169.82,8.36 168.4,6.94 160.86,6.94 160.61,6.69 v2(160.6,6.69)
  IN3 w0.061: v3(180.44,15.71) 180.06,16.1 179.8,16.1 179.52,15.82 176.35,15.82 174,18.17 174,18.92 172.8,20.12 172.8,21.46 172.56,21.7 171.85,21.7 171.54,22.01 171.54,25.48 170.67,26.35 170.67,26.81 168.53,28.95 164.76,28.95 164.43,29.28 164.43,30.67 163.17,31.93 162.91,31.93 162.17,32.67 160.58,32.67 v4(159.65,33.6)
  BOTTOM w0.069: RC711.1 159.87,33.38 v4(159.65,33.6) 159.6,33.65 159.6,35.17 159.4,35.37 159.4,36.69 159.18,36.91 UC1.CR46
FB_0.6V: length 3.3
  TOP w0.254: PR803.2 PC812.2 PR805.1 200.83,45.86 v5(201.33,45.86)
  BOTTOM w0.254: PU800.10 201.64,46.17 v5(201.33,45.86)
FB_1.1V_MEM: length 4.5
  BOTTOM w0.069: v1(103.17,11.53) 103.26,11.63 103.26,12.31 PR703.2
  BOTTOM w0.254: PR703.2 102.25,12.49 PC702.2 102.12,12.51 101.36,12.51 PR704.1 101.28,12.46 100.87,12.88 100.87,12.96 100.68,13.15 PU700.13
FB_1.8V: length 3.5
  BOTTOM w0.203: PU500.10 198.98,62.93 PR502.2 198.38,64.66 PR504.1 198.8,65.23 PR501.2
FB_5V: length 4.2
  IN3 w0.203: v4(27.72,18.97) 27.27,18.51 27.27,17.65 v4(27.65,17.27)
  BOTTOM w0.203: PU400.13 26.73,17.18 PR407.2 27.65,17.27 v4(27.65,17.27)
FB_5VB: length 4.5
  IN1 w0.508: v2(273.7,18.69) 273.7,19.27 v3(274.26,19.83)
  IN3 w0.508: v4(274.31,20.57) 274.31,19.88 v3(274.26,19.83)
  BOTTOM w0.254: v4(274.31,20.57) 274.31,20.57 PR416.2 274.25,19.72 PU401.13
FPR_DET#: length 113.4
  TOP w0.069: UE1.D9 183.13,19.85 183.61,19.37 183.61,19.25 183.78,19.07 187.24,19.07 188.33,20.16 v1(189.42,20.16) 189.55,20.16 189.7,20.01 v3(190.34,20.01)
  IN2 w0.051: v3(190.34,20.01) 190.44,19.91 190.44,19.25 190.67,19.02 190.67,18.71 190.87,18.51 191.76,18.51 191.83,18.59 195.85,18.59 202.4,12.03 210.75,12.03 211.47,11.31 216.82,11.31 217.3,10.83 220.62,10.83 221.41,11.63 223.2,11.63 223.45,11.88 232.8,11.88 234.73,13.8 239.21,13.8 240.13,14.72 243.4,14.72 248.43,19.75 248.43,22.7 249.9,24.17 249.9,26.1 249.92,26.13 250.77,26.13 252.5,27.86 252.5,28.48 252.87,28.85 256.05,28.85 256.46,29.27 v3(257.81,29.27)
  IN3 w0.061: v4(258.73,30.06) 258.73,30.04 257.96,29.27 v3(257.81,29.27)
  BOTTOM w0.069: R800.2 272.68,41.88 265.95,35.14 261.44,35.14 260.39,34.08 260.39,31.71 v4(258.73,30.06)
FPR_DET#_R: length 18.4
  BOTTOM w0.069: JFP1.1 257.5,36.94 257.9,37.33 257.9,38.2 258.33,38.63 259.4,38.63 259.62,38.42 267.7,38.42 v1(269.74,40.45) 271.29,42.01 D16.3 271.43,42.51 R800.1
FPR_SCAN#_R: length 149.7
  TOP w0.069: QF3.3 187.79,3.22 R629.1 188.43,3.19 188.51,3.19 189.42,2.28 193.03,2.28 v1(193.13,2.38) 193.23,2.28 197.72,2.28 199.67,4.24 209.89,4.24 211.11,3.02 212.31,3.02 213.04,3.74 230.21,3.74 231.23,2.72 231.23,1.92 v2(231.46,1.69)
  IN1 w0.061: v2(231.46,1.69) 233.9,1.69 234.33,1.26 253.33,1.26 254.47,2.41 268.03,2.41 272.15,6.52 272.15,20.11 269.97,22.29 v3(269.97,23.31)
  IN3 w0.061: v4(272.99,40.63) 272.99,31.17 272.73,30.91 272.35,30.91 269.97,28.53 v3(269.97,23.31)
  BOTTOM w0.069: v4(272.99,40.63) 273.24,40.89 273.24,43.17 272.91,43.5 272.45,43.5 R801.2 271.51,43.15 D16.2 271.07,43.37 270.57,42.87 270.57,41.7 268.87,40 268.87,39.92 267.55,38.6 259.68,38.6 259.47,38.8 258.26,38.8 257.67,38.22 257.67,37.66 257.45,37.44 JFP1.2
FPR_SCAN_INT#: length 133.6
  TOP w0.069: v2(182.36,7.92) 182.36,7.9 182.69,7.57 182.69,6.8 183.17,6.32 183.5,6.32 184.19,5.63 184.29,5.63 184.49,5.43 184.49,5.34 185.33,4.5 185.33,4.23 185.53,4.03 186.12,4.03 186.98,3.17 QF3.1 186.98,2.05 187.29,1.74 v1(188.2,1.74) ; UE1.L8 182.69,14.23 v3(182.69,13.4)
  IN1 w0.061: v3(182.69,13.4) 182.69,11.73 182.36,11.4 v2(182.36,7.92)
  IN3 w0.061: v3(182.69,13.4) 183.4,13.4 186,10.8 187.34,10.8 188.34,9.8 188.34,9.23 190.37,7.21 190.85,7.21 191.32,6.74 195.43,6.74 195.82,6.34 196.4,6.34 196.8,6.74 197.32,6.74 197.9,7.32 198.79,7.32 199.14,6.96 203.55,6.96 203.77,7.18 204.43,7.18 204.68,6.94 206.69,6.94 206.88,7.13 223.27,7.13 223.86,6.54 224.94,6.54 225.91,7.52 240.92,7.52 243.28,9.87 245.19,9.87 246.12,10.81 246.12,11.24 246.66,11.77 246.66,13.97 246.21,14.42 246.21,16.85 246.74,17.38 247.99,17.38 250.92,20.3 250.92,21.02 251.99,22.1 252.77,22.1 253.35,22.68 253.92,22.68 254.39,23.16 254.39,23.31 255.49,24.41 258.44,24.41 268,33.97 v4(268,36.29)
  BOTTOM w0.069: R801.1 273.07,42.76 273.07,41.17 268.77,36.87 268.58,36.87 v4(268,36.29)
GPD7: length 6.6
  BOTTOM w0.069: TP101.1 162.32,31.97 162.14,32.15 161.53,32.15 161.41,32.28 161.41,33.52 161.89,34 161.89,36.37 162.19,36.67 162.76,36.67 UC1.DC47
GPIO011: length 7
  TOP w0.069: TP84.1 182.07,9.26 181.62,9.71 181.62,10.95 181.04,11.53 181.04,14.9 UE1.K7
GPIO100: length 2.4
  TOP w0.069: RE487.1 174.79,13.2 175.39,13.8 175.44,13.8 175.53,13.89 176.63,13.89 UE1.M1
GPP_A23: length 5.6
  BOTTOM w0.069: RH715.2 161.08,33.7 160.95,33.83 160.95,34.74 161.13,34.92 161.13,35.37 161.2,35.45 161.2,35.78 161.13,35.86 161.13,36.03 161.2,36.11 161.2,36.42 161.13,36.49 161.13,36.52 161.56,36.95 162.56,36.95 UC1.DC45
GPP_B23: length 4.1
  TOP w0.069: v2(156.99,35.63) 156.99,34.98 v1(156.87,34.87) 156.87,33.65 RH647.1
  IN1 w0.061: v3(156.99,36.06) v2(156.99,35.63)
  IN3 w0.061: v3(156.99,36.06) 156.86,35.93 v4(156.6,35.93)
GPP_C2: length 1.3
  TOP w0.069: v2(167.17,47.21) 167.29,47.09 RH692.1
  IN1 w0.061: v3(166.99,47.51) 167.17,47.32 v2(167.17,47.21)
  IN3 w0.061: v4(166.73,47.25) v3(166.99,47.51)
GPP_C5: length 3.4
  TOP w0.069: v2(170.07,49.01) 170.07,49.02 RH98.1 171.02,49.02 RH666.1
  IN1 w0.061: v2(170.07,49.01) 169.59,48.54 v3(168.37,48.54)
  IN3 w0.061: v4(168.03,48.16) 168.03,48.21 v3(168.37,48.54)
GPP_E6: length 7.6
  BOTTOM w0.069: UC1.DT12 169.46,52.93 172.4,52.93 172.51,53.03 v1(172.58,53.03) 172.61,53.03 173.17,52.47 174.56,52.47 174.87,52.77 RH661.1 RH660.1
GPP_F4: length 13.2
  IN3 w0.061: v4(165.43,45.42) 165.7,45.69 167.23,45.69 167.45,45.91 168.43,45.91 168.54,45.79 170.14,45.79 170.88,46.53 174.27,46.53 174.66,46.14 177.84,46.14 v4(177.91,46.2)
GPP_F5: length 12.7
  IN3 w0.061: v4(177.91,45.62) 177.91,45.77 177.7,45.98 174.6,45.98 174.21,46.37 171.05,46.37 170.28,45.6 168.37,45.6 168.22,45.74 167.51,45.74 167.19,45.42 v4(166.08,45.42)
GPP_F19: length 3.4
  TOP w0.069: v2(167.15,48) 167.43,47.72 RH749.1
  IN1 w0.061: v3(167.5,47.59) 167.15,47.95 v2(167.15,48)
  IN3 w0.061: v4(167.04,47.95) 167.15,47.95 v3(167.5,47.59)
  BOTTOM w0.069: UC1.DL27 166.73,46.77 167.07,47.11 167.07,47.92 v4(167.04,47.95)
GPP_H2: length 1.4
  TOP w0.069: v2(165.65,40.97) RH618.1
  IN1 w0.061: v4(165.69,40.59) 165.69,40.94 v2(165.65,40.97)
  BOTTOM w0.069: UC1.DJ38 v4(165.69,40.59)
GPP_H8: length 3.8
  BOTTOM w0.069: UC1.DT40 169.48,40.1 169.53,40.05 169.53,40 169.69,39.84 169.74,39.84 169.76,39.82 170.94,39.82 171.06,39.69 RH714.1
GPP_H9: length 3.1
  BOTTOM w0.069: UC1.DW40 170.59,39.99 173.09,39.99 RH714.2
GPP_S4: length 1.1
  IN1 w0.061: v2(163.87,41.08) 163.87,40.92 163.61,40.66 163.58,40.66 v4(163.56,40.64)
  BOTTOM w0.069: UC1.DF38 v4(163.56,40.64)
GPP_S5: length 2.7
  TOP w0.069: v3(164.3,40.63) 164.46,40.79 RH716.2
  IN3 w0.061: v4(164.63,40.48) 164.45,40.48 v3(164.3,40.63)
  BOTTOM w0.069: UC1.DD39 163.55,40.26 163.89,40.61 164.5,40.61 v4(164.63,40.48)
H_CATERR#: length 4.4
  BOTTOM w0.069: RH80.1 125.24,60.92 125.95,60.22 125.95,59.83 126.2,59.58 126.2,58.69 126.63,58.26 126.63,57.88 126.34,57.59 UC1.J4
H_PROCHOT#: length 187.5
  TOP w0.069: PR702.1 101.89,14.04 100.27,15.66 v1(100.27,19.04) 100.27,27.73 v3(99.18,28.82) ; PR1109.2 121.25,56.46 RC614.1 ; PR1109.2 RH96.1 ; PR1109.2 121.25,56.05 120.77,55.57 v2(120.77,55.04)
  IN1 w0.061: v2(189.52,16.68) 189.41,16.78 v3(189.15,16.78) ; v4(108.57,55.43) 109.41,54.59 111.9,54.59 111.93,54.56 113.85,54.56 114.3,55.01 120.74,55.01 v2(120.77,55.04) 121.22,55.49 129.43,55.49 129.72,55.78 130.58,55.78 130.64,55.71 133.31,55.71 133.52,55.92 133.92,55.92 134.66,55.19 135.24,55.19 136.09,54.34 142.22,54.34 142.36,54.48 160.82,54.48 161.28,54.02 161.28,53.51 164.61,50.18 164.61,49.52 164.91,49.22 166.21,49.22 166.21,49.2 166.57,48.84 166.57,48.42 166.64,48.35 166.64,47.31 167.02,46.93 167.93,46.93 168.24,47.24 169.15,47.24 169.48,46.91 170.6,46.91 171.71,45.8 172.7,45.8 173.05,45.46 173.5,45.46 174.78,44.18 176.79,44.18 176.9,44.29 178.56,44.29 179.7,43.14 180.64,43.14 181.57,42.21 181.83,42.21 v4(181.85,42.24)
  IN2 w0.051: v4(99.53,55.39) 98.18,54.04 97.83,54.04 91.73,47.94 91.73,33.29 95.84,29.18 98.82,29.18 v3(99.18,28.82) ; v3(192.55,16.4) 189.53,16.4 v3(189.15,16.78)
  IN3 w0.061: v3(192.55,16.4) 192.42,16.53 192.42,20.39 192.7,20.67 192.7,21.91 194.47,23.68 194.47,25.2 196.32,27.05 196.32,31.72 195.56,32.48 195.56,34.56 193.41,36.72 193.41,37.28 191.23,39.46 190.39,39.46 189.03,40.83 187.19,40.83 185.97,42.04 182.54,42.04 182.35,42.24 v4(181.85,42.24)
  BOTTOM w0.069: v4(108.57,55.43) 108.54,55.39 v4(99.53,55.39) PR1123.2
H_PROCHOT#_R: length 2.3
  TOP w0.069: RC614.2 CC739.1 122.64,57.09 122.85,56.89 123,56.89 v4(123.04,56.85)
  BOTTOM w0.069: UC1.C3 123.37,57.51 123.08,57.22 123.08,56.89 v4(123.04,56.85)
H_THERMTRIP#: length 141.3
  IN1 w0.061: v4(122.62,58.92) 122.26,58.56 121.84,58.56 119.41,56.13 113.38,56.13 v3(112.92,55.67)
  IN2 w0.051: v4(162.4,27.83) 161.25,27.83 160.71,28.36 115.2,28.36 113.8,26.97 110.56,26.97 110.18,26.59 107.32,26.59 106.89,26.15 105.91,26.15 105.08,26.98 96.78,26.98 90.39,33.38 90.39,48.62 97.57,55.8 108.73,55.8 109.84,54.68 111.93,54.68 v3(112.92,55.67)
  BOTTOM w0.069: UC1.E3 124.45,58.33 124.07,58.72 123.61,58.72 123.58,58.69 123.03,58.69 122.82,58.89 122.65,58.89 v4(122.62,58.92) 121.4,60.14 CC738.1 118.96,59.63 118.96,59.63 RH95.1 ; v4(162.4,27.83) 161.91,27.83 161.78,27.97 161.78,28.91 162.02,29.15 v1(162.02,29.3) 161.71,29.61 160.82,29.61 159.77,30.66 QE16.3
HDA_BIT_CLK: length 3.9
  TOP w0.069: v2(160.9,35.73) 160.62,35.45 v1(160.62,35.43) 160.62,34.84 160.55,34.78 160.13,34.78 RH113.2 RH688.2
  IN1 w0.061: v3(160.85,36.59) 160.85,35.78 v2(160.9,35.73)
  IN3 w0.061: v4(160.98,36.91) 160.98,36.72 v3(160.85,36.59)
HDA_BIT_CLK_R: length 163.1
  TOP w0.069: UA1.14 263.91,59.64 264.68,58.87 CA37.1 264.89,58.92 264.89,59.05 264.76,59.17 264.76,59.53 v2(264.55,59.73) ; v1(158.81,32.43) 159.51,33.12 CH40.1 v2(159.75,33.81)
  IN1 w0.061: v3(248.88,24.48) 248.76,24.6 248.76,25.42 251.46,28.12 254.16,28.12 254.94,28.89 256.04,28.89 258.01,30.86 258.01,33.76 255.59,36.18 255.59,37.92 256.38,38.7 256.38,44.67 257.98,46.27 257.98,52.52 256.98,53.52 256.98,56.26 259.6,58.88 259.6,59.26 260.27,59.94 263.87,59.94 264.08,59.73 v2(264.55,59.73) ; v2(159.75,33.81) v3(160.01,34.07)
  IN2 w0.051: v3(160.01,34.07) 160.31,33.77 160.82,33.77 161,33.95 161,34.16 161.1,34.26 163.41,34.26 164.02,33.65 171.03,33.65 172.22,32.45 175.97,32.45 176.81,31.62 180.58,31.62 181.19,31.01 185.65,31.01 186.72,29.94 187.25,29.94 188.47,28.72 189.42,28.72 189.6,28.9 190.7,28.9 193.34,26.26 195.96,26.26 196.99,25.22 196.99,20.7 202.62,15.07 205.5,15.07 206.04,15.61 210.68,15.61 211.78,14.51 223.98,14.51 225.77,12.72 232.78,12.72 234.48,14.41 238.96,14.41 239.88,15.33 242.23,15.33 242.59,15.7 243.73,15.7 247.97,19.94 247.97,22.89 248.88,23.8 v3(248.88,24.48)
HDA_SDIN0: length 165.4
  TOP w0.069: v3(159.96,37.1) 160.15,37.3 CC727.1 ; v2(265.34,59.61) 265.35,59.61 265.72,59.24 265.72,58.64 265.67,58.59 265.67,58.59 265.39,58.31 RA17.2
  IN1 w0.061: v2(265.34,59.61) 265.34,59.66 264.61,60.39 264.21,60.39 264.1,60.51 260.09,60.51 259.07,59.48 259.07,59.1 256.45,56.48 256.45,53.3 257.45,52.3 257.45,46.49 255.85,44.89 255.85,38.92 255.07,38.14 255.07,35.96 257.48,33.55 257.48,31.08 255.82,29.42 252.01,29.42 248.09,25.5 v3(248.09,23.67)
  IN2 w0.051: v3(159.96,37.1) 159.45,37.1 159.37,37.03 159.37,34.99 159.66,34.71 160.64,34.71 160.64,34.71 163.6,34.71 164.21,34.1 171.22,34.1 172.41,32.91 176.16,32.91 177,32.07 180.77,32.07 181.38,31.47 185.84,31.47 186.91,30.4 187.44,30.4 188.66,29.18 189.23,29.18 189.41,29.36 190.89,29.36 193.53,26.71 196.15,26.71 197.45,25.41 197.45,20.89 202.81,15.53 205.31,15.53 205.85,16.07 210.87,16.07 211.97,14.97 224.17,14.97 225.96,13.17 232.5,13.17 234.2,14.87 238.77,14.87 239.69,15.79 242.04,15.79 242.4,16.15 243.54,16.15 247.51,20.13 247.51,22.37 247.33,22.55 247.33,23.37 247.63,23.67 v3(248.09,23.67)
  IN3 w0.061: v4(160.34,37.24) 160.09,37.24 v3(159.96,37.1)
HDA_SDIN0_R: length 2.8
  TOP w0.069: RA17.1 265.39,59.02 264.99,59.43 v1(264.99,59.86) 264.94,59.86 264.36,60.44 UA1.16
HDA_SDOUT: length 4.1
  TOP w0.069: v2(161.25,35.58) 161.81,35.01 v1(161.81,34.97) 161.23,34.39 RH217.2 RH112.2
  IN1 w0.061: v2(161.25,35.58) 161.25,36.07 161.18,36.14 v3(161.18,36.18)
  IN3 w0.061: v4(160.77,35.96) 160.97,35.96 v3(161.18,36.18)
  BOTTOM w0.069: UC1.CY47 160.98,36.16 v4(160.77,35.96)
HDA_SDOUT_R: length 159.9
  TOP w0.069: UA1.17 264.26,60.84 v2(264.3,60.8) ; CH50.1 v2(160.36,33.81)
  IN1 w0.061: v2(160.36,33.81) v3(160.66,34.11) ; v3(247.66,23.23) 247.66,25.44 251.9,29.68 255.68,29.68 257.21,31.22 257.21,33.4 254.8,35.82 254.8,38.24 255.56,39 255.56,45.01 257.16,46.61 257.16,52.18 256.16,53.18 256.16,56.6 258.24,58.68 258.24,59.59 259.45,60.8 v2(264.3,60.8)
  IN2 w0.051: v3(247.66,23.23) 247.74,23.15 247.74,20.04 243.63,15.93 242.5,15.93 242.13,15.56 239.79,15.56 238.86,14.64 234.38,14.64 232.69,12.95 225.86,12.95 224.07,14.74 211.88,14.74 210.77,15.84 205.94,15.84 205.4,15.3 202.72,15.3 197.22,20.8 197.22,25.32 196.05,26.48 193.44,26.48 190.8,29.13 189.51,29.13 189.33,28.95 188.56,28.95 187.35,30.17 186.82,30.17 185.74,31.24 181.28,31.24 180.68,31.84 176.9,31.84 176.06,32.68 172.32,32.68 171.13,33.88 164.12,33.88 163.51,34.49 160.8,34.49 160.66,34.35 v3(160.66,34.11)
HDA_SYNC: length 2.3
  TOP w0.069: RH111.2 160.21,35.23 v2(160.21,35.04)
  IN1 w0.061: v2(160.21,35.04) v3(160.59,35.04)
  IN3 w0.061: v3(160.59,35.04) 160.36,34.82 v4(160.36,34.64)
  BOTTOM w0.069: UC1.CV49 160.34,34.66 v4(160.36,34.64)
HDA_SYNC_R: length 159.6
  TOP w0.069: UA1.15 264.27,60.04 v2(264.3,60.01) ; CH51.1 v2(159.78,35.08)
  IN1 w0.061: v2(264.3,60.01) 264.22,60.01 263.99,60.24 260.2,60.24 259.33,59.37 259.33,58.99 256.71,56.37 256.71,53.41 257.71,52.41 257.71,46.38 256.11,44.78 256.11,38.81 255.33,38.03 255.33,36.07 257.74,33.66 257.74,30.97 255.93,29.16 252.12,29.16 248.38,25.41 248.38,24.17 v3(248.48,24.07) ; v3(159.95,35.45) 159.95,35.24 v2(159.78,35.08)
  IN2 w0.051: v3(159.95,35.45) 159.97,35.43 160.8,35.43 161.28,34.94 163.7,34.94 164.31,34.33 175.06,34.33 177.09,32.3 180.87,32.3 181.47,31.7 185.93,31.7 186.83,30.8 188.35,30.8 189.1,30.05 190.52,30.05 193.63,26.94 196.24,26.94 197.68,25.51 197.68,20.99 202.91,15.76 205.21,15.76 205.75,16.3 210.96,16.3 212.07,15.19 224.26,15.19 226.05,13.4 232.41,13.4 234.1,15.1 238.67,15.1 239.6,16.02 241.95,16.02 242.31,16.38 243.44,16.38 243.88,16.82 247.28,20.22 247.28,22.28 247.1,22.46 247.1,23.47 247.88,24.25 248.3,24.25 v3(248.48,24.07)
HOST_DEBUG_TX: length 73.7
  IN1 w0.061: v2(184.73,17.79) v3(184.73,17.44)
  IN3 w0.061: v4(243.63,12.71) 243.32,13.01 240.7,13.01 240.48,12.78 240.48,12.09 238.76,10.38 225.71,10.38 224.67,9.33 216.46,9.33 216.22,9.57 214.45,9.57 213.74,8.87 207.52,8.87 206.66,9.73 197.19,9.73 196.79,9.32 v3(196.79,9.09) 196.72,9.02 191.79,9.02 190.52,10.29 190.52,10.98 188.96,12.54 186.77,12.54 186.23,13.08 186.23,15.23 185,16.47 185,17.17 v3(184.73,17.44)
  BOTTOM w0.069: RE202.2 243.46,11.71 243.27,11.9 243.27,12.34 243.63,12.69 v4(243.63,12.71) 243.63,13.06 243.84,13.27 243.84,14.08 243.4,14.52 242.38,14.52 242.11,14.25 JDEG1.8
HOST_SD_WP#: length 177.7
  IN1 w0.061: v4(12.08,38.8) 12.4,38.8 15.6,35.6 20.03,35.6 21.9,33.73 21.9,32.61 21.64,32.34 21.64,30.16 25.13,26.67 28.75,26.67 31.17,24.25 31.17,22.51 34.39,19.29 38.17,19.29 47.41,10.06 69.61,10.06 70.46,10.91 75.77,10.91 91.73,26.87 105.13,26.87 106.01,27.75 107.61,27.75 v3(108.75,28.9)
  IN2 w0.051: v3(108.75,28.9) 108.95,29.1 111.9,29.1 113.7,30.9 151.23,30.9 154.45,34.12 154.45,36.64 v3(154.75,36.95)
  IN3 w0.061: v3(154.75,36.95) 154.7,36.9 v4(153.86,36.9)
  BOTTOM w0.069: v4(153.86,36.9) 153.86,36.85 153.66,36.64 153.66,36.45 UC1.CE47 153.23,36.02 153.23,35.03 151.99,33.79 150.91,33.79 RC717.2 ; QR1.2 v4(12.08,38.8)
HP_PLUG#: length 10.7
  BOTTOM w0.069: v5(278.83,69.72) 277.46,69.72 277.14,69.4 RA14.2 DA13.1 276.17,69.06 275.96,68.85 271.11,68.85 270.7,68.44 JHP1.3
HPOL_CONN: length 2.5
  IN3 w0.381: v4(263.74,64.24) 264.59,64.24 v4(265.77,63.06)
HPOR_CONN: length 7.8
  IN3 w0.381: v4(269.75,61.8) 269.36,61.8 269.18,61.98 269.14,61.98 265.1,66.02 v4(263.74,66.02)
HPOUT-L: length 5
  IN1 w0.381: v3(262.47,65.85) 262.47,66.24 v2(262.35,66.36) 262.35,66.97 261.33,67.99 v2(260.62,67.99)
  IN3 w0.381: v4(262.35,65.22) 262.47,65.35 v3(262.47,65.85)
  BOTTOM w0.127: v1(261.41,65.24) 262.32,65.24 v4(262.35,65.22)
HPOUT-L_L: length 2.3
  BOTTOM w0.127: v1(264.89,64.31) 264.1,65.09 LA19.1
  BOTTOM w0.381: RA6.2 263.06,65.09 LA19.1
HPOUT-R: length 5.2
  IN1 w0.381: v2(262.65,67.96) 263.04,67.96 263.44,67.57 263.44,66.82 v3(263.32,66.71) v2(262.98,66.36)
  IN3 w0.381: v4(262.98,66.24) v2(262.98,66.36) v3(263.32,66.71)
  BOTTOM w0.127: v4(262.98,66.24) 262.98,65.98 263.34,65.63 v1(264.86,65.63)
HPOUT-R_L: length 1.8
  BOTTOM w0.127: v1(263.74,67.89) LA18.1
  BOTTOM w0.381: LA18.1 263.03,66.87 RA3.2
HRESET_L_PD: length 2.9
  BOTTOM w0.069: UPD1.44 32.4,38.32 32.84,38.76 RPD88.1 33.05,38.39 v1(32.58,37.91)
HRESET_R_PD: length 2.7
  TOP w0.069: UPD2.44 258.17,40.66 257.68,41.15 RPD97.1 257.35,40.37 v1(257.39,40.33)
I2C1_PD_L_CLK: length 14.7
  TOP w0.069: v5(23.74,39.37) 23.84,39.47 24.45,39.47 26.07,37.85 30.9,37.85 31.92,36.82 v1(32.73,36.82) 33.83,36.82 33.89,36.76 JDB1.7
  BOTTOM w0.069: RPD163.1 23.05,39.55 23.57,39.55 v5(23.74,39.37) 23.84,39.47 23.96,39.47 23.99,39.44 23.99,38.59 24.24,38.35 24.58,38.35 UPD1.27
I2C1_PD_L_DAT: length 14.7
  TOP w0.069: JDB1.8 33.89,37.26 33.83,37.2 32.08,37.2 31.05,38.22 26.23,38.22 v1(25.28,39.16) 24.6,39.84 23.91,39.84 v5(23.74,40.01)
  BOTTOM w0.069: UPD1.28 24.39,38.72 24.36,38.74 24.36,39.59 24.12,39.84 23.91,39.84 v5(23.74,40.01) 23.65,39.92 23.01,39.92 RPD164.1
I2C1_PD_L_INT#: length 3.4
  BOTTOM w0.069: v1(23.31,41.4) RPD17.1 24.82,40.92 24.87,40.92 25.41,40.39 UPD1.29
I2C1_PD_R_CLK: length 20.1
  TOP w0.069: JDB2.7 278.49,49.08 278.43,49.14 277,49.14 275.88,48.02 v5(275.86,48.02) ; 266.82,41.08 267.03,41.08 267.36,41.41 RPD165.1 ; 266.82,41.08 266.4,40.66 UPD2.27 ; 266.82,41.08 v5(266.82,41.06)
  IN3 w0.061: v5(266.82,41.06) 267.44,41.06 267.82,40.68 268.44,40.68 268.73,40.39 271.63,40.39 275.78,44.54 275.78,47.95 v5(275.86,48.02)
I2C1_PD_R_DAT: length 21.8
  TOP w0.069: v5(266.82,41.65) 266.23,41.06 UPD2.28 ; v5(266.82,41.65) 266.49,41.98 v1(266.49,42.94) ; v5(266.82,41.65) 267.16,41.99 RPD166.1 ; v5(275.86,48.66) 275.88,48.66 276.74,49.52 278.43,49.52 278.49,49.58 JDB2.8
  IN3 w0.061: v5(275.86,48.66) 275.86,48.63 275.42,48.19 275.42,44.69 271.48,40.75 268.88,40.75 268.59,41.04 267.98,41.04 267.59,41.43 267.03,41.43 v5(266.82,41.65)
I2C1_PD_R_INT#: length 4.2
  TOP w0.069: v1(267.75,43.38) 267.39,43.74 RPD109.1 265.59,43.26 265.48,43.26 265,42.77 UPD2.29
I2C2_PD_L_CLK: length 12.8
  TOP w0.069: JDB1.9 33.89,37.76 33.83,37.82 32.24,37.82 30.85,39.21 v1(30.27,39.21) 26.99,39.21 25.95,40.25 v2(25.95,40.66)
  IN1 w0.061: v3(25.85,41.04) 25.95,40.93 v2(25.95,40.66)
  IN3 w0.061: v4(25.85,41.39) v3(25.85,41.04)
  BOTTOM w0.069: v4(25.85,41.39) 26.08,41.16 26.08,40.99 26.61,40.46 UPD1.32
I2C2_PD_L_DAT: length 12.3
  TOP w0.069: v2(26.38,40.66) 26.33,40.61 26.33,40.4 v1(26.89,39.85) 27.15,39.58 31.01,39.58 32.4,38.2 33.83,38.2 33.89,38.26 JDB1.10
  IN1 w0.061: v3(26.48,41.04) 26.38,40.94 v2(26.38,40.66)
  IN3 w0.061: v4(26.48,41.39) v3(26.48,41.04)
  BOTTOM w0.069: v4(26.48,41.39) 26.28,41.19 26.28,41.07 26.81,40.54 26.81,40.33 27.01,40.14 UPD1.33
I2C2_PD_L_INT#: length 2
  BOTTOM w0.069: RPD112.1 27.12,40.72 27.41,40.43 UPD1.34
I2C2_PD_R_CLK: length 20.8
  TOP w0.069: v2(264.55,43.76) 264.55,43.74 264.28,43.47 264.28,43.23 v1(263.97,42.92) 263.8,42.74 UPD2.32 ; v2(275.93,49.98) 276.1,50.14 278.43,50.14 278.49,50.08 JDB2.9
  IN1 w0.061: v3(275.17,49.85) 275.3,49.98 v2(275.93,49.98) ; v3(264.63,43.38) 264.63,43.68 v2(264.55,43.76)
  IN3 w0.061: v3(275.17,49.85) 274.83,49.85 273.5,48.53 273.5,47.25 273.25,47 273.25,46.79 272.55,46.1 272.35,46.1 271.44,45.19 269.67,45.19 269.01,44.53 268.26,44.53 267.63,43.9 264.88,43.9 264.63,43.65 v3(264.63,43.38)
I2C2_PD_R_DAT: length 21.5
  TOP w0.069: v2(263.92,43.76) 263.75,43.59 263.75,43.56 263.4,43.21 UPD2.33 ; v2(275.93,50.49) 275.96,50.52 278.43,50.52 278.49,50.58 JDB2.10
  IN1 w0.061: v3(264,43.38) 264,43.65 263.92,43.73 v2(263.92,43.76) ; v4(275.17,50.49) v2(275.93,50.49)
  IN3 w0.061: v4(275.17,50.49) 274.94,50.49 273.14,48.68 273.14,47.4 272.88,47.15 272.88,46.94 272.4,46.47 272.2,46.47 271.29,45.56 269.51,45.56 268.85,44.9 268.11,44.9 267.48,44.26 264.73,44.26 264.22,43.76 264.22,43.6 v3(264,43.38)
I2C2_PD_R_INT#: length 2
  TOP w0.069: RPD113.1 263,43.47 UPD2.34
I2C3_PD_L_CLK: length 4.3
  BOTTOM w0.069: v1(21.63,34.05) 22.7,34.05 23,34.36 RPD194.2 23.11,34.52 23.38,34.79 23.38,35.58 23.72,35.92 UPD1.21
I2C3_PD_L_DAT: length 2.4
  BOTTOM w0.069: UPD1.22 23.67,36.32 23,35.65 RPD142.2
I2C3_PD_L_INT#: length 3.6
  BOTTOM w0.069: v1(21.55,35.35) 21.68,35.35 22.16,35.83 22.49,35.83 22.84,36.18 RPD155.2 23.19,36.22 23.69,36.72 UPD1.23
I2C3_PD_R_CLK: length 2.6
  TOP w0.069: UPD2.21 266.7,38.26 267.02,37.94 267.02,37.18 267.34,36.86 RPD199.2
I2C3_PD_R_DAT: length 4.1
  TOP w0.069: UPD2.22 266.67,38.66 267.3,38.03 ; 267.3,38.03 268.5,38.03 v1(268.82,37.71) ; 267.3,38.03 267.3,37.54 RPD146.2
I2C3_PD_R_INT#: length 2
  TOP w0.069: UPD2.23 266.79,39.06 267.28,38.56 RPD131.2
I2C_0_SCL: length 56.4
  TOP w0.069: v3(128.56,62.66) 128.56,63.37 R1015.1
  IN3 w0.061: v3(128.56,62.66) 128.56,62.73 128.94,63.11 129.17,63.11 129.59,62.69 133.81,62.69 133.96,62.54 136.74,62.54 137.08,62.88 141.4,62.88 141.96,62.32 145.67,62.32 146.78,63.43 148.05,63.43 148.5,62.98 148.5,61.79 151.34,58.94 151.34,57.5 150.88,57.04 150.88,55.51 151.52,54.87 153.24,54.87 153.5,54.61 155.39,54.61 155.66,54.33 161.13,54.33 161.75,53.71 164.58,53.71 165.31,52.99 166.59,52.99 167.97,51.61 168.1,51.61 168.55,51.16 169.85,51.16 170.45,50.56 170.45,49.9 170.12,49.57 169.48,49.57 v4(169.25,49.34)
  BOTTOM w0.069: v4(169.25,49.34) 169.25,49.07 169.19,49 UC1.DT23
I2C_0_SCL_R: length 4.2
  TOP w0.069: R1015.2 128.36,64.51 TP122.1 127.5,65.37 v4(127.5,65.58) 127.6,65.68 R239.1
  BOTTOM w0.069: JEDP1.37 128.4,64.67 v4(127.5,65.58)
I2C_0_SDA: length 53.9
  TOP w0.069: R1016.1 129,62.77 129.1,62.67 v3(129.1,62.67)
  IN3 w0.061: v4(168.86,47.74) 169.17,48.05 169.17,48.97 168.87,49.27 168.87,49.85 168.92,49.9 168.92,50.7 168.82,50.79 168.4,50.79 167.95,51.24 167.82,51.24 166.44,52.62 165.15,52.62 164.43,53.34 161.6,53.34 160.97,53.97 155.51,53.97 155.23,54.25 153.25,54.25 153,54.5 151.37,54.5 150.51,55.36 150.51,57.19 150.98,57.66 150.98,58.79 148.13,61.64 148.13,62.78 147.85,63.06 146.93,63.06 145.82,61.95 141.81,61.95 141.25,62.51 137.23,62.51 136.89,62.17 133.81,62.17 133.66,62.32 129.44,62.32 129.1,62.66 v3(129.1,62.67)
  BOTTOM w0.069: UC1.DT24 v4(168.86,47.74)
I2C_0_SDA_R: length 5.5
  TOP w0.069: TP121.1 128.95,66.8 128.95,66.75 128.56,66.36 R238.1 128.23,65.78 v4(128.03,65.58) 128.03,65.5 129,64.53 R1016.2
  BOTTOM w0.069: v4(128.03,65.58) 128.75,64.86 JEDP1.35
I2C_1_SCL: length 67.8
  TOP w0.069: v2(196.7,30.04) 198.87,27.88 198.87,18.79 v1(198.02,17.94) 197.85,17.77 197.85,11.48 194.88,8.51 194.88,7.03 194.1,6.24 194.1,4.63 v4(194.25,4.48)
  IN1 w0.061: v2(196.7,30.04) 196.31,30.44 196.31,31.47 195.06,32.72 195.06,34.32 193.25,36.12 192.12,36.12 190.94,37.3 190.75,37.3 190.16,37.89 190.16,38.42 189.52,39.06 188.66,39.06 187.53,40.19 186.54,40.19 184.18,42.55 183.31,42.55 181.95,43.91 181.68,43.91 181.17,44.43 180.24,44.43 178.44,46.23 174.58,46.23 173.57,47.23 172.13,47.23 171.14,48.22 v3(170.1,48.22)
  IN3 w0.061: v4(169.84,47.96) v3(170.1,48.22)
  BOTTOM w0.069: R6219.1 195.03,2.2 194.25,2.98 v4(194.25,4.48)
I2C_1_SCL_R: length 16.5
  IN3 w0.061: v4(197.83,2.65) 197.83,2.84 198.09,3.1 v4(198.09,3.24)
  BOTTOM w0.069: R6219.2 196.48,2.2 R6215.2 196.86,2.18 197.14,1.9 198.46,1.9 D483.3 198.68,2.13 198.69,2.15 198.4,2.44 197.95,2.44 197.83,2.56 v4(197.83,2.65) ; JTP1.3 205.21,9.45 204.61,8.86 204.61,6.83 202.48,4.69 v1(200.01,4.69) 199.68,4.69 198.77,3.78 198.31,3.78 198.09,3.56 v4(198.09,3.24)
I2C_1_SDA: length 67.2
  TOP w0.069: v2(196.98,30.31) 196.98,30.3 199.24,28.03 199.24,18.53 198.31,17.59 v1(198.31,16.02) 198.31,11.41 195.26,8.36 195.26,6.77 194.5,6.01 194.5,4.77 v4(194.78,4.49)
  IN1 w0.061: v2(196.98,30.31) 196.67,30.61 196.67,31.62 195.43,32.87 195.43,34.47 193.41,36.49 192.87,36.49 189.9,39.46 188.79,39.46 188.28,39.97 188.26,39.97 187.68,40.56 186.69,40.56 184.33,42.92 183.46,42.92 182.1,44.28 181.83,44.28 181.32,44.79 180.39,44.79 178.59,46.59 174.73,46.59 173.72,47.6 172.28,47.6 171.29,48.58 v3(170.49,48.58)
  IN3 w0.061: v4(170.49,47.96) v3(170.49,48.58)
  BOTTOM w0.069: v4(194.78,4.49) 194.78,3.02 195.03,2.77 R6220.1
I2C_1_SDA_R: length 14.5
  BOTTOM w0.069: JTP1.2 205.71,9.42 204.98,8.7 204.98,6.64 202.36,4.01 200.2,4.01 v1(199.61,3.42) 199.15,3.42 198.9,3.17 198.75,3.17 198.72,3.15 198.71,3.15 D483.2 198.45,2.89 198.01,2.89 197.88,3.01 197.03,3.01 196.82,2.8 R6216.2 195.97,2.8 195.95,2.77 R6220.2
I2C_RT_L_INT#: length 14
  IN3 w0.061: v4(31.08,59.02) 30.16,58.11 27.65,58.11 26.42,56.88 25.58,56.88 25.29,57.17 23.25,57.17 v4(22.32,56.23)
  BOTTOM w0.069: v4(31.08,59.02) 31.41,58.69 31.41,57.76 31.18,57.52 30.83,57.52 URT1.A10 ; v4(22.32,56.23) 21.99,56.56 21.5,56.56 RT152.1
I2C_RT_L_SCL: length 1.7
  IN1 w0.061: v3(29.15,56.76) 29.57,57.18 v2(30.32,57.18)
  IN3 w0.061: v4(29.39,57) v3(29.15,56.76)
I2C_RT_L_SDA: length 1.8
  IN1 w0.061: v2(30.32,56.54) 29.47,56.54 v3(29.12,56.2)
  IN3 w0.061: v4(28.74,56.35) 28.9,56.2 v3(29.12,56.2)
I2C_RT_R_INT#: length 3.2
  BOTTOM w0.069: URT2.A10 270.75,54.22 272.05,55.52 272.05,56.34 RT199.1
I2C_RT_R_SCL: length 2.8
  TOP w0.069: RT197.1 270.75,53.45 270.34,53.87 269.78,53.87 v3(269.74,53.91)
  IN3 w0.061: v4(269.27,53.91) v3(269.74,53.91)
I2C_RT_R_SDA: length 3.1
  TOP w0.069: RT198.1 270.17,52.3 270.37,52.51 270.37,53.31 v2(270.3,53.38)
  IN1 w0.061: v2(270.3,53.38) 269.59,53.38 269.4,53.58 268.99,53.58 v3(268.95,53.54)
  IN3 w0.061: v3(268.95,53.54) 268.67,53.26 v4(268.62,53.26)
I_ADP: length 173.3
  TOP w0.069: v1(29.73,9.03) 29.91,9.03 30.92,10.04 PR234.2 31.13,9.84 31.13,9.72 31.25,9.6 v2(31.38,9.6)
  IN1 w0.061: v3(184.72,19.91) 184.82,19.91 185.13,20.21 185.13,21.56 184.9,21.79 v2(184.73,21.79) ; v2(31.38,9.6) 31.41,9.63 32.31,9.63 34.79,7.16 v3(35.83,7.16)
  IN2 w0.051: v3(184.72,19.91) 184.82,19.91 186.23,18.5 186.23,17.31 185.86,16.94 185.86,14.9 184.62,13.66 183.63,13.66 182.89,12.92 180.9,12.92 180.54,13.28 176.79,13.28 176.33,12.82 171.82,12.82 171.09,12.08 168.24,12.08 165.87,9.72 140.99,9.72 140.71,10 136.76,10 136.25,9.49 123.13,9.49 123.08,9.44 107.38,9.44 104.41,6.47 94.82,6.47 93.5,7.79 80.99,7.79 80.49,8.3 74.3,8.3 73.74,7.74 68.77,7.74 68.14,8.37 64.7,8.37 64.06,7.74 63.1,7.74 62.63,8.2 41.9,8.2 41.75,8.06 41.4,8.06 40.23,6.88 40.23,6.46 39.86,6.09 38.44,6.09 37.38,7.16 v3(35.83,7.16)
I_BATT: length 162.5
  TOP w0.069: v2(33.8,7.18) v1(32.02,7.18) 31.1,7.18 30.54,7.74 30.54,8.74 PR233.2 ; v2(177.8,6.63) 177.93,6.63 178.65,7.36 178.65,7.76 179,8.12 RE125.2
  IN1 w0.061: v2(33.8,7.18) 34.33,6.65 34.33,4.18 34.08,3.93 34.08,3.55 34.28,3.34 37.55,3.34 38.39,4.18 38.85,4.18 39.33,4.66 39.89,4.66 40.44,5.21 41.21,5.21 41.74,5.73 41.74,5.94 42.39,6.6 45.13,6.6 45.69,6.03 92.74,6.03 96.27,2.5 113.51,2.5 114.12,3.12 121.02,3.12 121.78,3.88 128.47,3.88 130.3,5.71 157.67,5.71 159.25,4.13 159.25,3.47 159.75,2.96 162.98,2.96 164.23,4.21 170.15,4.21 171.1,5.16 175.45,5.16 176.84,6.55 177.71,6.55 v2(177.8,6.63)
I_BATT_R: length 8.5
  TOP w0.069: UE1.J4 178.82,15.88 178.82,13.72 178.65,13.55 178.65,12.41 v2(178.53,12.29) ; v2(179.08,9.03) CE106.1
  IN1 w0.061: v2(179.08,9.03) 178.91,9.2 178.83,9.2 178.63,9.4 178.63,11.68 178.53,11.78 v2(178.53,12.29)
I_SYS: length 242.7
  TOP w0.203: v5(88.64,59.45) 88.92,59.73 91.42,59.73 93.38,57.78 93.38,48.27 92.75,47.64 90.39,47.64 88.89,46.14 88.89,41.97 91.9,38.96 91.9,38.36 92.9,37.36 93.77,37.36 94.22,36.9 94.63,36.9 98.97,32.56 98.97,29.66 100.75,27.88 100.75,15.89 v3(106.03,10.61) 106.03,7.82 v1(103.75,5.53) 42.33,5.53 41.57,6.29 40.43,6.29 v2(40.37,6.24) ; v2(37.02,15.77) 36.13,15.77 34.25,13.89 31.15,13.89 30.44,13.17 PR232.1 30.44,11.76 PR229.2
  IN1 w0.061: v2(179.03,9.87) v4(179.03,9.85)
  IN1 w0.203: v2(40.37,6.24) 40.37,7 42.27,8.9 42.27,11.07 37.58,15.77 v2(37.02,15.77)
  IN2 w0.203: v3(106.03,10.61) 107.02,10.61 107.35,10.28 122.73,10.28 122.78,10.33 135.9,10.33 136.41,10.84 141.06,10.84 141.34,10.56 165.53,10.56 168.12,13.15 170.3,13.15 v4(170.4,13.05)
  BOTTOM w0.203: v4(179.03,9.85) 179.03,6.28 178.78,6.04 174.28,6.04 173.88,6.44 173.88,8.03 170.65,11.26 170.65,12.8 v4(170.4,13.05) ; PR1103.1 91.99,60.44 91.02,59.48 88.67,59.48 v5(88.64,59.45)
I_SYS_R: length 7.4
  TOP w0.203: CE107.1 179.95,10.74 RE159.1 ; CE107.1 179.91,11.38 179.54,11.75 179.54,15.8 UE1.J5 ; CE107.1 RE126.1
IMON: length 4.4
  BOTTOM w0.069: v1(102.81,64.18) 102.51,63.88 102.51,63.5 102.25,63.24 PR1133.1
  BOTTOM w0.203: PR1133.1 PC1107.1 101.79,61.71 PU1100.9
IMVP_SMBCLK: length 130.5
  TOP w0.069: v3(181.07,20.54) 181.07,19.05 UE1.F7
  IN2 w0.051: v3(98.58,55.37) 98.41,55.21 98.41,54.98 97.93,54.5 97.79,54.5 91.38,48.09 91.38,33.14 96.56,27.96 109.61,27.96 110,28.34 112.76,28.34 114.57,30.14 162.5,30.14 164.28,28.36 169.89,28.36 170.7,27.55 173.65,27.55 174.59,26.61 175.86,26.61 v3(176.11,26.87)
  IN3 w0.061: v3(181.07,20.54) 180.49,21.11 179.5,21.11 179.25,21.37 177.99,21.37 175.21,24.15 175.21,25.96 v3(176.11,26.87) ; v4(97.37,56.13) 97.6,56.13 97.66,56.07 97.66,55.79 97.37,55.5 97.37,55 97.67,54.69 98.14,54.69 98.42,54.98 98.42,55.22 v3(98.58,55.37)
IMVP_SMBCLK_VR: length 3.3
  BOTTOM w0.203: PR1112.2 96.84,57.04 PR1118.1 97.37,57.14 97.83,57.6 98.18,57.6 98.3,57.72 PU1100.18
IMVP_SMBDAT: length 128.7
  IN1 w0.061: v2(180.73,21.79) v3(180.73,22.13)
  IN2 w0.051: v3(98.04,55.37) 98.24,55.18 98.24,55.06 97.86,54.68 97.72,54.68 91.2,48.16 91.2,33.07 96.49,27.78 109.69,27.78 110.07,28.16 112.84,28.16 114.64,29.96 162.42,29.96 164.2,28.18 169.82,28.18 170.63,27.37 173.58,27.37 174.52,26.43 176.32,26.43 v3(176.74,26.86)
  IN3 w0.061: v3(176.74,26.86) 176.37,26.48 176,26.48 175.4,25.88 175.4,24.23 178.07,21.56 179.26,21.56 179.83,22.13 v3(180.73,22.13) ; v4(98.13,56.13) 97.91,56.13 97.85,56.07 97.85,55.71 97.56,55.42 97.56,55.07 97.75,54.88 98.06,54.88 98.24,55.06 98.24,55.18 v3(98.04,55.37)
IMVP_SMBDAT_VR: length 2.9
  BOTTOM w0.203: PR1113.2 98.3,56.88 PR1121.1 98.7,57.61 PU1100.17
IMVP_VR_ON_EC: length 157.7
  TOP w0.069: UE1.N7 181.53,11.86 v2(182.01,11.37) 182.26,11.13 182.26,11.03 182.53,10.76 RE473.2
  IN1 w0.061: v3(182.04,15.42) 181.81,15.19 181.81,12.29 182.01,12.08 v2(182.01,11.37)
  IN2 w0.051: v3(182.04,15.42) 182.04,15.43 181.93,15.53 181.93,17.45 180.95,18.43 175.17,18.43 174.72,18.88 171.49,18.88 170.61,19.77 170.61,23.15 166.73,27.03 161.29,27.03 160.47,27.86 115.41,27.86 114.01,26.46 110.77,26.46 110.39,26.08 107.53,26.08 107.1,25.65 101.98,25.65 101.17,26.46 96.59,26.46 89.88,33.17 89.88,48.83 94.63,53.58 94.63,55.65 95.59,56.61 97.09,56.61 97.55,56.15 109.16,56.15 v4(109.53,55.78)
  BOTTOM w0.069: v4(109.53,55.78) 109.56,55.78 v1(109.93,56.15) 110.33,56.55 110.33,58.89 110.27,58.95 RE10.1 109.54,59.35 109.34,59.35 109.16,59.53 109.16,60.29 109.32,60.45 109.65,60.45 U15.2
IMVP_VR_ON_EN: length 73.8
  TOP w0.069: v2(91.91,57.6) 92.09,57.42 92.09,51.61 88.3,47.81 88.3,41.72 91.31,38.71 91.31,37.84 93.57,35.58 95.61,35.58 98.31,32.88 98.31,28.26 99.86,26.71 99.86,16.6 98.01,14.75 PJTAG8.2
  IN1 w0.061: v5(96.93,58.04) 96.9,58.04 96.46,57.6 v2(91.91,57.6)
  IN3 w0.061: v4(100.42,58.11) 100.14,57.83 100.14,57.45 99.96,57.27 97.52,57.27 96.93,57.87 v5(96.93,58.04)
  BOTTOM w0.069: v4(100.42,58.11) 102.2,56.33 v1(103.34,56.33) 108.64,56.33 109.56,57.26 CE430.1 109.59,57.32 RE489.2
  BOTTOM w0.203: PU1100.21 97.1,58.22 v5(96.93,58.04)
IMVP_VR_ON_P: length 114.5
  TOP w0.069: UH6.2 174.19,27.39 173.68,27.9 v2(173.68,28.49) ; v5(173.34,37.51) 173.27,37.44 v1(173.27,36.39) 173.27,36.37 171.1,34.2 v2(171.1,33.42)
  IN1 w0.061: v2(171.1,33.42) 171.1,33.05 173.06,31.09 173.06,29.26 173.68,28.65 v2(173.68,28.49)
  IN2 w0.051: v4(109.34,61.94) 109.98,61.31 112.15,61.31 112.94,60.52 115.54,60.52 120.11,65.09 125.17,65.09 126.02,64.24 129.71,64.24 130.16,63.8 134.35,63.8 134.76,64.2 135.27,64.2 135.8,63.67 138.51,63.67 139.12,64.28 140.66,64.28 140.94,64.56 148.27,64.56 148.83,64 159.12,64 159.23,63.89 166.76,63.89 173.75,56.9 173.75,51.53 173.88,51.39 173.88,48.5 173.55,48.16 173.55,42.05 173.34,41.85 v5(173.34,37.51)
  BOTTOM w0.069: RE489.1 RE29.1 ; RE29.1 RE10.2 ; RE29.1 108.27,59.35 107.91,59.35 107.79,59.47 U15.4 108.32,59.84 108.36,59.8 108.55,59.8 108.83,60.08 108.83,61 109.34,61.52 v4(109.34,61.94) 108.31,61.94 107.74,62.51 107.74,62.55 107.39,62.9 UE8.2
INPUT3VSEL: length 7.2
  BOTTOM w0.069: RH301.1 RH298.1 169.23,29.6 169.23,31.53 168.68,32.08 v1(168.68,32.16) 168.19,32.66 168.19,34.49 167.75,34.92 UC1.DN49
INTRUDER#: length 11.5
  TOP w0.069: RH64.1 168.7,36.31 168.62,36.23 v3(168.49,36.23) 168.43,36.17 168.11,36.17 v1(167.84,36.43)
  IN3 w0.061: v4(170.98,35.35) 170.83,35.5 169.55,35.5 168.82,36.23 v3(168.49,36.23) 168.44,36.18 168.22,36.18 v4(168.16,36.24)
  BOTTOM w0.069: UC1.DR47 168.4,36.45 168.19,36.24 v4(168.16,36.24) ; v4(170.98,35.35) 170.73,35.1 170.73,34.28 172.37,32.64 173.31,32.64 173.47,32.48 173.47,31.99 CC653.1 173.21,31.56 RH671.1
IRCAM_EN: length 49.4
  TOP w0.069: RE528.2 188.69,25.77 v3(189.04,26.13) v6(189.85,26.13)
  IN1 w0.061: v3(181.4,23.21) 181.32,23.13 181.32,22.52 181.08,22.28 181.08,21.34 180.38,20.64 180.02,20.64 179.57,20.19 179.57,18.15 v2(179.93,17.79)
  IN2 w0.051: v3(186.73,47.72) 187.01,47.72 187.03,47.69 187.03,47.22 192.19,42.06 192.19,39.83 194.65,37.37 194.65,36.87 194.99,36.53 v4(195.54,36.53)
  IN3 w0.061: v3(186.73,47.72) 186.58,47.72 v4(186.31,47.98) ; v4(193.64,30.62) 193.64,29.15 193.25,28.76 192.86,28.76 191.51,27.41 190.82,27.41 190.11,26.7 189.61,26.7 v3(189.04,26.13) 188.46,25.54 187.86,25.54 186.53,24.21 182.93,24.21 181.98,23.26 181.45,23.26 v3(181.4,23.21)
  BOTTOM w0.069: v4(186.31,47.98) 185.37,48.93 QZ11.2 ; v4(195.54,36.53) 195.44,36.43 195.44,32 194.06,30.62 v4(193.64,30.62)
ISH_I2C_1_SCL: length 116.1
  TOP w0.069: R6116.1 162.87,62.14 162.87,61.4 164.08,60.19 164.08,57.41 164.37,57.12 v1(165.05,56.44) 165.2,56.29 165.2,51.56 164.45,50.81 164.45,48.19 162.76,46.5 159.68,46.5 v2(158.99,47.19)
  IN1 w0.061: v2(157.95,38.21) 157.54,38.61 v3(157.54,38.68) 157.54,40.23 157.06,40.71 157.06,43.3 157.49,43.73 157.49,44.54 158.99,46.04 v2(158.99,47.19)
  IN2 w0.051: v3(157.54,38.68) 158.94,37.28 158.94,33.9 159.43,33.42 159.81,33.42 160.19,33.04 170.78,33.04 171.97,31.84 175.72,31.84 176.55,31.01 180.33,31.01 180.93,30.4 184.78,30.4 185.93,29.25 187.07,29.25 188.55,27.78 190.96,27.78 193.09,25.65 195.52,25.65 196.38,24.78 196.38,20.45 202.37,14.46 205.75,14.46 206.29,15 210.42,15 211.53,13.9 220.88,13.9 222.05,12.72 v4(222.05,12.49)
  IN3 w0.061: v4(156.64,38.31) 157.18,38.31 v3(157.54,38.68)
  BOTTOM w0.069: JIO1.22 221.45,11.66 222.05,12.26 v4(222.05,12.49)
ISH_I2C_1_SCL_R: length 8.2
  TOP w0.069: R6116.2 163.67,63.82 TP134.1 163.95,64.56 v5(163.95,65.32)
  BOTTOM w0.069: JUFC1.34 159.6,66.04 160.16,65.47 162.73,65.47 163.06,65.14 163.77,65.14 v5(163.95,65.32) 164.15,65.52 JUFC1.8
ISH_I2C_1_SDA: length 118.8
  TOP w0.069: v2(159.41,47.17) 159.64,47.17 159.93,46.88 162.28,46.88 v1(162.57,47.17) 162.9,47.17 164.08,48.35 164.08,50.96 164.83,51.71 164.83,56.14 164.22,56.75 163.71,57.26 163.71,60.03 162.5,61.24 162.5,62.4 R6117.1
  IN1 w0.061: v2(158.59,38.21) 158.55,38.21 v4(158.08,38.68) 158,38.75 158,40.29 157.8,40.48 157.43,40.86 157.43,43.05 158.11,43.73 159.41,45.03 v2(159.41,47.17)
  IN2 w0.051: v4(158.08,38.68) 159.09,37.66 159.09,33.97 159.39,33.67 159.98,33.67 160.31,33.34 170.9,33.34 172.1,32.15 175.84,32.15 176.68,31.31 180.46,31.31 181.06,30.71 185.5,30.71 186.57,29.63 187.12,29.63 188.67,28.08 191.08,28.08 193.22,25.95 195.83,25.95 196.69,25.1 196.69,20.58 202.5,14.77 205.62,14.77 206.16,15.31 210.55,15.31 211.66,14.2 221.21,14.2 v4(222.9,12.51)
  BOTTOM w0.069: v4(222.9,12.51) 223.1,12.31 223.1,11.98 222.95,11.83 222.95,10.63 221.75,9.43 JIO1.23 ; UC1.CN41 158.08,39.08 v4(158.08,38.68)
ISH_I2C_1_SDA_R: length 7.2
  TOP w0.069: v5(163.39,65.5) 163.39,65.14 162.73,64.48 TP135.1 163.03,64.05 R6117.2
  BOTTOM w0.069: JUFC1.32 159.95,66.04 160.29,65.7 163.19,65.7 v5(163.39,65.5) 163.8,65.91 JUFC1.10
ISH_TABLE_MODE#: length 47.9
  TOP w0.069: v2(174.08,37.33) 174.59,37.33 174.77,37.15 174.77,34.21 173.7,33.14 173.12,33.14 172.51,32.52 170.16,32.52 169.84,32.2 169.84,26.84 169.97,26.71 170.78,26.71 171.18,26.31 171.18,22.37 v1(170.91,22.09) 170.8,21.99 170.8,21.71 170.95,21.56 171.57,21.56 171.79,21.78 176.03,21.78 176.37,22.12 177.7,22.12 177.96,21.86 177.96,20.5 178.02,20.43 178.02,19.26 178.22,19.07 178.7,19.07 178.82,18.95 178.82,18.34 179.05,18.11 181.7,18.11 181.85,17.96 181.85,17.47 UE1.H8
  IN1 w0.061: v2(174.08,37.33) 173.85,37.1 v3(173.72,37.1)
  IN2 w0.051: v3(173.72,37.1) 173.72,37 173.52,36.8 172.23,36.8 170.32,38.7 170.32,41.91 169.84,42.39 v4(169.84,42.72)
  IN3 w0.061: v4(174.27,37.84) 174.27,37.65 v3(173.72,37.1)
  BOTTOM w0.069: RC751.2 174.27,38.21 v4(174.27,37.84)
IST_TP_0: length 1.9
  TOP w0.069: TP62.1 144.95,54.4 144.49,53.94 v5(144.49,53.48)
  BOTTOM w0.069: UC1.BF11 v5(144.49,53.48)
IST_TP_1: length 1.2
  TOP w0.069: TP61.1 143.57,52.98 v5(143.57,53.48)
  BOTTOM w0.069: UC1.BD11 v5(143.57,53.48)
IST_TRIG_0: length 1.4
  TOP w0.069: v5(144.03,53.83) 143.81,53.83 TP64.1
  BOTTOM w0.069: UC1.BE10 v5(144.03,53.83)
IST_TRIG_1: length 2.9
  TOP w0.069: v5(144.97,53.83) 146.06,54.93 TP63.1
  BOTTOM w0.069: UC1.BF10 144.97,54.55 v5(144.97,53.83)
JACK_PLUG#: length 35.1
  TOP w0.069: UA1.48 256.13,59.24 CA40.1 v2(256.12,57.98)
  IN1 w0.061: v2(256.12,57.98) v3(256.63,57.98)
  IN3 w0.061: v4(268.95,60.9) 268.95,60.52 267.3,58.87 257.52,58.87 v3(256.63,57.98)
  BOTTOM w0.069: RA14.1 277.99,69.33 278.58,68.75 278.58,67.1 276.44,64.97 v1(276.44,63.72) 276.44,61 275.4,59.96 269.89,59.96 v4(268.95,60.9)
JTAG_CLK: length 68.6
  IN1 w0.061: v3(182.33,21.49) v2(182.33,20.99)
  IN3 w0.061: v4(239.54,12.58) 239.19,12.24 238.77,12.24 238.62,12.39 238.62,12.63 238.4,12.84 237.05,12.84 235.38,11.17 221.51,11.17 221.16,10.83 216.81,10.83 216.34,11.3 216.27,11.3 v3(215.74,11.83) 214.92,11.83 214.12,11.03 195.08,11.03 194.72,11.39 194.34,11.39 194.02,11.07 193.37,11.07 193.31,11.02 192.7,11.02 192.54,11.18 192.54,11.66 188.03,16.17 188.03,17.14 187.36,17.81 187.36,20.13 186.55,20.95 185.64,20.95 184.57,22.01 182.85,22.01 v3(182.33,21.49)
  BOTTOM w0.069: v4(239.54,12.58) 240.11,13.15 JDEG1.4
JTAG_RST#: length 12.4
  TOP w0.069: RE164.1 189.15,7.87 CE63.1 189.11,8.85 JTAG2.1 189.08,8.88 188.41,9.56 188.41,9.78 188.64,10 RE156.1 188.18,10.63 v2(188.18,10.66) ; UE1.G13 v2(186.94,17.79)
  IN1 w0.061: v2(186.94,17.79) 187.32,17.41 187.32,16.08 188.22,15.18 188.22,11.87 188.18,11.83 v2(188.18,10.66)
JTAG_TDI: length 65.5
  IN1 w0.061: v3(237.83,12.14) 237.28,12.14 v2(237.17,12.03) ; v3(183.13,19.04) v2(183.13,19.39)
  IN3 w0.061: v4(238.27,12.58) v3(237.83,12.14) 236.4,10.71 225.59,10.71 224.53,9.66 216.6,9.66 216.21,10.05 197.05,10.05 196.41,9.42 192.24,9.42 190.84,10.81 190.84,11.12 189.09,12.87 188.19,12.87 186.55,14.5 186.55,15.37 186.03,15.9 186.03,18.24 185.6,18.66 183.51,18.66 v3(183.13,19.04)
  BOTTOM w0.069: v4(238.27,12.58) 238.79,13.1 238.88,13.1 239.11,13.33 JDEG1.2
JTAG_TDO: length 69.9
  IN1 w0.061: v2(180.73,18.59) v3(180.73,18.92)
  IN3 w0.061: v4(240.17,12.58) 239.14,11.55 237.58,11.55 236.58,10.55 225.66,10.55 224.6,9.49 216.53,9.49 216.14,9.89 207.9,9.89 v3(207.67,9.66) 207.44,9.89 197.12,9.89 196.41,9.18 191.85,9.18 190.68,10.36 190.68,11.05 189.03,12.7 186.84,12.7 186.39,13.15 186.39,15.3 185.87,15.83 185.87,17.67 185.66,17.87 185.23,17.87 184.75,18.36 183.15,18.36 182.58,18.92 v3(180.73,18.92)
  BOTTOM w0.069: JDEG1.5 240.61,13.01 v4(240.17,12.58)
JTAG_TMS: length 69.9
  IN1 w0.061: v2(179.93,20.99) 179.98,21.04 v3(179.98,21.45)
  IN3 w0.061: v3(179.98,21.45) 180.04,21.51 181.32,21.51 181.99,22.18 184.64,22.18 185.7,21.11 186.62,21.11 187.54,20.19 187.54,17.98 188.2,17.32 188.2,16.24 192.7,11.73 192.7,11.25 192.77,11.18 193.24,11.18 193.3,11.23 193.96,11.23 194.27,11.55 194.79,11.55 195.15,11.19 213.29,11.19 v3(213.93,11.83) 214.27,12.17 221.24,12.17 221.42,11.99 223.35,11.99 224,11.34 235.31,11.34 237,13.02 238.46,13.02 v4(238.9,12.58)
  BOTTOM w0.069: v4(238.9,12.58) 239.61,13.28 JDEG1.3
KB_DET#: length 86.6
  IN1 w0.061: v3(162.15,35.95) 161.48,35.27 160.83,35.27 160.06,36.04 160.06,36.59 160.34,36.87 160.34,37.18 160.26,37.25 160.26,39.08 v4(160.57,39.39) 160.36,39.6 v2(160.36,39.65)
  IN2 w0.051: v3(162.15,35.95) 162.19,35.98 163.52,35.98 164.56,34.94 175.31,34.94 177.34,32.91 181.12,32.91 181.72,32.31 186.19,32.31 187.07,31.42 188.61,31.42 189.37,30.66 191.52,30.66 192.52,29.66 v3(192.57,29.66) 192.57,29.61 193.31,28.87 193.31,28.15 193.91,27.55 196.57,27.55 198.29,25.83 198.29,21.24 201.53,18 204.05,18 205.14,16.91 211.21,16.91 212.32,15.8 224.77,15.8 v4(225.53,15.04)
  BOTTOM w0.069: v4(225.53,15.04) 225.44,14.95 225.44,14.67 224.65,13.89 224.65,11.83 224.45,11.63 JIO1.32 ; UC1.CV41 160.54,39.39 v4(160.57,39.39)
LAN_WAKE#: length 32.4
  TOP w0.069: v2(164.22,34.28) 164.46,34.52 164.46,34.94 v1(164.38,35.02) 164.37,35.03 RH600.2 RH601.1
  IN1 w0.061: v3(171.06,27.89) 171.06,28.31 170.69,28.68 170.69,30.03 170.05,30.66 170.05,30.89 167.8,33.14 165.36,33.14 v2(164.22,34.28)
  IN3 w0.061: v3(171.06,27.89) 171.25,27.89 171.91,27.23 173.35,27.23 174.47,26.11 174.47,23.19 175.08,22.58 175.08,18.62 175.51,18.18 176.57,18.18 176.87,18.48 v4(177.89,18.48)
  BOTTOM w0.069: v4(177.89,18.48) 178.33,18.04 v4(178.33,14.59)
LAN_WAKE#_R: length 3.9
  TOP w0.069: RH600.1 163.53,34.17 v5(163.23,33.88) 163.49,33.62 v1(163.49,33.32)
  BOTTOM w0.069: v5(163.23,33.88) 163.11,34 163.11,35.71 163.48,36.08 UC1.DE47
LCD_TST: length 121.8
  TOP w0.069: UE1.M2 177.51,13.79 177.2,13.48 176.32,13.48 176.19,13.61 v2(175.63,13.61) 175.38,13.35 175.38,12.93 174.93,12.48 RE160.2 ; v4(135.5,65.5) 135.77,65.23 136.38,65.23 136.64,64.97 TP116.1
  IN1 w0.061: v3(176.49,24.35) 176.21,24.07 176.21,23.23 176.3,23.14 176.3,16.39 175.63,15.71 v2(175.63,13.61)
  IN2 w0.051: v3(192.85,33.9) 192.77,33.98 192.16,33.98 191.71,34.43 187.07,34.43 185.67,35.83 184.94,35.83 184.62,36.15 184.62,37.16 183.46,38.32 183.46,39.05 181.84,40.67 181.62,40.67 181.17,41.12 181.17,41.66 180.81,42.02 180.81,42.47 179.39,43.88 179.39,45.86 178.96,46.3 178.96,48.11 176.54,50.53 176.54,51.36 175.07,52.84 175.07,57.1 167.3,64.87 167.3,65.32 166.98,65.64 166.19,65.64 165.59,66.24 155.13,66.24 154.06,65.17 149.17,65.17 148.48,65.85 145.79,65.85 145.41,66.24 143.53,66.24 143.08,65.78 140.6,65.78 140.27,66.11 136.11,66.11 v4(135.5,65.5)
  IN3 w0.061: v3(192.85,33.9) 192.85,31.33 193.22,30.97 193.22,29.81 191.3,27.89 190.62,27.89 189.91,27.18 189.37,27.18 188.97,26.79 188.77,26.79 188.07,26.09 187.71,26.09 186.77,25.14 186.19,25.14 185.91,24.86 182.65,24.86 182.56,24.77 178.36,24.77 178.04,25.09 176.7,25.09 176.49,24.88 v3(176.49,24.35)
  BOTTOM w0.069: v4(135.5,65.5) 135.27,65.5 134.7,66.07 JEDP1.2
LCD_VCC_TEST_EN: length 138.5
  IN1 w0.061: v2(176.73,19.39) 177.03,19.09 v3(177.03,18.99)
  IN2 w0.051: v3(96.08,55.34) 96.08,54.81 90.03,48.77 90.03,33.23 96.65,26.61 101.23,26.61 102.05,25.8 107.03,25.8 107.46,26.23 110.33,26.23 110.71,26.61 113.95,26.61 115.35,28.01 160.57,28.01 161.39,27.18 166.79,27.18 170.76,23.22 170.76,19.84 171.56,19.04 173.55,19.04 173.69,19.17 176.85,19.17 v3(177.03,18.99)
  IN3 w0.061: v3(96.08,55.34) 95.12,56.3 95.12,58.59 94.83,58.87 94.83,60.43 94.02,61.24 94.02,64.66 96.93,67.57 97.54,67.57 97.83,67.86 97.83,68.39 v4(97.78,68.45)
  BOTTOM w0.069: D1.2 97.78,68.64 v4(97.78,68.45)
LCDVDD_MONITOR: length 0.9
  BOTTOM w0.203: R628.1 110.71,68.52 110.84,68.65 QV21.2
LDO2_CAP: length 1.9
  TOP w0.203: CA51.1 265.14,63.06 264.62,62.54 264.34,62.54 264.24,62.44 UA1.21
LDO3_CAP: length 3.1
  TOP w0.203: UA1.19 264.44,61.64
  TOP w0.254: CA32.1 265.77,60.39 264.86,61.31 v1(264.86,61.38) 264.82,61.48 264.44,61.64
LDO_3V: length 2.9
  BOTTOM w0.254: PR305.2 212.66,17.98 212.66,18.76 PC342.2 212.69,19.31 212.99,19.61 PU302.6
LID_CL_SIO#: length 11.5
  TOP w0.069: DE1.2 189.16,4.42 188.84,4.74 188.84,6.12 188.46,6.49 v1(188.46,6.55) 188.46,6.67 188.4,6.73 188.4,8.92 v2(187.72,9.59) ; UE1.N11 185.59,12.13 185.89,12.13 186.82,11.2 186.82,11.05 v2(187.13,10.74)
  IN1 w0.061: v2(187.13,10.74) 187.72,10.15 v2(187.72,9.59)
LID_CL_TS_FP#: length 163.3
  TOP w0.069: RH743.1 174.59,50 v3(175.15,49.45) ; v3(191.76,3.88) 191.78,3.9 DE3.2 191.78,4.91 191.85,4.97 RE237.2 191.86,5.5 193.42,7.06 193.42,7.58 196.95,11.1 v1(197.07,11.1) 197.07,11.49 197.03,11.54 197.03,15.17 195.99,16.21 195.99,19.61 198.5,22.11 198.5,25.87 196.41,27.95 196.41,30.71 195.74,31.39 194.69,31.39 v3(194.67,31.38)
  IN2 w0.051: v3(194.67,31.38) 194.76,31.46 194.76,31.83 194.11,32.48 189.82,32.48 189.46,32.84 188.69,32.84 188.14,33.39 186.82,33.39 185.29,34.92 184.31,34.92 183.2,36.03 183.2,37.22 180.07,40.35 178.5,40.35 174.31,44.54 174.31,47.38 175.15,48.21 v3(175.15,49.45) ; v3(256.22,23.89) 256.22,24.96 259.02,27.75 259.28,27.75 259.89,28.37 259.89,29.16 259.56,29.49 v3(259.56,31.15)
  IN3 w0.061: v3(256.22,23.89) 255.53,23.89 254.78,23.15 254.78,22.96 253.96,22.14 253.96,21.46 253.63,21.13 253.38,21.13 252.73,20.47 252,20.47 249.54,18.01 249.54,17.25 249.03,16.73 247.87,16.73 246.69,15.55 246.69,14.62 247.15,14.17 247.15,11.8 246.45,11.11 246.45,10.44 246.25,10.25 246.25,9.33 245.71,8.79 243.9,8.79 243.49,8.37 242.93,8.37 239.87,5.31 199.06,5.31 197.99,4.24 197.07,4.24 196.26,3.43 192.21,3.43 v3(191.76,3.88) ; v3(259.56,31.15) 259.56,32.14 259.25,32.45 259.25,34.2 257.52,35.93 v4(257.52,36.26)
  BOTTOM w0.069: v4(257.52,36.26) 256.2,36.26 255.06,37.41 R808.2
LID_POWER_ON#: length 121.9
  TOP w0.069: v2(119.31,3.38) 119.31,3.09 PD601.1 ; RE142.1 179.91,24.37 179.44,23.9 179.44,20.5 v2(179.13,20.19)
  IN1 w0.061: v2(119.31,3.38) 120.16,4.23 128.59,4.23 130.23,5.87 157.74,5.87 159.41,4.2 159.41,3.53 159.82,3.12 162.91,3.12 164.16,4.37 170.08,4.37 171.03,5.32 175.39,5.32 176.99,6.93 178.08,6.93 178.39,7.24 v4(178.64,7.24) ; v2(179.13,20.19) 179.13,19.86 v4(179.16,19.83)
  IN2 w0.051: v4(178.64,7.24) 180.47,7.24 181.66,8.43 185.95,8.43 186.16,8.22 194.98,8.22 195.52,8.76 198.71,8.76 v3(199.65,7.82)
  IN3 w0.061: v3(199.65,7.82) 200.08,7.38 v4(202.35,7.38)
  BOTTOM w0.069: v4(202.35,7.38) 202.63,7.38 202.75,7.5 202.75,8.65 202.08,9.32 202.08,10.61 203,11.54 203,15.2 204.55,16.74 205.13,16.74 v1(205.83,16.05) 205.98,16.05 206.29,16.35 QE19.1 ; v4(179.16,19.83) 179.16,15.77 178.83,15.44 178.83,11.13 178.64,10.93 v4(178.64,7.24)

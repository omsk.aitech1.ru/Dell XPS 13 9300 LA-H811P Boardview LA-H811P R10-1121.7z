# Allegro board LAH811PR10-1121.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VALW on VCC: 23.46,1.22 23.46,4.36 21.4,6.42 18.18,6.42 18.18,29.81 18.17,29.81 17.54,31.23 16.12,31.87 16.11,31.87 10.68,31.87 10.68,35.79 10.67,35.79 10.04,37.22 8.62,37.85 8.61,37.85 4.16,37.85 4.16,42.16 4.15,42.16 3.52,43.58 2.1,44.22 2.09,44.22 1.17,44.22 1.17,47.43 3.19,47.43 4.09,46.53 7.56,46.53 8.47,47.43 13.96,47.43 14.65,47.01 15.46,46.96 15.46,40.86 16.11,40.2 22.04,40.2 22.67,40.84 37.9,40.84 39.75,33.6 43.67,27.25 31.71,27.25 31.71,30.91 29.79,32.83 25.77,32.83 24.6,31.67 24.6,29.17 26.13,27.65 26.13,12.28 28.41,10 28.41,1.22
+5VALW on IN2: 127.98,57.73 127.98,56.08 128.23,55.82 131.66,55.82 132.81,56.96 132.81,57.47 132.3,57.98 128.23,57.98
+5VALW_L_TBT on BOTTOM (solid shape): 23.48,37.67 24.96,37.67 25.01,37.61 25.01,37.44 24.95,37.38 23.17,37.38 23.1,37.3 22.67,37.3 22.6,37.38 22.6,37.94 22.65,37.99 23.16,37.99
+5VALW_L_TBT on BOTTOM (solid shape): 35.09,32.84 35.09,30.9 34.74,30.55 32.19,30.55 32.1,30.64 32.1,31.56 31.89,31.78 30.54,31.78 30.1,32.22 30.1,33.17 30.17,33.23 34.69,33.23
+5VALWB on TOP: 193.13,45.41 193.89,45.41 194.15,45.66 194.15,47.31 199.61,52.77 202.02,52.77 202.66,52.14 205.07,52.14 205.2,52.01 205.2,50.87 204.81,50.49 202.27,50.49 200.92,49.13 199.65,49.13 194.78,44.26 193.47,44.26 192.86,43.65 191.48,43.65 191.29,43.84 191.29,44.79 191.53,45.03 192.75,45.03
+5VALWB on BOTTOM: 221.86,17.8 222.7,17.8 222.85,17.65 222.85,16.71 222.76,16.62 222.76,16.43 222.53,16.2 221.07,16.2 220.94,16.32 220.94,17.29 221.02,17.37 221.43,17.37
+5VALWB on BOTTOM: 228.56,7.31 228.56,12.64 228.69,12.77 228.69,14.04 228.44,14.29 227.14,14.29 227.01,14.17 227.01,13.76 227.42,13.35 227.42,12.01 226.66,11.24 226.66,9.97 226.91,9.72 226.91,7.31 227.04,7.18 228.44,7.18
+5VALWB on BOTTOM: 255.74,50.49 256.25,50.49 256.38,50.61 256.38,52.27 256.25,52.39 255.36,52.39 255.23,52.27 255.23,51.38 255.61,51 255.61,50.61
+5VALWB on BOTTOM: 261.73,29.97 261.46,30.25 261.46,33.66 261.85,34.06 265.85,34.06 266.08,33.83 266.08,30 266.05,29.97 265.56,29.97 265.56,30.52 264.8,30.52 264.8,29.97 264.35,29.97 264.35,30.51 263.59,30.51 263.59,29.97
+5VALWB on VCC: 221.94,12.51 209.21,25.24 203.29,35.32 203.29,51.91 203.65,52.27 205.78,52.27 205.78,43.14 231.02,18.59 255.1,44.28 255.09,44.29 254.94,45.79 254.67,47.27 253.02,52.68 250.11,57.54 250.02,57.83 250.15,58.11 254.57,62.53 254.65,62.53 255.05,62.12 255.13,62.04 257.65,62.04 257.65,51.27 260.19,48.73 260.19,37.05 262.98,34.25 262.98,27.48 262.24,26.74 259.57,26.74 258.43,25.6 252.97,25.6 248.85,21.48 236.53,13.73 235.32,12.51
+5VALWB on IN3: 261.63,31.87 261.63,30.6 261.91,30.32 262.68,30.32 263.56,31.21 263.56,31.62 263.13,32.05 261.81,32.05
+5VALWB on IN3: 255.36,50.49 256.38,50.49 256.5,50.61 256.5,52.01 256.38,52.14 255.36,52.14 255.23,52.01 255.23,50.61
+5VALWB_R_TBT on TOP (solid shape): 260.3,35.51 260.3,34.56 259.86,34.12 259.58,34.12 259.44,33.98 259.44,33.35 259.31,33.22 258.48,33.22 258.36,33.34 258.36,35.48 258.46,35.58 260.24,35.58
+5VALWB_R_TBT on TOP (solid shape): 267.81,40.25 267.81,40.13 267.8,40.12 267.8,39.69 267.75,39.64 267.25,39.64 267.17,39.72 265.45,39.72 265.39,39.79 265.39,39.95 265.45,40.01 266.99,40.01 267.29,40.3 267.76,40.3
+5VALWB_R_TBT on BOTTOM: 258.66,33.6 258.66,32.58 258.79,32.45 260.31,32.45 260.31,34.99 259.42,35.88 259.42,38.45 258.23,38.45 258,38.22 258,36.82 257.7,36.52 257.7,34.56
+5VALWB_R_TBT on IN1: 266.79,40.07 267.55,40.07 267.55,39.69 267.43,39.57 267.3,39.57 266.79,39.06 265.77,39.06 265.52,39.31 265.52,39.95 263.87,41.6 260.57,41.6 259.3,40.33 259.3,36.01 259.68,35.63 259.68,35.12 259.42,34.87 258.79,34.87 257.65,36.01 257.65,40.2 259.93,42.49 264.38,42.49
+5VALWBP on BOTTOM: 261.23,22.93 261.02,23.13 261.02,29.47 261.38,29.83 268.17,29.83 268.54,29.46 268.54,23.43 268.31,23.19 266.21,23.19 265.92,23.49 263.46,23.49 262.9,22.93
+5VALWP on BOTTOM (solid shape): 26.76,9.97 26.76,9.21 26.63,9.09 26.13,9.09 25.8,8.76 25.8,3.48 25.44,3.12 24.47,3.12 24.17,3.42 24.17,3.44 22.75,6.04 19.99,7.12 19.97,7.12 19.9,7.18 19.9,9.97 20.16,10.23 26.51,10.23
+5VALWP on TOP: 24.86,3.5 28.03,3.5 28.16,3.62 28.16,4.26 28.03,4.39 27.01,4.39 26.89,4.51 26.89,7.82 26.38,8.32 24.6,8.32 24.42,8.15 24.42,3.93
+5VBS on BOTTOM: 234.51,5.48 238.44,5.48 238.65,5.68 238.65,6.77 238.32,7.1 237.07,7.1 236.21,6.24 234.41,6.24 234.23,6.06 234.23,5.76
+5VBS on BOTTOM: 228.41,15.33 228.06,15.69 227.55,15.69 226.91,16.32 226.91,17.65 227.06,17.8 227.72,17.8 227.93,17.59 227.93,17.09 228.06,16.96 231.59,16.96 231.89,16.65 231.89,15.92 231.28,15.31 230.16,15.31 230.14,15.33
+5VBS_FAN2 on BOTTOM: 231.37,7.33 231.37,9.45 231.82,9.91 236.69,9.91 237.86,8.74 238.36,8.74 238.6,8.49 238.6,7.37 238.49,7.26 236.91,7.26 236.76,7.12 236.05,7.12 235.93,7.24 235.93,8.3 235.37,8.85 232.9,8.85 232.59,8.54 232.59,7.31 232.32,7.04 231.66,7.04
+5VBS_R on BOTTOM: 224.12,17.87 226.33,17.87 226.38,17.82 226.38,16.78 226.28,16.68 224.14,16.68 224.04,16.78 224.04,17.8
+5VS on BOTTOM (solid shape): 61.05,10.48 62.19,10.48 62.7,9.97 62.7,9.85 61.69,8.83 61.43,8.83 58.38,11.88 58.38,12.01 58.89,12.51 59.02,12.51
+5VS on BOTTOM: 42.02,4.61 43.29,5.88 43.36,5.88 43.56,6.08 43.56,6.67 43.22,7 41.67,7 40.59,5.92 40.59,4.84 40.82,4.61
+5VS on BOTTOM: 32.96,2.84 32.96,3.29 32.98,3.32 33.49,3.32 33.64,3.47 34.02,3.47 34.2,3.29 34.2,1.57 34.02,1.39 32.81,1.39 32.69,1.51 32.69,2.57
+5VS on IN3: 41.67,4.63 41.67,5.5 41.44,5.73 40.07,5.73 39.23,4.89 36.67,4.89 36.03,4.26 35.65,4.26 35.62,4.28 33.44,4.28 33.24,4.08 33.24,2.28 33.62,1.9 38.94,1.9
+5VS_AUDIO on BOTTOM: 255.49,58.74 255.49,59.63 255.61,59.76 255.61,60.27 255.74,60.39 258.03,60.39 258.28,60.65 258.28,61.79 258.15,61.92 254.98,61.92 254.73,61.66 254.73,60.52 254.34,60.14 253.46,60.14 253.33,60.01 253.33,57.47 253.58,57.22 256.25,57.22 256.38,57.35 256.38,58.49 256.25,58.62 255.61,58.62
+5VS_AUDIO_R on BOTTOM: 255.23,53.79 255.11,53.92 255.11,55.19 254.73,55.57 254.73,56.46 254.8,56.53 256.3,56.53 256.38,56.46 256.38,53.92 256.25,53.79
+5VS_FAN1 on BOTTOM (solid shape): 63.34,9.34 65.46,9.34 66.28,8.51 66.28,6.11 66,5.83 64.56,5.83 62.19,8.2 62.19,8.32 63.21,9.34 63.34,9.34
+5VS_R on BOTTOM (solid shape): 31.97,2.59 31.97,1.41 31.9,1.34 29.94,1.34 29.83,1.44 29.83,2.53 29.91,2.61 31.95,2.61
+8.4V_BATT+ on BOTTOM (solid shape): 75.28,20.43 74.89,20.04 74.89,19.57 75.36,19.57 75.75,19.96 76.13,19.58 76.13,19.3 75.16,18.33 73.61,18.33 73.37,18.09 73.37,17.39 73.22,17.24 72.64,17.24 71.51,16.11 71.05,16.11 70.68,15.74 70.68,14.6 70.5,14.42 62.7,14.42 62.57,14.55 62.57,16.2 62.7,16.32 62.7,18.36 62.82,18.48 68.52,19.23 73.89,21.28 74.43,21.28
+8.4V_BATT+ on IN1 (solid shape): 75.66,21.79 75.66,20.13 72.86,17.34 68.04,17.34 67.15,16.45 63.21,16.45 62.83,16.83 62.83,18.23 63.08,18.48 64.35,18.48 64.48,18.61 65.09,18.61 65.19,18.71 66.31,18.86 67.37,19.07 67.86,19.17 68.49,19.32 68.7,19.37 69.05,19.47 69.16,19.49 70.07,19.75 70.83,20.01 71.46,20.26 72.35,20.64 72.99,20.9 73.5,21.15 73.74,21.28 74.13,21.28 74.51,21.66 74.77,21.66 75.15,22.04 75.4,22.04
+8.4V_BATT+ on IN2 (solid shape): 76.16,21.28 76.16,19.75 73.01,16.6 67.34,16.6 67.34,16.6 67.22,16.6 66.96,16.34 63.21,16.34 62.83,16.72 62.83,18.23 63.08,18.48 64.35,18.48 64.48,18.61 65.09,18.61 65.19,18.71 66.31,18.86 67.37,19.07 67.86,19.17 68.49,19.32 68.7,19.37 69.05,19.47 69.16,19.49 70.07,19.75 70.83,20.01 71.46,20.26 72.35,20.64 72.99,20.9 73.5,21.15 74.03,21.43 75.15,22.03 75.41,22.03
+8.4V_BATT+ on IN3 (solid shape): 75.66,21.79 75.66,21.02 74.64,20.01 74.64,19.63 73.62,18.61 73.62,18.1 72.86,17.34 62.83,17.34 62.7,17.47 62.7,18.36 62.93,18.58 62.97,18.58 64.1,18.63 65.38,18.74 66.31,18.86 67.37,19.07 67.86,19.17 68.49,19.32 68.7,19.37 69.05,19.47 69.16,19.49 70.07,19.75 70.83,20.01 71.46,20.26 72.35,20.64 72.99,20.9 73.5,21.15 73.75,21.28 73.82,21.36 74.44,21.69 75.04,22.03 75.05,22.04 75.4,22.04
+DVDD on TOP: 258.41,57.22 258.41,56.2 258.28,56.08 257.14,56.08 257.01,56.2 257.01,56.58 256.88,56.71 256.38,56.71 255.74,57.35 255.74,58.11 255.61,58.23 255.23,58.23 255.11,58.11 255.11,56.2 256,55.31 258.79,55.31 258.92,55.44 258.92,57.22 258.79,57.35 258.54,57.35
+PVDD on TOP: 256.95,62.16 257.97,62.16 258.02,62.1 258.02,61.94 257.99,61.91 257.17,61.91 256.76,61.5 256.76,60.4 257.01,60.14 257.95,60.14 258.01,60.08 258.01,59.92 257.96,59.87 257.03,59.87 256.9,59.74 256.87,59.74 256.68,59.56 254.46,59.56 254.39,59.63 254.39,61.86 254.45,61.92 256.71,61.92
+PVDD on BOTTOM: 255.74,59.63 255.74,59 255.87,58.87 256.38,58.87 257.01,59.5 257.01,60.14 256.88,60.27 256.38,60.27 256.25,60.14 256.25,59.76 255.87,59.76
+VBATT on BOTTOM (solid shape): 55.53,19.46 58.51,18.79 61.55,18.49 61.69,18.36 61.69,17.59 61.94,17.34 61.94,16.71 62.07,16.58 62.07,13.91 61.94,13.78 59.88,13.78 58.89,12.8 58.8,12.8 58.26,13.34 58.26,15.28 57.53,16.01 57.53,17.05 57.06,17.53 55.75,17.53 55.38,17.9 55.38,19.32
+VBATT on IN1 (solid shape): 56.1,19.37 57.24,19.12 58.51,18.86 59.53,18.74 60.67,18.61 60.92,18.61 61.18,18.36 61.18,16.71 60.8,16.32 55.84,16.32 53.94,18.23 53.94,19.5 54.07,19.63 55.21,19.63
+VBATT on IN2 (solid shape): 55.06,19.61 58.27,18.83 61.55,18.49 62.07,17.98 62.07,16.89 61.72,16.55 55.62,16.55 53.94,18.23 53.94,19.5 54.04,19.61
+VBATT on IN3 (solid shape): 56.1,19.37 57.24,19.12 57.88,18.99 59.4,18.74 60.67,18.61 60.8,18.61 61.05,18.36 61.05,17.42 60.9,17.26 54.9,17.26 53.94,18.23 53.94,19.5 54.07,19.63 55.21,19.63
+VCC1.05_OUT_FET on TOP: 150.08,61.16 150.84,60.39 151.86,60.39 152.11,60.14 152.11,58.11 151.98,57.98 149.82,57.98 148.3,59.5 148.3,62.55 148.17,62.68 147.79,62.68 147.66,62.81 147.66,64.08 147.92,64.33 147.92,65.98 148.55,66.62 149.57,66.62 150.08,66.11
+VCC1.05_OUT_FET on BOTTOM: 149.7,65.09 153.25,65.09 153.38,65.22 153.38,66.74 153.25,66.87 150.97,66.87 150.84,67 150.84,67.63 150.71,67.76 148.93,67.76 148.81,67.63 148.81,65.22 149.19,64.84 149.44,64.84
+VCC1.05_OUT_FET on BOTTOM: 152.22,58.73 152.36,58.87 152.69,58.87 152.74,58.82 152.74,58.62 152.11,57.98 150.99,57.98 150.89,58.08 150.89,58.67 150.95,58.73
+VCC1.05_OUT_PCH on BOTTOM: 163.92,45.28 163.92,44.26 164.05,44.14 164.94,44.14 165.06,44.26 165.06,45.28 164.94,45.41 164.05,45.41
+VCC1P8A on BOTTOM (solid shape): 147.41,55.34 147.35,55.28 147.32,55.29 147.01,55.19 147.03,54.86 147.04,54.81 146.99,54.78 146.91,54.78 146.9,54.79 146.78,54.82 146.66,54.79 146.64,54.78 146.56,54.78 146.51,54.81 146.52,54.86 146.32,55.31 146.12,54.86 146.12,54.81 146.08,54.78 145.99,54.78 145.98,54.79 145.86,54.82 145.74,54.79 145.73,54.78 145.64,54.78 145.6,54.81 145.61,54.86 145.59,55.23 145.22,55.24 145.17,55.23 145.14,55.27 145.14,55.38 145.2,55.44 147.31,55.44
+VCC1P8A on BOTTOM (solid shape): outline of 236 points within 144.88,57.96 150.78,62.29
+VCC1P8A on IN3 (solid shape): 150.54,58.37 150.54,58.11 149.82,57.39 149.82,56.94 147.56,54.68 145.17,54.68 145.08,54.77 145.08,55.79 145.22,55.93 146.82,55.93 147.04,56.15 147.04,56.52 147.67,57.15 147.67,57.57 148.69,58.59 150.32,58.59
+VCC1P8A_R on BOTTOM: 143.22,63.31 142.58,63.95 142.58,66.11 142.71,66.24 143.6,66.24 143.73,66.11 143.73,64.84 144.49,64.08 144.49,61.28 144.36,61.16 143.35,61.16 143.22,61.28
+VCC3V3_TBT_L_LDO on TOP (solid shape): 35.27,33.85 35.27,32.83 35.14,32.71 34,32.71 33.87,32.83 33.87,33.83 34,33.95 35.17,33.95
+VCC3V3_TBT_L_LDO on BOTTOM (solid shape): 27.56,33.17 27.56,31.84 28.45,30.95 28.45,30.44 28.39,30.38 27.88,30.38 27.82,30.44 27.82,30.76 27.24,31.33 27.24,33.17 27.31,33.23 27.5,33.23
+VCC3V3_TBT_L_LDO on BOTTOM (solid shape): 23.25,32.56 23.25,31.69 23.2,31.64 22.57,31.64 22.49,31.56 22.49,31.03 22.92,30.6 22.92,30.37 22.8,30.24 22.42,30.24 22.06,30.6 22.06,31.92 22.21,32.07 22.7,32.07 22.75,32.12 22.75,32.53 22.8,32.58 23.23,32.58
+VCC3V3_TBT_R_LDO on TOP (solid shape): 263.16,35.45 263.16,33.67 262.59,33.1 262.59,32.78 262.52,32.72 262.01,32.72 261.95,32.78 261.95,33.84 262.22,34.1 262.6,34.1 262.84,34.35 262.84,35.44 262.9,35.5 263.11,35.5
+VCC3V3_TBT_R_LDO on BOTTOM: 245.56,12.31 249.54,12.31 249.7,12.16 249.7,11.88 249.44,11.63 245.63,11.63 245.45,11.8 245.45,12.21
+VCC3V3_TBT_R_LDO on IN3: 245.91,13.28 245.33,13.28 245.07,13.02 245.07,11.8 245.33,11.55 245.99,11.55 246.09,11.65 246.09,13.1
+VCC_SFR_OC on BOTTOM: 154.01,41.22 154.65,41.22 154.78,41.09 154.78,40.33 156.55,38.55 156.55,34.74 155.72,33.91 155.72,32.43 155.62,32.33 154.65,32.33 154.14,31.82 153.23,31.82 152.72,31.31 151.6,31.31 151.6,32.07 151.83,32.3 152.97,32.3 153,32.33 153,32.71 153.13,32.83 153.25,32.83 153.38,32.96 153.38,33.6 154.27,34.49 154.27,34.99 154.52,35.25 154.52,36.14 154.27,36.39 154.27,37.28 153.89,37.66 153.89,41.09
+VCC_SFR_OC_R on BOTTOM: 150.46,30.93 150.46,29.53 150.59,29.41 150.94,29.41 151.45,29.91 152.49,29.91 152.62,30.04 152.62,30.93 152.49,31.06 150.59,31.06
+VCCA_CLKLDO_1P8 on BOTTOM: 170.41,52.08 170.27,51.95 170.27,51.78 170.4,51.65 170.4,51.66 171.92,51.66 172.86,50.72 173.92,50.72 174.17,50.46 174.17,47.45 174.21,47.41 174.7,47.41 175.1,47.01 175.73,47.01 175.76,47.04 175.76,47.85 175.43,48.18 175.43,50.64 175.02,51.05 175.02,51.26 174.73,51.55 174.44,51.55 174.44,51.53 174.34,51.43 173.03,51.43 172.38,52.08
+VCCIN on BOTTOM (solid shape): outline of 264 points within 130.52,52.01 133.44,53.66
+VCCIN on BOTTOM (solid shape): outline of 941 points within 147.54,53.23 155.97,55.44
+VCCIN on BOTTOM (solid shape): outline of 973 points within 149.57,41.6 159.98,43.76
+VCCIN on BOTTOM (solid shape): outline of 2442 points within 104.23,30.8 127.47,54.3
+VCCIN on TOP: 150.08,41.85 148.93,42.99 140.68,42.99 139.03,44.65 126.58,44.65 125.95,45.28 124.42,45.28 123.53,44.39 123.53,42.87 119.98,39.31 112.61,39.31 111.09,37.79 111.09,32.45 110.71,32.07 105.75,32.07 105.37,32.45 105.37,41 105.45,41.08 106.68,41.08 106.8,41.19 106.8,43.4 107.79,44.39 107.79,47.72 108.37,48.3 108.4,48.3 108.42,48.28 111.6,48.28 111.88,48.56 111.88,49.47 113.15,50.74 120.36,50.74 121.25,51.63 130.39,51.63 130.65,51.88 130.65,52.39 130.9,52.65 132.17,52.65 132.3,52.77 132.3,53.54 132.42,53.66 135.27,53.66 135.5,53.43 135.5,52.19 135.68,52.01 137.3,52.01 138.29,51.02 140.83,51.02 142.58,52.77 145.76,52.77 146.27,53.28 146.27,55.31 146.52,55.57 150.71,55.57 151.35,54.93 152.87,54.93 153.13,54.68 154.65,54.68 155.54,53.79 155.54,52.65 155.41,52.52 154.9,52.52 154.65,52.27 154.01,52.27 153.89,52.14 153.89,45.15 154.01,45.03 154.65,45.03 154.78,44.9 154.78,44.26 154.9,44.14 158.59,44.14 158.71,44.26 158.71,44.9 158.84,45.03 159.86,45.03 160.11,44.77 160.11,42.49 159.98,42.36 153.76,42.36 153.25,41.85
+VCCIN on IN1: 105.63,32.07 105.25,32.45 105.25,52.01 105.84,52.61 114.83,52.61 115.83,53.6 118.01,53.6 119.22,52.39 119.85,52.39 120.99,51.25 123.66,51.25 124.42,50.49 125.57,50.49 125.95,50.87 125.95,52.65 126.46,53.15 129.63,53.15 130.27,53.79 133.44,53.79 133.82,54.17 155.92,54.17 157.7,52.39 157.7,45.84 156.45,44.59 156.45,42.21 156.22,41.98 141.57,41.98 138.77,44.77 127.83,44.77 127.32,44.26 122.39,44.26 117.44,39.31 113.12,39.31 113.09,39.29 112.38,39.29 110.88,37.79 110.88,34.82 111.98,33.72 111.98,32.33 111.72,32.07
+VCCIN on VCC: 105.99,31.69 105.12,32.56 105.12,52.29 107.38,54.55 118.81,54.55 124.27,60.01 132.32,60.01 132.81,59.53 132.81,53.3 133.97,52.14 144.59,52.14 148.02,55.57 154.67,55.57 155.67,54.57 155.67,52.67 156.32,52.01 161.76,52.01 161.76,42.59 161.02,41.85 150.18,41.85 148.79,43.25 124.32,43.25 112.76,31.69
+VCCIN on IN2: 106.64,54.42 146.52,54.42 148.05,55.95 149.88,55.95 150.06,55.77 151.51,55.77 152.31,54.97 154.97,54.97 160.24,49.7 160.24,42.49 159.73,41.98 149.7,41.98 148.93,42.74 116.17,42.74 112.1,38.68 112.1,31.95 111.47,31.31 102.07,31.31 100.8,32.58 100.8,48.58
+VCCIN on IN3: 137.12,49.98 159.73,49.98 160.11,49.6 160.11,42.36 159.98,42.23 153.38,42.23 153.13,41.98 149.82,41.98 149.06,42.74 134.2,42.74 133.31,43.63 129.63,43.63 128.36,42.36 124.8,42.36 123.28,43.88 118.96,43.88 114.52,39.44 112.99,39.44 111.34,37.79 111.34,34.99 111.98,34.36 111.98,31.82 111.72,31.56 106.14,31.56 105.37,32.33 105.37,47.44 107.15,49.22 121.25,49.22 121.76,48.71 123.28,48.71 124.04,47.95 124.7,47.95 124.83,47.82 134.96,47.82
+VCCIN_AUX on TOP (solid shape): 191.1,60.27 191.1,55.31 190.21,54.42 188.56,54.42 182.21,60.77 182.21,65.09 183.86,66.74 184.62,66.74
+VCCIN_AUX on BOTTOM (solid shape): outline of 163 points within 128.23,52.01 130.39,53.54
+VCCIN_AUX on BOTTOM (solid shape): outline of 429 points within 139.28,53.23 142.94,55.34
+VCCIN_AUX on BOTTOM (solid shape): outline of 688 points within 156.05,52.9 164.56,54.81
+VCCIN_AUX on TOP: 154.78,58.87 160.75,58.87 160.87,59 160.87,59.63 159.42,61.08 154.7,61.08 154.4,60.77 154.4,59.25
+VCCIN_AUX on TOP: 142.2,55.19 142.2,55.82 142.33,55.95 142.84,55.95 142.97,55.82 142.97,54.04 140.93,52.01 139,52.01 138.72,51.73 138.27,51.73 138.01,51.99 138.01,54.07 137.73,54.35 137.73,54.86 137.81,54.93 141.95,54.93
+VCCIN_AUX on TOP: 137.25,59.25 136.74,59.76 136.74,60.59 136.45,60.88 136.45,61.37 136.62,61.54 141.38,61.54 141.38,61.54 141.49,61.54 141.59,61.44 141.59,59.56 141.28,59.25
+VCCIN_AUX on TOP: 155.54,54.81 156.94,54.81 157.19,54.55 157.82,54.55 158.08,54.81 162.65,54.81 163.03,54.42 163.03,52.14 162.9,52.01 158.84,52.01 158.46,52.39 157.82,52.39 157.57,52.14 157.23,52.14 156.86,51.77 155.88,51.77 155.77,51.89 155.77,52.58 156.28,52.58 156.3,52.6 156.3,53.79 156.17,53.92 155.67,53.92 155.41,54.17 155.41,54.68
+VCCIN_AUX on TOP: 129.25,53.28 129.5,53.54 130.01,53.54 130.14,53.41 130.14,52.01 130.01,51.88 127.6,51.88 127.47,52.01 127.47,53.15 127.6,53.28
+VCCIN_AUX on BOTTOM: 135.6,60.27 135.6,58.87 135.73,58.74 138.27,58.74 138.52,59 138.52,59.12 140.43,61.03 140.43,62.81 140.3,62.93 139.79,62.93 138.65,61.79 136.36,61.79 136.23,61.66 136.23,60.9
+VCCIN_AUX on BOTTOM: 185,66.36 192.05,59.31 192.05,58.36 190.59,56.9 190.59,51.82 189.64,50.87 189.38,50.87 183.03,57.22 183.03,58.11 181.1,60.04 181.1,60.43 181.7,61.03 181.7,61.79 182.21,62.3 182.21,64.97 181.83,65.35 181.83,65.85 180.94,66.74 180.94,67.12 181.7,67.89 182.34,67.89 183.86,66.36
+VCCIN_AUX on VCC: 156.53,52.52 156.17,52.88 156.17,54.78 154.88,56.08 147.81,56.08 144.38,52.65 134.18,52.65 133.31,53.51 133.31,67.99 175.55,67.99 175.56,67.99 176.98,68.63 177.61,70.05 177.62,70.05 177.62,71.89 183.05,71.89 183.06,71.89 183.95,72.22 184.52,72.99 187.25,72.99 187.26,72.99 188.68,73.63 189.31,75.05 189.32,75.05 189.32,75.58 191.86,75.58 191.86,52.52
+VCCIN_AUX on GND3: 127.93,51.71 127.41,52.23 127.47,52.29 127.47,67.53 127.96,68.01 176.34,68.01 177.64,69.31 177.64,71.64 177.79,71.8 183.71,71.8 184.88,72.97 188.03,72.97 189.32,74.26 189.32,75.51 191.99,75.51 191.99,53.13 191.23,52.37 191.23,52.19 191.17,52.14 170.65,52.14 170.5,51.99 168.14,51.99 167.99,52.14 166.82,52.14 166.18,52.77 164.96,52.77 164.43,53.31 156.61,53.28 156.05,53.84 156.05,54.73 154.83,55.95 147.74,55.95 145.1,53.31 138.85,53.31 138.42,52.88 135.55,52.88 135.32,52.65 134.2,52.65 133.24,51.71
+VCCPRIM_1P8 on BOTTOM (solid shape): 178.4,50.49 178.4,49.6 178.27,49.47 177.76,49.47 177.38,49.85 177.38,50.49 177.51,50.61 178.27,50.61
+VCCPRIM_1P8 on BOTTOM (solid shape): outline of 515 points within 162.14,48.33 165.19,52.39
+VCCPRIM_1P8 on IN3 (solid shape): 180.18,50.74 180.18,50.11 179.54,49.47 177.76,49.47 177.38,49.85 177.38,51.12 177.51,51.25 179.67,51.25
+VCCPRIM_1P8 on TOP: 162.29,48.25 162.23,48.32 162.23,51.24 162.29,51.3 163.31,51.3 163.44,51.17 163.44,48.38 163.31,48.25
+VCCPRIM_1P8 on VCC: 174.95,43.88 174.19,44.65 162.27,44.65 162.27,52.01 180.43,52.01 180.43,46.02 180.2,45.79 176.9,45.79 176.37,45.26 176.37,43.88
+VCCPRTC_3P3 on TOP: 165.32,43.63 171.79,43.63 172.05,43.38 174.46,43.38 174.59,43.25 174.59,42.74 174.46,42.61 165.32,42.61 165.19,42.74 165.19,43.5
+VCCST_CPU on BOTTOM (solid shape): 151.67,62.61 151.67,60.92 152.21,60.37 152.21,58.97 152.09,58.85 151.85,58.85 151.78,58.91 151.78,60.09 151.15,60.72 151.15,62.6 151.2,62.65 151.63,62.65
+VCCST_CPU on TOP: 152.24,61.79 152.11,61.92 152.11,62.3 152.49,62.68 152.49,63.44 152.62,63.57 154.27,63.57 154.34,63.51 154.34,61.86 154.27,61.79
+VCCST_CPU on IN3: 151.22,62.55 151.22,61.79 151.35,61.66 153.25,61.66 153.38,61.79 153.38,62.55 153.25,62.68 151.35,62.68
+VCCST_R on TOP: 150.2,63.82 150.2,62.3 150.33,62.17 151.6,62.17 151.98,62.55 151.98,63.82 151.86,63.95 150.33,63.95
+VCCSTG_CPU on BOTTOM (solid shape): 151.22,63.95 151.22,62.93 150.98,62.69 150.98,60.63 151.6,60.01 151.6,58.89 151.57,58.85 151.31,58.85 151.24,58.92 151.24,58.94 151.24,59.61 150.47,60.38 150.47,62.66 150.44,62.69 150.44,64.01 150.51,64.08 151.09,64.08
+VCCSTG_OUT on TOP: 127.69,43.88 132.42,43.88 132.55,43.76 132.55,42.87 132.42,42.74 124.17,42.74 124.04,42.87 124.04,44.26 124.17,44.39 125.57,44.39 125.87,44.7 126.88,44.7
+VCCSTG_OUT on BOTTOM: 132.93,43.63 133.06,43.5 133.06,42.87 132.17,41.98 129.12,41.98 128.87,42.23 128.87,43.38 129.12,43.63
+VCCSTG_OUT on BOTTOM: 125.57,43.76 125.57,43.5 125.44,43.38 124.68,43.38 124.17,43.88 124.17,44.01 124.3,44.14 125.19,44.14
+VCCSTG_R on BOTTOM: 149.19,64.97 151.22,64.97 151.35,64.84 151.35,64.46 151.22,64.33 150.2,64.33 149.82,63.95 149.82,62.93 149.7,62.81 148.93,62.81 148.68,63.06 148.68,64.46
+VDDQ_MEM on TOP: outline of 296 points within 101.82,6.93 169.25,28.64 ; 2 cut-outs
+VDDQ_MEM on BOTTOM: 102.58,21.02 102.83,20.77 107.41,20.77 107.53,20.9 107.53,23.18 107.41,23.31 102.71,23.31 102.58,23.18
+VDDQ_MEM on VCC: 108.42,8.32 108.42,18.84 106.14,21.13 106.14,24.22 107.89,25.98 118.18,25.98 120.46,28.26 160.77,28.26 161.53,27.5 162.63,27.5 163.39,28.26 165.97,28.26 169.51,24.73 169.51,9.21 112.38,9.21 111.49,8.32 ; 2 cut-outs
+VSS_PLL on TOP (solid shape): 175.54,18.22 176.59,18.22 176.92,17.89 176.92,17.66 176.83,17.58 175.2,17.58 175,17.78 173.24,17.78 173.14,17.88 173.14,18.83 173.19,18.88 174.88,18.88
AGND on BOTTOM: 268.45,68.83 268.45,69.77 268.36,69.86 267.49,69.86 266.16,68.52 264.44,68.52 264.38,68.46 264.38,67.19 266.02,65.55 269.2,65.55 269.3,65.65 269.3,67.98
AGND on GND1, GND2, GND3, GND4: 267.15,61.49 266.95,61.69 266.03,61.69 265.55,62.17 263.34,62.17 263.23,62.28 263.23,63.67 262.7,64.2 258.43,64.2 258.03,63.8 258.03,62.91 257.67,62.55 255.34,62.55 255.12,62.78 255.12,65.38 255.72,65.98 256.86,65.98 258.79,67.91 258.79,69.18 259.49,69.88 263.68,69.88 263.93,69.62 263.93,68.86 264.27,68.52 266.13,68.52 267.49,69.88 268.19,69.88 268.38,69.69 268.38,68.86 269.08,68.16 269.08,65.88 269.42,65.54 271.78,65.54 272.12,65.88 272.12,68.61 272.48,68.97 276.02,68.97 276.57,68.42 276.57,67.1 276.32,66.85 276.32,65.71 275.81,65.2 275.81,62.43 274.86,61.49
AGND on VCC: 267.15,61.49 266.95,61.69 266.03,61.69 265.55,62.17 263.34,62.17 263.23,62.28 263.23,63.67 262.7,64.2 258.43,64.2 258.03,63.8 258.03,62.91 257.67,62.55 255.34,62.55 255.12,62.78 255.12,62.89 255.12,65.38 255.72,65.98 256.86,65.98 258.79,67.91 258.79,69.18 259.49,69.88 263.68,69.88 263.93,69.62 263.93,68.86 264.27,68.52 266.13,68.52 267.49,69.88 268.19,69.88 268.38,69.69 268.38,68.86 269.08,68.16 269.08,65.88 269.42,65.54 271.78,65.54 272.12,65.88 272.12,68.61 272.48,68.97 276.02,68.97 276.57,68.42 276.57,67.1 276.32,66.85 276.32,65.71 275.81,65.2 275.81,62.43 274.86,61.49
DV12S on BOTTOM (solid shape): 13.2,47.04 13.2,45.17 12.88,44.85 12.88,44.38 12.84,44.34 12.84,43.53 12.8,43.49 12.65,43.49 12.61,43.53 12.61,44.45 12.66,44.5 12.66,46.62 12.31,46.97 12.31,47.29 12.37,47.35 12.88,47.35
DV12S on BOTTOM (solid shape): 10.1,46.32 10.1,46.06 10.15,46.01 10.15,45.89 10.4,45.64 10.4,45.45 11.23,44.62 11.23,43.54 11.16,43.48 11.04,43.48 10.97,43.54 10.97,44.43 10.59,44.81 9.89,44.81 9.83,44.88 9.83,45.5 9.63,45.7 9.21,46.12 9.21,46.61 9.28,46.68 9.74,46.68
DV33_18 on BOTTOM (solid shape): 15.99,43.37 15.99,42.93 15.93,42.86 15.45,42.86 15.23,42.64 14.72,42.64 14.58,42.78 13.77,42.78 13.72,42.83 13.72,42.97 13.78,43.04 14.59,43.04 14.69,43.13 14.93,43.13 15.24,43.44 15.93,43.44
GND on TOP (solid shape): 199.49,55.15 191.49,55.15 191.49,63.15 199.49,63.15
GND on TOP (solid shape): 133.06,51.12 133.06,50.36 132.93,50.23 131.41,50.23 131.28,50.36 131.28,51.12 131.41,51.25 132.93,51.25
GND on TOP (solid shape): 199.86,69.03 199.86,67.38 198.85,66.36 197.25,66.36 196.87,66.74 196.87,68.47 197.62,69.22 199.67,69.22
GND on TOP (solid shape): 205.58,49.85 205.58,45.66 205.45,45.53 204.99,45.53 204.81,45.71 204.81,46.37 204.61,46.58 204,46.58 203.8,46.78 203.8,49.98 203.93,50.11 205.32,50.11
GND on TOP (solid shape): 119.61,52.79 120.07,52.79 120.23,52.63 120.23,51.38 119.73,50.88 115.37,50.88 115.3,50.95 115.3,51.62 115.64,51.95 117.51,51.95 118.45,52.9 119.49,52.9
GND on TOP (solid shape): 263.56,33.25 263.56,31.12 263.51,31.07 262.88,31.07 262.88,31.79 262,31.79 261.94,31.86 261.94,32.62 262.56,32.62 262.69,32.74 262.69,33.06 262.95,33.32 263.5,33.32
GND on TOP (solid shape): 194.57,74.73 194.94,74.28 195.35,73.86 196.36,72.84 196.36,72.07 194.27,69.98 194.02,69.98 193.38,70.62 193.38,71.85 192.67,72.56 192.67,73.04 194.36,74.73
GND on TOP (solid shape): 23.41,0.25 18.01,0.25 17.48,0.47 17.26,1 17.26,6.1 23.41,6.1
GND on TOP (solid shape): 275.63,1 275.42,0.47 274.89,0.25 268.5,0.25 268.5,6.1 275.63,6.1
GND on TOP (solid shape): 205.76,63.72 205.76,58.82 205.2,58.26 203.13,58.26 202.68,58.71 202.68,59.91 204,61.23 204,61.34 204.46,61.8 204.06,62.2 203.6,61.74 203.49,61.74 202.33,60.57 201.01,59.25 200.78,59.49 200.78,61.94 201.28,62.45 201.66,62.45 203.68,64.46 205.01,64.46
GND on TOP (solid shape): 24.12,8.13 24.12,0.69 23.69,0.25 18.01,0.25 17.45,0.49 17.21,1.05 17.21,8.46 23.79,8.46
GND on TOP (solid shape): 20.3,35.46 20.3,34.4 20.29,34.39 20.29,34.36 20.25,34.32 16.63,34.32 16.31,34.01 16.31,30.86 16.16,30.89 16.01,30.9 10.51,30.9 9.95,31.14 9.71,31.7 9.71,35.68 9.71,35.78 9.7,35.88 19.88,35.88
GND on TOP (solid shape): 136.98,21.73 137,21.68 137.02,21.68 137.02,21.56 137.51,21.07 137.51,20.25 137.5,20.25 136.97,20.25 136.77,20.04 136.61,20.04 136.57,20.08 136.58,20.13 136.66,20.22 136.69,20.22 136.69,20.24 136.7,20.25 136.7,21.54 136.65,21.59 136.64,21.64 136.69,21.68 136.73,21.68 136.83,21.69 136.93,21.73
GND on TOP (solid shape): 12.4,84.4 12.93,84.18 13.15,83.65 13.15,81.15 13.11,81.15 13.11,81.02 13.05,80.96 12.86,80.96 12.77,81.05 12.77,81.15 11.45,81.15 10.39,81.59 9.95,82.65 9.95,84.4
GND on TOP (solid shape): 91.73,56.93 91.73,51.96 88.21,48.44 88.21,47.92 88.16,47.87 88.16,41.67 88.21,41.62 88.21,41.19 90.34,39.06 90.34,31.4 89.54,30.61 87.03,33.11 86.73,33.11 86.53,32.91 86.53,32.61 89.03,30.1 88.92,29.98 83.24,29.98 82.54,30.68 82.56,30.71 85.24,36.73 86.15,43.25 86.15,57.92 90.74,57.92
GND on TOP (solid shape): 29.51,58.9 29.51,57.92 29.19,57.6 27.27,57.6 27.04,57.37 27.04,56.67 25.87,56.67 25.87,57.14 26.2,57.48 26.2,57.54 26.37,57.7 26.4,57.68 26.78,57.97 26.31,58.03 26.29,58.01 26.24,58 26.2,58.05 26.2,58.83 26.38,59 27.65,59 27.65,59 29.41,59
GND on TOP (solid shape): 94.71,4.95 100,4.95 100.49,4.46 100.49,2.93 100.97,2.45 104.69,2.45 104.85,2.3 104.85,0.25 94.71,0.25 93.51,0.25 92.95,0.49 92.71,1.05 92.71,3 92.36,3.85 91.51,4.2 87.51,4.2 87.17,4.15 86.86,4.01 86.86,4.97 94.71,4.97
GND on TOP (solid shape): 254.08,63.4 254.19,63.42 254.25,63.33 254.25,59.68 254.19,59.58 254.07,59.61 253.58,59.58 253.67,59.09 253.67,58.77 253.63,58.29 254.1,58.36 254.25,58.36 254.25,53.88 253.57,53.2 251.71,53.2 251.7,53.23 250.62,55.14 249.35,56.95 249.06,57.89 249.47,58.79
GND on TOP (solid shape): outline of 94 points within 257.65,37.51 266.84,43.02
GND on TOP (solid shape): outline of 179 points within 268.72,48.05 284.62,69.97
GND on TOP (solid shape): outline of 349 points within 162.75,0.2 275.69,28.82
GND on TOP (solid shape): outline of 239 points within 0.2,0.2 292.7,56.98
GND on TOP (solid shape): outline of 150 points within 32.85,19.09 278.05,76.55
GND on TOP (solid shape): outline of 396 points within 0.2,0.25 292.7,84.45
GND on BOTTOM (solid shape): 142.4,0.05 137.4,0.05 137.35,0.05 136.4,0.05 136.4,5.65 142.4,5.65
GND on BOTTOM (solid shape): 90.51,41.22 90.51,38.11 90.45,38.04 87.21,38.04 87.15,38.11 87.15,41.15 87.28,41.28 90.45,41.28
GND on BOTTOM (solid shape): 92.42,24.45 92.42,23.31 92.29,23.18 91.4,23.18 91.28,23.31 91.28,24.45 91.4,24.58 92.29,24.58
GND on BOTTOM (solid shape): 92.42,22.17 92.42,20.26 92.29,20.13 91.02,20.13 90.51,20.64 90.51,22.42 90.64,22.55 92.04,22.55
GND on BOTTOM (solid shape): 94.32,19.5 94.32,16.07 94.2,15.94 92.29,15.94 92.17,16.07 92.17,19.63 92.42,19.88 93.94,19.88
GND on BOTTOM (solid shape): 101.94,22.8 101.94,22.04 101.82,21.91 99.35,21.91 99.15,22.12 99.15,22.78 99.3,22.93 101.82,22.93
GND on BOTTOM (solid shape): 104.97,39.69 104.97,38.55 104.89,38.47 104.05,38.47 103.93,38.6 103.93,39.64 104,39.72 104.94,39.72
GND on BOTTOM (solid shape): 106.2,29.79 106.2,28.83 106.14,28.77 104.99,28.77 104.87,28.9 104.87,29.72 104.99,29.85 106.14,29.85
GND on BOTTOM (solid shape): 185.79,68.17 185.79,67.89 184.49,66.59 184.32,66.59 182.72,68.19 182.72,68.6 183.91,69.79 184.16,69.79
GND on BOTTOM (solid shape): 198.87,47.46 198.87,44.95 198.79,44.87 198.21,44.87 198.11,44.98 198.11,47.72 198.24,47.85 198.49,47.85
GND on BOTTOM (solid shape): 204.81,75.19 204.81,73.35 204.69,73.22 201.32,73.22 201.19,73.35 201.19,75.25 201.32,75.38 204.62,75.38
GND on BOTTOM (solid shape): 205.58,49.85 205.58,45.53 205.45,45.41 203.86,45.41 203.73,45.53 203.73,49.92 203.93,50.11 205.32,50.11
GND on BOTTOM (solid shape): 152.36,62.57 152.95,62.57 152.95,60.97 152.91,60.93 151.81,60.93 151.78,60.96 151.78,62.61 151.83,62.66 152.36,62.66
GND on BOTTOM (solid shape): 85.94,19.37 85.94,15.92 85.87,15.84 84.65,15.84 84.55,15.94 84.55,19.37 84.67,19.5 85.82,19.5
GND on BOTTOM (solid shape): 190.02,70.05 190.02,69.98 189.26,69.22 189.19,69.22 188.88,69.54 188.62,69.54 188.43,69.73 188.43,69.86 189,70.43 189.64,70.43
GND on BOTTOM (solid shape): 33.45,44.32 19.25,44.32 19.25,44.92 32.85,44.92 32.85,61.32 19.85,61.32 19.85,44.92 19.25,44.92 19.25,61.92 33.45,61.92
GND on BOTTOM (solid shape): 27.71,30.72 27.71,30.4 27.84,30.28 28.41,30.28 28.46,30.22 28.46,29.51 27.67,28.72 26.89,28.72 26.84,28.77 26.84,30.85 27.58,30.85
GND on BOTTOM (solid shape): 193.38,50.74 193.38,50.49 192.62,49.73 192.62,49.6 192.5,49.47 191.54,49.47 191.48,49.54 191.48,50.23 191.99,50.74 192.88,50.74 193,50.87 193.26,50.87
GND on BOTTOM (solid shape): 204.18,63.19 204.18,62.93 201.13,59.89 200.93,59.89 200.72,60.09 200.72,60.22 200.05,60.9 200.05,61.02 202.41,63.39 202.71,63.39 203.14,63.82 203.54,63.82
GND on BOTTOM (solid shape): 98.13,13.15 98.13,8.07 98.01,7.94 97.37,7.94 96.1,9.21 96.1,10.86 96.23,10.99 97.5,10.99 97.63,11.12 97.63,13.15 97.75,13.28 98.01,13.28
GND on BOTTOM (solid shape): 194.15,50.49 194.15,48.96 193.64,48.46 193.64,46.17 193.51,46.04 193.07,46.04 192.94,46.17 192.94,46.32 192.5,46.77 192.5,48.2 192.88,48.58 192.88,49.73 193.77,50.61 194.02,50.61
GND on BOTTOM (solid shape): 199.86,69.03 199.86,67.38 198.85,66.36 197.4,66.36 196.05,67.71 195.82,67.71 195.25,67.14 194.9,67.14 194.8,67.24 194.8,67.36 195.9,68.46 196.86,68.46 197.62,69.22 199.67,69.22
GND on BOTTOM (solid shape): 198.13,64.23 198.13,63.58 198.41,63.3 198.41,63 199.34,62.07 199.34,61.97 199.16,61.79 199.04,61.79 197.51,63.31 197.32,63.31 197.13,63.51 197.13,63.96 197.73,64.56 197.8,64.56
GND on BOTTOM (solid shape): 28.11,27.8 28.11,27.45 28.03,27.37 28.03,27.37 26.57,27.37 26.32,27.12 26.32,22.7 26.22,22.6 25.69,22.6 25.57,22.71 25.57,24.6 25.41,24.75 25.41,27.8 25.49,27.88 28.03,27.88
GND on BOTTOM (solid shape): 148.07,62.68 150.23,62.68 150.36,62.55 150.36,60.98 150.31,60.93 149.87,60.93 149.82,60.98 149.82,61.66 149.62,61.87 147.99,61.87 147.65,62.2 146.02,62.2 145.94,62.29 145.94,62.83 146.06,62.96 147.79,62.96
GND on BOTTOM (solid shape): 205.94,39.64 206.09,38.74 206.27,37.85 206.27,36.45 206.02,36.2 205.58,36.2 205.45,36.33 205.45,37.3 205.32,37.43 205.02,37.43 204.81,37.64 204.81,39.69 204.88,39.76 205.83,39.76
GND on BOTTOM (solid shape): 274.55,44.3 256.95,44.3 256.95,44.9 273.95,44.9 273.95,57.9 257.55,57.9 257.55,44.9 256.95,44.9 256.95,49.42 256.88,49.5 256.6,49.5 256.53,49.57 256.53,49.73 256.6,49.8 256.9,49.8 256.95,49.85 256.95,58.5 274.55,58.5
GND on BOTTOM (solid shape): 21.81,54.82 21.81,53.8 21.71,53.71 21.02,53.71 20.79,53.48 20.79,50.59 20.94,50.44 22.39,50.44 22.57,50.26 22.57,49.57 22.44,49.45 20.61,49.45 20.41,49.65 20.41,54.68 20.68,54.96 21.66,54.96
GND on BOTTOM (solid shape): 95.24,34.13 95.24,32.63 95.57,32.3 97.14,32.3 98.01,31.44 98.01,29.91 97.8,29.71 93.66,29.71 93.38,29.99 93.37,29.99 93.37,31.37 91.97,32.78 91.97,33.46 92.06,33.55 92.88,33.55 93.61,34.29 95.08,34.29
GND on BOTTOM (solid shape): 95.29,43.74 95.29,42.17 95.42,42.04 97.18,42.04 98.13,41.09 98.13,39.44 97.88,39.18 93.82,39.18 93.59,39.41 93.59,42.08 93.05,42.61 92.11,42.61 91.99,42.74 91.99,43.4 92.09,43.5 93.31,43.5 93.69,43.88 95.14,43.88
GND on BOTTOM (solid shape): 24.78,54.04 25.16,54.04 25.16,54.04 25.29,54.04 25.46,54.22 25.73,54.22 25.8,54.15 25.79,54.08 25.8,54.04 25.8,53.69 25.79,53.63 25.8,53.55 25.75,53.5 23.67,53.5 23.43,53.74 23.43,54.22 23.46,54.25 24.58,54.25
GND on BOTTOM (solid shape): 265.65,51.07 265.65,50.47 265.56,50.38 265.22,50.38 264.71,49.88 263.83,49.88 263.7,49.75 263.7,49.43 263.46,49.19 262.78,49.19 262.42,48.84 262.42,48.18 262.22,47.98 261.51,47.98 261.34,48.15 261.34,48.93 261.89,49.49 261.89,50.6 262.13,50.84 264.73,50.84 264.81,50.91 264.81,50.91 264.9,51.01 264.91,51.01 265.03,51.13 265.6,51.13
GND on BOTTOM (solid shape): 93.64,57.98 93.64,55.65 94.49,54.81 98.52,54.81 99.02,54.3 101.69,54.3 102.2,54.81 109.95,54.81 110.32,55.18 110.79,55.18 111.38,55.77 111.38,56.24 112.1,56.96 118.2,56.96 118.33,56.84 118.33,54.93 118.07,54.68 111.98,54.68 111.34,54.04 111.34,53.15 111.09,52.9 105.25,52.9 104.87,52.52 104.87,47.19 104.74,47.06 103.34,47.06 103.21,47.19 103.21,51.5 102.83,51.88 90.66,51.88 89.12,50.34 89.12,45.22 88.93,45.03 87.29,45.03 86.82,45.5 86.82,57.8 87.81,58.78 92.84,58.78
GND on BOTTOM (solid shape): 194.85,75.17 194.85,74.38 195.82,73.44 196.94,72.7 196.94,72.65 196.92,72.65 194.73,70.46 194.73,69.69 193.57,68.52 193.39,68.52 193.3,68.61 193.3,68.79 193.68,69.17 193.68,69.18 193.92,69.42 193.92,70.03 193.46,70.49 193.46,70.94 193.62,71.11 193.62,71.61 192.7,72.53 192.7,73 193.03,73.33 193.03,74.75 192.92,74.86 192.2,74.86 191.99,74.65 191.16,74.65 190.97,74.83 190.97,75.44 191.11,75.58 194.44,75.58
GND on BOTTOM (solid shape): 12.4,84.4 12.93,84.18 13.15,83.65 13.15,81.15 13.1,81.15 13.1,81.07 13.01,80.97 12.86,80.97 12.76,81.07 12.76,81.15 11.45,81.15 10.39,81.59 9.95,82.65 9.95,84.4
GND on BOTTOM (solid shape): 16.31,52.19 16.96,51.54 16.96,50.21 16.31,49.56 16.31,48.6 15.49,47.49 14.19,47.94 7.86,47.94 6.83,46.91 4.61,46.91 3.77,47.74 3.77,48.4 14.47,48.4 14.49,48.36 15.27,47.91 15.85,48.6 15.85,52.95 16.31,52.95
GND on BOTTOM (solid shape): 275.63,14 275.63,1 275.42,0.47 274.89,0.25 269.7,0.25 269.7,6.94 270.52,7.76 271.16,7.76 274.15,7.75 272.22,10.04 272.22,13.9 272.68,14.36 275.27,14.36
GND on BOTTOM (solid shape): 25.26,40.34 25.26,40.26 25.25,40.25 25.22,40.18 25.2,40.11 25.2,39.92 25.18,39.86 25.18,39.81 25.18,39.23 25.18,39.18 25.2,39.12 25.2,39.06 25.39,38.87 30.63,38.87 30.83,39.07 30.84,39.23 30.84,39.59 30.94,39.69 31.59,39.69 31.71,39.57 31.71,39.18 31.59,39.06 31.07,39.06 30.76,38.75 30.76,38.17 30.88,38.06 32.29,38.06 32.34,38.01 32.33,37.98 32.33,37.87 32.37,37.76 32.37,37.03 32.32,36.97 30.92,36.97 30.76,36.82 30.76,35.84 30.95,35.65 31.85,35.65 31.92,35.58 31.92,35.43 31.88,35.39 30.77,35.39 30.7,35.47 25.36,35.47 25.3,35.41 23.96,35.41 23.95,35.4 23.92,35.4 23.88,35.36 23.88,35.25 23.84,35.17 23.77,35.14 23.71,35.14 23.66,35.13 23.56,35.14 23.52,35.23 23.52,35.52 23.69,35.69 24.27,35.69 24.31,35.69 24.9,35.69 25.08,35.69 25.25,35.87 25.25,38.7 24.93,39.03 24.93,39.24 24.93,39.27 24.93,40.26 24.58,40.6 24.56,40.71 24.65,40.78 24.82,40.78
GND on BOTTOM (solid shape): 8.44,73.9 8.44,73.48 8.7,73.22 8.7,72.38 8.8,72.28 9.84,72.28 10.05,72.08 10.05,71.54 9.51,71.01 9.51,65.09 9.46,65.04 9.46,64.25 10.15,63.56 13.49,63.56 15.06,65.13 16.26,65.13 16.83,64.56 16.83,63.04 17.9,61.97 17.9,60.83 17.29,60.22 15.85,60.22 15.85,62.08 15.85,62.9 15.25,63.6 14.47,63.1 2.23,63.1 2.23,63.77 2,64.08 1.63,63.96 1.55,63.92 1.47,63.96 1.1,64.08 0.87,63.77 0.87,63.1 0.2,63.1 0.2,64.51 0.2,64.85 0.39,65.08 0.67,65.17 0.82,65.17 1.55,65.17 2.05,65.37 2.25,65.87 2.25,68.84 2.05,69.34 1.55,69.54 0.67,69.54 0.39,69.63 0.2,69.86 0.2,71.64 0.9,71.64 1.1,71.84 5.45,71.84 6.15,71.84 6.93,71.34 7.53,72.04 7.53,73.96 7.61,73.96 7.61,73.97 8.37,73.97
GND on BOTTOM (solid shape): 285.35,62.67 285.4,62.59 285.4,60.85 285.98,60.16 286.76,60.62 286.77,60.65 291.8,60.65 292.02,60.5 292.29,60.45 292.7,60.45 292.7,58.54 292.61,58.33 292.4,58.24 291.3,58.24 290.66,57.98 290.4,57.34 290.4,54.49 290.66,53.85 291.3,53.59 292.7,53.59 292.7,52.43 291.87,52.43 291.02,51.58 291.87,50.73 292.7,50.73 292.7,49.63 283.75,49.63 283.25,49.43 283.05,48.93 283.05,42.75 283.17,42.35 283.64,41.98 283.7,41.82 283.7,34.25 283.24,34.25 283.24,41.71 282.77,42.14 282.59,42.75 282.59,48.93 282.93,49.75 283.75,50.09 284.12,50.46 284.12,52.98 283.65,53.45 283.65,59.39 282.79,60.25 282.79,60.9 283.02,61.13 283.9,61.13 284.12,61.34 284.12,61.95 284.83,62.66 285.15,62.66 285.2,62.66 285.25,62.68
GND on BOTTOM (solid shape): 0.66,45.06 0.65,44.9 0.66,44.74 0.66,44.05 0.76,43.81 1,43.71 1.99,43.71 3.16,43.23 3.65,42.05 3.65,37.68 3.75,37.44 3.99,37.34 8.51,37.34 9.55,36.98 10.13,36.04 11.56,36.04 12.09,35.51 15.3,35.51 16.13,34.68 16.13,32.72 16.9,31.95 18.05,31.95 18.17,31.82 18.17,29.89 17.67,29.38 17.67,1.05 17.77,0.81 18.01,0.71 35.95,0.71 35.95,0.25 18.01,0.25 17.44,0.49 17.21,1.05 17.21,29.7 16.86,30.55 16.01,30.9 10.51,30.9 9.95,31.14 9.71,31.7 9.71,35.68 9.36,36.53 8.51,36.89 3.99,36.89 3.42,37.12 3.19,37.68 3.19,42.05 2.84,42.9 1.99,43.25 1,43.25 0.44,43.49 0.2,44.05 0.2,47.06 0.66,47.06
GND on BOTTOM (solid shape): 275.69,1.05 275.45,0.49 274.89,0.25 230.25,0.25 229.68,0.49 229.45,1.05 229.45,1.5 229.25,2 228.75,2.2 214.75,2.2 214.25,2 214.04,1.5 214.04,0.5 213.96,0.29 213.75,0.2 209.05,0.2 208.84,0.29 208.75,0.5 208.75,1.5 208.55,2 208.05,2.2 200.85,2.2 200.35,2 200.14,1.5 200.14,1.05 199.91,0.49 199.35,0.25 160.48,0.25 160.48,2.33 161.26,3.11 163.09,3.11 163.34,3.36 163.34,6.12 164.39,7.17 171.46,7.17 172.14,6.49 172.14,1.95 173.37,0.71 199.35,0.71 199.59,0.81 199.69,1.05 199.69,1.5 200.03,2.32 200.85,2.66 208.05,2.66 208.87,2.32 209.21,1.5 209.21,0.66 213.59,0.66 213.59,1.5 213.93,2.32 214.75,2.66 228.75,2.66 229.21,2.56 229.6,2.29 229.93,1.96 233.01,1.96 233.47,2.42 233.47,4.46 233.94,4.92 238.29,4.92 238.81,4.39 238.81,1.85 239.96,0.71 274.89,0.71 275.13,0.81 275.23,1.05 275.23,27.52 275.69,27.52
GND on BOTTOM (solid shape): outline of 213 points within 3.19,0.2 292.7,56.73
GND on BOTTOM (solid shape): outline of 150 points within 21.39,19.09 276.54,76.55
GND on BOTTOM (solid shape): outline of 272 points within 1.1,15.66 292.7,84.45
GND on IN1 (solid shape): 265.12,39.78 265.12,39.42 264.63,38.93 264.63,38.32 264.25,37.94 259.91,37.94 259.66,38.19 259.66,40.23 260.64,41.21 263.68,41.21
GND on IN1 (solid shape): 259.65,60.67 259.75,60.6 259.72,60.49 258.55,59.32 258.44,59.3 258.38,59.39 258.38,59.54 259.5,60.67
GND on IN1 (solid shape): outline of 704 points within 249.06,46.13 280.78,70.85
GND on IN1 (solid shape): outline of 3699 points within 0.2,0.2 292.7,84.45
GND on VCC (solid shape): 143.79,2.04 146.45,4.7 149.11,2.04 149.11,1.05 149.21,0.81 149.45,0.71 160.3,0.71 160.3,0.25 149.45,0.25 148.89,0.49 148.65,1.05 148.65,2.04 146.45,4.24 144.25,2.04 144.25,1.05 144.01,0.49 143.45,0.25 127.59,0.25 127.59,0.71 143.45,0.71 143.69,0.81 143.79,1.05
GND on IN2 (solid shape): outline of 349 points within 249.06,52.36 282.53,72.61
GND on IN2 (solid shape): outline of 723 points within 86.15,52.19 95.59,76.55
GND on IN2 (solid shape): outline of 1261 points within 0.2,30.53 18.28,73.68
GND on IN2 (solid shape): outline of 4013 points within 0.2,0.2 292.7,84.45
GND on IN3 (solid shape): 264.2,40.63 264.11,40.54 260.61,40.54 260.28,40.21 260.28,40.1 260.26,40.06 260.23,40.05 260.02,39.72 260.41,39.68 260.49,39.73 260.57,39.68 260.87,39.62 260.97,39.92 260.97,40.01 261.06,40.06 264.31,40.06 264.53,40.29 265.12,39.71 265.12,38.05 264.93,37.86 259.91,37.86 259.66,38.12 259.66,40.15 260.67,41.17 263.66,41.17
GND on IN3 (solid shape): outline of 1237 points within 85.27,11.94 101.72,30.29
GND on IN3 (solid shape): outline of 150 points within 19.37,19.09 274.08,76.55
GND on IN3 (solid shape): outline of 1549 points within 92.42,10.82 110.65,47.79
GND on IN3 (solid shape): outline of 5366 points within 0.2,0.2 292.7,84.45
GND on TOP: 189.7,9.47 190.46,9.47 190.59,9.34 190.59,7.05 190.46,6.93 189.57,6.93 189.45,7.05 189.45,8.2 189.57,8.32 189.57,9.34
GND on TOP: 28.41,27.12 31.97,27.12 32.86,26.23 32.86,22.93 30.06,20.13 30.06,19.12 29.94,18.99 28.79,18.99 28.67,19.12 28.67,21.15 28.28,21.53 28.03,21.53 27.9,21.66 27.9,22.55 27.78,22.67 27.78,24.58 28.16,24.96 28.16,26.87
GND on TOP: 165.47,5.2 167.17,5.2 167.22,5.15 167.22,4.28 167.1,4.16 165.44,4.16 165.34,4.26 165.34,5.07
GND on TOP: 163.54,51.88 163.29,52.14 163.29,54.55 162.78,55.06 158.08,55.06 157.7,54.68 157.32,54.68 157.06,54.93 153.89,54.93 153.76,54.81 153.25,54.81 153,55.06 151.47,55.06 150.71,55.82 146.14,55.82 145.12,54.81 143.6,54.81 143.35,55.06 143.35,55.95 143.22,56.08 142.08,56.08 141.95,55.95 141.95,55.31 141.82,55.19 138.39,55.19 138.29,55.08 137.81,55.08 137.73,55.16 137.73,55.47 138,55.73 138.3,55.73 138.39,55.82 141.57,55.82 141.95,56.2 141.95,57.6 141.82,57.73 139.03,57.73 138.77,57.98 138.77,58.74 139.03,59 141.34,59 141.73,59.39 141.73,61.46 141.52,61.67 136.68,61.67 136.59,61.76 136.59,62.59 136.74,62.74 136.74,63.04 139.05,65.35 141.44,65.35 141.82,64.97 141.82,64.08 142.84,63.06 143.47,63.06 143.6,62.93 143.6,60.77 144.74,59.63 147.54,59.63 149.32,57.85 152.24,57.85 153.07,58.69 161.18,58.69 164.43,55.44 164.43,52.14 164.17,51.88
GND on TOP: 261.66,29.91 261.66,30.98 261.71,31.03 262.07,31.03 262.17,30.93 262.17,30.54 262.4,30.31 262.87,30.31 262.87,30.32 264.06,30.32 264.48,30.32 264.99,29.81 264.99,29.28 265.27,29 266.94,29 267.04,28.9 267.04,27.99 267.55,27.48 272.91,27.48 273.46,28.04 274.53,28.04 274.65,27.91 274.65,25.97 274.28,25.6 273.02,25.6 272.95,25.66 272.24,25.66 270.2,23.61 270.2,22.65 269.95,22.41 269.56,22.41 269.51,22.46 269.51,24.53 269.58,24.59 269.58,26.19 269.05,26.72 265.74,26.72 265.73,26.7 264.87,26.7
GND on TOP: 120.82,66.72 124.54,66.72 124.65,66.61 124.65,62.38 125.53,61.5 125.53,59.05 124.63,58.15 123.97,58.15 123.1,59.01 120.24,59.01 119.89,59.36 119.89,65.79
GND on TOP: 193.53,52.49 193.53,54 192.52,55.01 191.6,55.01 191.43,55.18 191.43,60.42 184.79,67.06 182.66,67.06 180.93,68.78 180.93,69.25 179.82,70.36 177.29,70.36 176.65,71 176.65,72.56 176.74,72.77 176.95,72.85 182.95,72.85 183.45,73.06 183.65,73.56 183.65,73.66 183.74,73.87 183.95,73.96 187.15,73.96 188,74.31 188.35,75.16 188.35,75.76 191.28,75.76 192.39,74.65 192.39,68.26 195.26,65.39 197.45,65.39 200.07,62.77 200.07,54.65 200.03,54.61 200.03,53.53 196.23,49.72 195.17,49.72 195.04,49.85 195.04,50.97
GND on TOP: 153.89,42.23 160.75,42.23 160.87,42.11 160.87,41.6 160.75,41.47 159.98,41.47 159.73,41.22 154.27,41.22 153.76,41.72 153.76,42.11
GND on TOP: 182.39,50.87 182.64,50.87 183.78,49.73 184.75,49.73 184.88,49.6 184.88,49.09 184.75,48.96 183.35,48.96 182.97,49.34 182.97,50.03 182.64,50.36 182.41,50.36 182.34,50.44 182.34,50.82
GND on TOP: 37.24,41.07 35.89,42.42 35.89,60.58 36.5,61.19 36.5,65.82 34.96,67.37 33.85,67.37 33.23,67.98 33.23,70.34 33.62,70.73 37.98,70.73 38.75,69.96 38.75,63.48 43.43,58.79 43.84,57.89 43.55,56.95 40.76,52.28 39.18,47.07 38.91,45.67 38.77,44.24 38.75,42.65 38.85,41.07
GND on TOP: 188.18,54.42 188.18,54.17 187.67,53.66 186.78,53.66 186.78,53.67 183.65,53.67 177.36,59.96 177.95,60.55 182.05,60.55
GND on TOP: 139.49,51.07 138.39,51.07 138.27,51.2 138.27,51.53 138.37,51.63 138.77,51.63 138.99,51.85 139.71,51.85 139.85,51.71 139.85,51.43
GND on TOP: 236.46,2.94 234.7,4.7 233.08,4.7 231.57,6.21 229.53,6.21 228.7,7.04 228.7,9.24 230.52,11.06 235.65,11.06 235.65,10.94 235.71,11 252.73,11 253.58,10.15 259.62,10.15 260.12,9.65 260.12,6.84 257.31,4.03 252.31,4.03 251.22,2.94
GND on TOP: 154.4,48.2 154.01,48.58 154.01,51.88 154.14,52.01 154.65,52.01 155.03,52.39 155.54,52.39 155.67,52.52 155.67,53.76 155.69,53.79 156.15,53.79 156.17,53.76 156.17,52.39 156.55,52.01 157.7,52.01 157.95,52.27 158.33,52.27 158.71,51.88 161.51,51.88 162.03,51.36 162.03,48.38 161.85,48.2
GND on TOP: 258.28,32.71 259.3,32.71 259.42,32.58 259.42,31.95 259.04,31.56 259.04,24.71 258.92,24.58 258.66,24.58 257.66,25.58 257.66,26.98 257.27,27.37 257.27,31.69
GND on TOP: 15.85,57.76 15.85,62.9 15.25,63.6 14.48,63.1 12.27,63.1 12.27,64.15 13.81,65.7 18.31,65.7 23.91,64.31 26.56,61.65 26.56,60.67 26.25,60.36 24.86,60.36 22.27,57.76
GND on TOP: 112.07,15.11 112.15,15.07 112.17,14.98 112.17,14.88 112.21,14.78 112.21,14.75 112.2,14.72 112.19,14.71 112.17,14.69 112.14,14.69 111.99,14.67 111.88,14.57 111.82,14.52 111.75,14.52 111.56,14.53 111.4,14.41 111.39,14.39 110.63,14.39 110.31,14.48 110.08,14.24 110.07,14.23 109.87,14.03 109.74,14.03 109.74,14.2 109.72,14.24 109.72,15.11
GND on TOP: 29.05,2.99 29.17,2.86 29.17,1.34 29.05,1.21 24.6,1.21 24.47,1.34 24.47,2.86 24.6,2.99
GND on TOP: 270.6,38.04 270.73,37.91 273.65,37.91 273.9,38.17 273.9,39.95 273.78,40.07 270.85,40.07 270.6,39.82
GND on TOP: 90.77,33.6 97.12,33.6 98.01,32.71 98.01,28.49 97.99,28.47 97.99,28.16 99.75,26.4 99.75,22.3 99.38,21.93 95.8,21.93 95.25,21.37 95.25,17.14 94.17,16.06 92.65,16.06 91.05,17.67 91.05,21.08 90.51,21.62 90.51,22.68 91.79,23.96 92.78,23.96 93.15,24.33 94.69,24.33 95.12,24.77 95.12,26.1 95.77,26.74 95.77,28.74 95.43,29.08 93.03,29.08 92.93,29.18 92.93,30.32 92.67,30.57 90.9,30.57 90.64,30.83 90.64,33.47
GND on TOP: 96.94,61.1 99.1,61.1 104.75,55.45 104.75,54.43 104.5,54.18 96.02,54.18 95.64,54.55 95.64,59.8 ; 1 cut-out
GND on TOP: 137.38,53.54 137.5,53.41 137.5,52.39 137.38,52.27 135.85,52.27 135.7,52.42 135.7,53.38 135.85,53.54
GND on TOP: 156.5,62.55 156.3,62.35 156.3,61.33 156.38,61.26 159.22,61.26 159.27,61.31 159.27,62.15 158.87,62.55
GND on TOP: 90.77,43.5 93.79,43.5 94.75,44.46 97.83,44.46 98.08,44.21 98.08,41.17 98.26,40.98 104.79,40.98 105.03,40.73 105.03,33.1 104.44,32.52 101.42,32.52 97.68,36.25 97.68,37.02 95.77,38.93 95.14,38.93 94.92,39.15 93.98,39.15 90.64,42.49 90.64,43.38
GND on BOTTOM: 205.07,35.76 205.07,35.25 206.59,33.72 206.59,32.45 208.62,30.42 208.88,30.42 209.13,30.68 209.13,30.8 208.5,31.44 208.5,31.82 208.12,32.71 207.48,34.1 206.97,35.63 206.59,36.01 205.32,36.01
GND on BOTTOM: 136.11,66.79 135.98,66.67 127.56,66.67 127.44,66.55 127.44,66.11 127.35,66.03 126.82,66.03 126.05,66.79 126.05,67.12 126.15,67.23 136.06,67.23 136.11,67.18
GND on BOTTOM: 281.14,60.9 282.54,60.9 282.79,61.16 282.79,61.92 282.54,62.17 281.65,62.17 281.01,61.54 281.01,61.03
GND on BOTTOM: 92.8,24.38 92.8,23.44 93.05,23.18 94.3,23.18 94.55,23.44 94.55,24.22 95.26,24.94 95.26,25.9 94.71,26.46 94.71,27.65 94.81,27.75 95.47,27.75 95.85,28.14 98.11,28.14 98.53,27.72 99.31,27.72 99.42,27.82 99.42,28.39 98.65,29.15 98.39,29.15 98.26,29.28 93.56,29.28 93.18,28.9 93.18,27.7 94.02,26.87 94.02,25.98 94.12,25.87 94.12,24.71 93.92,24.5 92.93,24.5
GND on BOTTOM: 182.72,57.98 182.72,57.6 182.34,57.22 182.34,56.84 188.81,50.36 188.81,49.85 187.8,48.84 187.67,48.84 181.07,55.44 179.92,56.58 179.92,57.73 179.29,58.36 179.29,58.74 180.43,59.89 180.81,59.89
GND on BOTTOM: 203.8,26.23 203.8,25.47 203.67,25.34 202.27,25.34 201.26,26.36 201.26,27.5 200.5,28.26 200.5,28.77 200.62,28.9 201.13,28.9
GND on BOTTOM: 40.32,15.99 40.32,13.12 39.46,12.26 37.94,12.26 37.76,12.08 36.77,12.08 34.76,14.09 34.76,17.09 34.96,17.29 34.96,18.41 35.29,18.74 36.03,18.74 36.84,19.55 36.87,19.55 37.38,19.04 37.38,18.94
GND on BOTTOM: 211.47,17.46 214.48,17.46 214.78,17.76 214.78,18.89 215.06,19.17 215.19,19.17 215.25,19.1 215.25,17.29 214.56,16.6 214.56,16.06 214.36,15.85 213.63,15.85 212.99,16.49 211.99,16.49 211.69,16.79 211.35,16.79 211.3,16.84 211.3,17.28
GND on BOTTOM: 84.67,32.31 85.16,33.35 85.59,34.42 87.34,34.42 87.4,34.36 87.4,31.63 87.34,31.56 84.99,31.56 84.67,31.88
GND on BOTTOM: 192.98,71.77 193.18,71.77 193.49,71.47 193.49,71.26 193.33,71.11 193.33,70.4 193.79,69.94 193.79,69.66 193.71,69.59 193.51,69.59 192.9,70.2 192.9,70.45 192.95,70.5 192.95,70.91 192.65,71.21 192.65,71.44
GND on BOTTOM: 109.01,30.19 111.8,30.19 111.93,30.07 111.93,28.8 111.8,28.67 109.01,28.67 108.88,28.8 108.88,30.07
GND on BOTTOM: 267.01,22.06 270.07,22.06 270.89,21.25 270.89,17.29 270.69,17.1 270.03,17.1 270.02,17.1 269.89,17.1 269.68,16.9 269.68,14.84 269.6,14.76 268.87,14.76 268.8,14.83 268.8,17.49 269.11,17.8 270.03,17.8 270.22,17.99 270.22,18.33 269.99,18.56 269.14,18.56 268.94,18.76 268.9,18.76 268.64,19.02 268.06,19.02 267.87,19.21 267.87,19.47 267.63,19.71 267.28,19.71 266.84,20.15 266.84,21.89
GND on BOTTOM: 26,14.04 29.05,14.04 29.17,13.91 29.17,13.71 29.5,13.38 31.59,13.38 31.69,13.28 31.69,12.39 31.94,12.13 31.94,11.88 31.16,11.1 30.09,11.1 30.01,11.18 30.01,12.11 29.43,12.69 28.69,12.69 28.54,12.84 28.54,13.35 28.46,13.43 28.08,13.43 27.9,13.25 27.9,12.51 28.16,12.26 28.16,10.85 27.58,10.28 26.85,10.28 26.78,10.36 24.6,10.36 24.47,10.48 24.47,12.13 24.65,12.31 25.85,12.31 26,12.46 26,13.28 25.87,13.4 25.87,13.91
GND on BOTTOM: 20.3,17.54 19.31,18.53 17.21,18.53 17.21,28.41 18.2,28.41 23.01,23.59 24.28,23.59 24.71,23.16 24.71,18.96 23.29,17.54
GND on BOTTOM: 269.71,27.17 268.88,28.01 268.88,29.71 269.87,30.7 271.29,30.7 271.57,30.99 271.57,33.74 271.29,34.02 271.29,36.44 274.99,40.14 283.7,40.14 283.7,32.5 283.7,31.7 283.46,31.14 282.9,30.9 276.89,30.9 276.04,30.55 275.69,29.7 275.69,27.73 275.69,27.17
GND on BOTTOM: 24.47,2.61 26.25,2.61 26.38,2.48 26.38,1.59 26.25,1.47 24.47,1.47 24.35,1.59 24.35,2.48
GND on BOTTOM: 147.16,54.3 147.54,54.3 147.92,53.92 147.92,53.31 147.84,53.23 146.98,53.23 146.9,53.31 146.9,54.04

# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS_WLAN_MCU: length 32.8
  TOP w0.381: RW58.2 v2(260.47,7.82) ; RW52.2 267.32,8.09 267.04,7.82 v1(266.51,7.82) ; RW57.2 v3(265.25,19.17)
  TOP w0.508: v2(265.32,7.82) v1(266.51,7.82)
  IN1 w0.508: v2(265.32,7.82) 264.52,7.82 v2(263.87,8.46) ; v2(263.26,8.46) 261.11,8.46 v2(260.47,7.82) 260.47,6.14 259.3,4.97 v4(257.9,4.97)
  IN2 w0.457: v3(265.25,19.17) 265.32,19.11 265.32,13.36 263.05,11.09 v3(262.88,11.09)
  BOTTOM w0.508: v4(257.9,4.97) 257.65,4.72 253.23,4.72 251.73,3.22 RW1238.2
  vias: v2(260.19,12.82) v2(260.59,12.82)
+3VS_WLAN_R: length 1.3
  BOTTOM w0.069: R222.1 264.76,1.85 v1(264.15,1.24)
+5VALW: length 262.8
  TOP w0.127: v5(27.24,9.16) 27.24,9.47 v6(27.6,9.82) ; v5(27.9,6.04) 27.95,6.09 v6(28.56,6.09) ; v5(27.9,7.94) 28,7.84 v6(28.49,7.84)
  TOP w0.381: v3(147.38,62.35) 147.47,62.27 UC13.3
  TOP w0.508: v4(139.92,65.65) 141.34,65.65 141.82,65.17 141.82,63.39 142.75,62.46 142.75,58.5 141.83,57.58 139.38,57.58 v3(138.91,57.12)
  IN1 w0.381: v3(147.38,62.35) 147.46,62.43 147.46,62.43 150.15,65.12 153.15,65.12 v5(153.96,65.93)
  IN2 w0.508: v3(107.07,30.09) 107.79,30.09 107.99,30.29 107.99,30.42 108.49,30.93 111.65,30.93 113.09,32.38 147.31,32.38 v4(149.29,34.36) ; 32.35,27.75 31.76,27.17 31.76,22.29 32.93,21.13 34.67,21.13 35.26,20.54 36.57,20.54 38.19,18.92 40.01,18.92 44.02,14.9 67.65,14.9 67.93,15.18 73.93,15.18 88.41,29.66 ; 88.41,29.66 91.48,29.66 96.03,25.11 99.87,25.11 100.8,24.19 107.8,24.19 v3(107.91,24.07) ; 88.41,29.66 88.46,29.71 88.46,49.31 92.8,53.65 92.8,56 95.47,58.67 99.67,58.67 100.48,57.85 105.6,57.85 106.31,57.14 110.69,57.14 111.09,56.74 120.18,56.74 120.89,56.02 128.06,56.02 ; 132.42,57.09 135.98,57.09 137.22,55.85 137.74,55.85 138.91,57.02 v3(138.91,57.12)
  IN3 w0.508: v3(107.91,24.07) 107.79,24.2 107.79,26.74 106.39,28.14 106.39,29.43 107.05,30.09 v3(107.07,30.09) ; v3(147.38,62.35) 146.2,61.17 141.86,61.17 138.91,58.22 v3(138.91,57.12)
  BOTTOM w0.254: v5(153.96,65.93) 153.86,66.03 153.86,67.1 153.2,67.76 151.58,67.76 151.23,67.41 UC12.3 ; UC22.3 140.25,65.99 v4(139.92,65.65)
  BOTTOM w0.381: v4(149.29,34.36) 148.83,33.9 148.22,33.9 147.64,33.32 147.64,31.26 147.95,30.95 UC27.3
  vias: v3(32.73,29.79) v3(32.73,29.28) v3(32.73,28.77) v3(32.73,28.26) v3(33.24,29.79) v3(33.24,29.28) v3(33.24,28.77) v3(33.24,28.26) v4(27.01,1.85) v4(27.27,1.59) v4(27.4,1.85) v4(32.73,29.79) v4(32.73,29.28) v4(32.73,28.77) v4(32.73,28.26) v4(33.24,29.79) v4(33.24,29.28) v4(33.24,28.77) v4(33.24,28.26) v5(27.27,8.58) v5(27.27,7.94) v5(27.27,7.31) v5(27.27,6.67) v5(27.27,6.04) v5(27.27,5.4) v5(27.27,4.77) v5(27.9,8.58) v5(27.9,7.31) v5(27.9,6.67) v5(27.9,5.4) v5(27.9,4.77)
+5VALW_L_TBT: length 19.3
  IN3 w0.508: v4(34.61,31.36) 33.34,31.36 31.44,33.26 31.44,35.37 30.52,36.29 25.26,36.29 24.4,35.43 24.4,34.76 23.99,34.36 23.59,34.36 22.59,35.35 22.59,37.31 v4(22.9,37.62)
  vias: v1(33.11,32.63)
+5VALWB: length 113.4
  TOP w0.203: v3(183.99,44.29) U31.4
  TOP w0.254: UT3.4 v2(167.05,3.04) ; v2(267.15,42.56) 268.57,42.56 268.87,42.26 UC25.4 ; v2(172.51,3.46) 172.24,3.19 v2(171.24,3.19) 170.85,3.19 170.64,3.41 UC23.3 ; v5(192.22,43.86) 192.22,43.3 189.96,41.04 189.96,40.35 189.42,39.82 v3(189.32,39.82)
  TOP w0.381: v4(228.35,8.23) 227.1,6.99 226.04,6.99 225.83,6.79 198.59,6.79 198.05,6.25 196.84,6.25 196.66,6.43 v2(196.66,6.57) ; v2(182.97,4.99) 180.91,4.99 180.44,4.53 v2(180.44,4.34)
  IN1 w0.254: v2(167.05,3.04) 167.05,2.88 167.91,2.02 170.07,2.02 v2(171.24,3.19)
  IN1 w0.381: v2(182.97,4.99) 183.04,4.93 188.26,4.93 189.4,6.06 193.24,6.06 193.39,6.22 194.56,6.22 195.14,6.8 195.77,6.8 196,6.57 v2(196.66,6.57) ; 176.47,4.49 177.89,3.07 179.27,3.07 180.44,4.23 v2(180.44,4.34) ; 176.47,4.49 176.47,4.39 175.82,3.74 173.38,3.74 173.11,3.46 v2(172.51,3.46) ; 176.47,4.49 v2(176.47,4.79)
  IN1 w0.508: v3(265.6,41.75) 266.41,42.56 v2(267.15,42.56)
  IN2 w0.254: v3(189.32,39.82) 189.32,40.4 188.84,40.89 187.05,40.89 184.42,43.52 184.42,43.86 v3(183.99,44.29)
  IN2 w0.508: v5(192.22,43.86) 193.49,42.59 193.49,41.27 196.15,38.6 v4(196.15,35.91)
  IN3 w0.508: v3(265.6,41.75) 266,41.34 266,37.91 266.36,37.56 266.36,34.5 263.25,31.39
  BOTTOM w0.254: v4(196.15,35.91) 196.56,35.91 196.94,36.29 196.94,37.28 196.67,37.55 UC24.4 ; v5(254.34,51.25) 254.37,51.27 U36.4 ; v4(221.49,19.06) 221.88,18.66 U60.4
  vias: v1(198.51,50.79) v2(204.94,52.01) v2(204.94,51.5) v2(204.94,51) v3(204.94,52.01) v3(204.94,51.5) v3(204.94,51) v3(221.72,16.59) v3(222.26,16.6) v3(227.57,13.73) v3(227.85,14.17) v3(228.08,13.73) v3(228.36,14.17) v3(228.59,13.73) v3(255.44,51.55) v3(255.61,51.07) v3(256.22,51.88) v3(256.22,51.05) v3(261.81,31.74) v3(261.81,31.31) v3(261.81,30.88) v3(262.22,31.46) v3(262.19,31.06) v3(262.19,30.65) v4(221.72,16.59) v4(222.26,16.6) v4(227.57,13.73) v4(227.85,14.17) v4(228.08,13.73) v4(228.36,14.17) v4(228.59,13.73) v4(255.37,52.01) v4(255.87,52.01) v4(255.87,50.74) v4(256.02,51.4) v4(261.81,31.74) v4(261.81,31.31) v4(261.81,30.88) v4(262.22,31.46) v4(262.19,31.06) v4(262.19,30.65)
+5VALWB_R_TBT: length 1.1
  TOP w0.127: v6(257.87,34.82) 257.93,34.76 258.94,34.76
  vias: v2(258.66,35.37) v2(258.79,35.12) v2(258.92,35.37) v2(259.04,35.12) v2(259.17,35.37) v2(259.3,35.12) v2(259.42,35.37) v2(266.7,39.86) v2(267.01,39.86) v2(267.5,39.96) v3(258.6,38.32) v3(258.6,37.81) v3(258.6,37.3) v3(258.6,36.8) v3(258.6,36.29) v3(258.6,35.78) v4(258.6,38.32) v4(258.6,37.81) v4(258.6,37.3) v4(258.6,36.8) v4(258.6,36.29) v4(258.6,35.78)
+5VALWBP: length 19.6
  TOP w0.254: v5(265.49,22.29) 265.55,22.24 268.34,22.24 268.97,21.61 268.97,18.76 270.07,17.67 v1(274,17.67) 274.38,18.05 v2(274.38,18.99)
  IN1 w0.254: v2(274.38,18.99) v3(274.38,18.48)
  IN3 w0.254: v5(265.49,22.29) 265.49,22.4 263.07,24.82 v4(261.53,24.82) ; v4(274.31,18.87) 274.31,18.56 v3(274.38,18.48)
+5VALWP: length 17.7
  IN3 w0.203: 28.87,16.43 27.73,16.43 27.5,16.2 27.01,16.2 26.51,16.71 25.67,16.71 25.31,17.06 25.31,18.61 v4(25.82,19.12) ; 28.87,16.43 28.87,13.1 28.72,12.95 28.72,10.51 28.06,9.85 v4(26.17,9.85) ; 28.87,16.43 28.87,17.65 28.33,18.18 v4(27.65,18.18)
  vias: v1(25.59,6.44) v5(24.68,8.07) v5(24.68,7.43) v5(24.68,5.28) v5(24.68,4.64) v5(25.26,8.07) v5(25.26,7.43) v5(25.26,5.28) v5(25.26,4.64)
+5VBS: length 19
  BOTTOM w0.127: R670.2 227.37,17.77 v6(228.11,18.51)
  BOTTOM w1.016: 231.1,16.43 232.78,16.43 233.77,15.44 233.77,11.65 235.08,10.34 236.86,10.34 237.88,9.31 238.77,9.31 239.33,8.76 239.33,6.77 238.74,6.18 LT10.1
+5VBS_FAN2: length 0.7
  IN3 w0.508: v3(235.37,8.32) 235.52,8.17 v4(236.06,8.17)
+5VS: length 34.5
  IN1 w0.127: v2(36.92,4.92) 36.36,4.36 v3(36.36,3.88)
  BOTTOM w0.254: 60.54,8.35 60.54,7 62.4,5.15 69.85,5.15 R38.2
  BOTTOM w1.016: 61.85,9.65 60.54,8.35 58.64,8.35 56.33,6.04 42.56,6.04 42.28,5.76
  vias: v4(33.64,3.14) v4(33.64,2.81) v4(33.92,3.27) v4(33.92,2.94) v4(40.88,5.2) v4(40.88,4.82) v4(41.26,5.2) v4(41.26,4.82)
+5VS_AUDIO: length 0.9
  TOP w0.127: v5(253.84,59.38) v6(253.84,58.51)
+5VS_AUDIO_R: length 2.4
  BOTTOM w0.069: R716.1 255.11,56.46 253.53,56.46 v1(253.35,56.63)
+5VS_FAN1:
  vias: v2(64.81,8.02) v3(64.81,8.02) v4(64.81,8.02)
+8.4V_BATT+:
  vias: v1(72.94,18.89) v3(63.21,18.23) v3(63.21,17.72) v3(63.72,18.23) v3(63.72,17.72) v3(64.23,18.23) v3(64.23,17.72) v3(64.73,18.23) v3(64.73,17.72) v3(65.24,18.23) v3(65.24,17.72) v3(65.75,18.23) v3(65.75,17.72) v3(66.26,18.23) v3(66.26,17.72) v3(66.77,18.23) v3(66.77,17.72) v3(67.27,18.74) v3(67.27,18.23) v3(67.27,17.72) v3(67.78,18.74) v3(67.78,18.23) v3(67.78,17.72) v3(68.29,18.74) v3(68.29,18.23) v3(68.29,17.72) v3(68.8,18.74) v3(68.8,18.23) v3(68.8,17.72) v3(69.31,18.74) v3(69.31,18.23) v3(69.31,17.72) v3(69.81,19.25) v3(69.81,18.74) v3(69.81,18.23) v3(69.81,17.72) v3(70.32,19.25) v3(70.32,18.74) v3(70.32,18.23) v3(70.32,17.72) v3(70.83,19.25) v3(70.83,18.74) v3(70.83,18.23) v3(70.83,17.72) v3(71.34,19.75) v3(71.34,19.25) v3(71.34,18.74) v3(71.34,18.23) v3(71.34,17.72) v3(71.85,19.75) v3(71.85,19.25) v3(71.85,18.74) v3(71.85,18.23) v3(71.85,17.72) v3(72.35,20.26) v3(72.35,19.75) v3(72.35,19.25) v3(72.35,18.74) v3(72.35,18.23) v3(72.35,17.72) v3(72.86,20.26) v3(72.86,19.75) v3(72.86,19.25) v3(72.86,18.74) v3(72.86,18.23) v3(72.86,17.72) v3(73.37,20.77) v3(73.37,20.26) v3(73.37,19.75) v3(73.37,19.25) v3(73.37,18.74) v3(73.37,18.1) v3(73.88,20.77) v3(73.88,20.26) v3(73.88,19.75) v3(73.88,19.25) v3(74.39,21.28) v3(74.39,20.77) v3(74.39,20.26) v3(74.39,19.75) v3(74.89,21.28) v3(74.89,20.77) v3(75.4,21.79) v3(75.4,21.28) v4(62.96,17.98) v4(62.96,17.47) v4(63.46,17.98) v4(63.46,17.47) v4(63.97,18.48) v4(63.97,17.98) v4(63.97,17.47) v4(64.48,18.48) v4(64.48,17.98) v4(64.48,17.47) v4(64.99,18.48) v4(64.99,17.98) v4(64.99,17.47) v4(65.5,18.48) v4(65.5,17.98) v4(65.5,17.47) v4(65.75,18.61) v4(66,18.48) v4(66,17.98) v4(66,17.47) v4(66.26,18.61) v4(66.51,18.48) v4(66.51,17.98) v4(66.51,17.47) v4(67.02,18.48) v4(67.02,17.98) v4(67.02,17.47) v4(67.53,18.48) v4(67.53,17.98) v4(67.53,17.47) v4(68.04,18.99) v4(68.04,18.48) v4(68.04,17.98) v4(68.04,17.47) v4(68.29,19.12) v4(68.54,18.99) v4(68.54,18.48) v4(68.54,17.98) v4(68.54,17.47) v4(68.8,19.12) v4(69.05,18.99) v4(69.05,18.48) v4(69.05,17.98) v4(69.05,17.47) v4(69.56,18.99) v4(69.56,18.48) v4(69.56,17.98) v4(69.56,17.47) v4(70.07,19.5) v4(70.07,18.99) v4(70.07,18.48) v4(70.07,17.98) v4(70.07,17.47) v4(70.32,19.63) v4(70.58,19.5) v4(70.58,18.99) v4(70.58,18.48) v4(70.58,17.98) v4(70.58,17.47) v4(71.08,19.5) v4(71.08,18.99) v4(71.08,18.48) v4(71.08,17.98) v4(71.08,17.47) v4(71.59,20.01) v4(71.59,19.5) v4(71.59,18.99) v4(71.59,18.48) v4(71.59,17.98) v4(71.59,17.47) v4(71.85,20.13) v4(72.1,20.01) v4(72.1,19.5) v4(72.1,18.99) v4(72.1,18.48) v4(72.1,17.98) v4(72.1,17.47) v4(72.86,20.64) v4(73.62,21.02) v4(73.62,20.52) v4(73.62,20.01) v4(73.62,19.5) v4(73.62,18.99)
+AVDD1: length 11.8
  TOP w0.203: UA1.40 257.05,62.44 256.88,62.61
  TOP w0.254: v2(255.66,62.93) 255.79,63.06 CA23.1 256.88,62.61 ; v2(257.65,66.29) 257.93,66.29 258.59,66.95 RA64.2
  IN1 w0.254: v2(255.66,62.93) 255.66,63.14 255.72,63.19 v3(255.72,63.26) 255.36,63.62 255.36,65.09 256,65.73 257.09,65.73 v2(257.65,66.29)
  IN3 w0.254: v3(255.72,63.26) 255.87,63.11 v4(255.87,62.93)
  BOTTOM w0.127: v1(257.44,64.07) 257.27,63.9 LA1.1
  BOTTOM w0.254: v4(255.87,62.93) LA1.1
+DVDD: length 4.6
  TOP w0.203: CA54.1 258.66,57.22 259.21,57.76 UA1.3
  TOP w0.254: RA13.2 255.54,57.17 v1(255.78,56.92) 256.25,56.46 RA63.1 ; CA54.1 CA33.1
+DVDD_MIC: length 3.6
  TOP w0.069: v1(160.11,65.91) 160.29,65.73 F1.2
  TOP w0.508: F1.2 161.3,65.73 161.8,65.22 161.8,64.5 v2(161.76,64.46)
  IN1 w0.254: v2(161.76,64.46) 161.5,64.46 v3(161.38,64.34)
  IN3 w0.254: v3(161.38,64.34) v4(161,64.34)
+DVDDIO: length 4.9
  TOP w0.203: CA36.1 266.05,59.53 266.05,59.57 264.38,61.24 UA1.18
  TOP w0.254: RA41.2 266.87,59.15 CA38.1 266.79,59.25 266.54,59.5 CA36.1
+PVDD: length 0.6
  BOTTOM w0.069: 256.91,60.11 v1(257.49,60.11)
  vias: v5(256.63,59.76)
+V1.05A_BYPASS: length 1.7
  TOP w0.127: v3(165.83,51.73) 165.83,51.53 v1(165.37,51.08)
  TOP w0.254: RC595.2 165.83,52.08 165.83,51.74 v3(165.83,51.73)
  IN3 w0.254: v3(165.83,51.73) 165.8,51.71 165.55,51.71 v4(165.43,51.82)
+V1.05A_MIPI60: length 19.9
  TOP w0.254: 90.62,64.56 90.88,64.83 JMIPI60.1
  TOP w0.508: 88.58,64.51 88.46,64.38 R123.2 v3(87.57,63.16) ; 88.58,64.51 88.2,64.89 88.2,68.77 89.35,69.91 89.35,71.24 v2(90.39,72.28) ; 88.58,64.51 88.63,64.56 90.62,64.56
  IN1 w0.508: v2(90.1,75.13) 90.54,74.68 90.54,72.43 v2(90.39,72.28)
  IN3 w0.508: v3(87.57,63.16) 87.57,62.78 v4(87.82,62.53)
  BOTTOM w0.127: v1(88.51,63.44) 88.51,62.6 C1544.1
  BOTTOM w0.508: v4(87.82,62.53) C1544.1
+V3.3A_1.8A_PCH_SPI: length 135.8
  TOP w0.254: RH635.2 161.88,42.73 v2(162.27,43.12) 162.52,42.87 164.28,42.87 165.55,41.6 166.54,41.6 166.89,41.24 166.89,38.88 165.37,37.36 RH141.2 165.05,37.09 164.73,36.77 162.3,36.77 161.88,37.2 RH643.2
  TOP w0.381: v2(162.27,43.12) 163.9,44.76 v1(169.69,44.76) 170.89,44.76 171.53,45.4 CC30.1 171.79,45.76 RC583.2 172.38,46.07 172.92,46.61 RC582.2
  IN1 w0.254: v3(99.57,74.1) 99.58,74.11 99.58,74.74 99.25,75.07 v2(99.25,75.13)
  IN1 w0.381: v2(162.27,43.12) 162.27,43.11 161.9,42.75 161.9,42.61 v3(161.92,42.59)
  IN2 w0.254: v3(99.57,74.1) 99.71,73.96 99.71,70.1 101.33,68.47 101.33,68.22 101.79,67.76 101.79,65.25 103.11,63.93 103.11,63.41 107.49,59.03 111.62,59.03 112.04,58.62 118.57,58.62 121.45,61.5 133.33,61.5 133.37,61.46 138.75,61.46 139.18,61.03 141.93,61.03 142.09,61.18 147.97,61.18 149.22,59.94 156.4,59.94 157.82,58.52 163.53,58.52 163.91,58.15 166.98,58.15 167.6,57.52 168.87,57.52 171.35,55.04 171.35,50.63 170.57,49.85 170.57,49.31 166.68,45.41 166.17,45.41 165.38,44.62 165.38,44.26 164.45,43.34 164.45,42.92 163.67,42.13 162.38,42.13 v3(161.92,42.59)
  IN3 w0.254: v3(161.92,42.59) 161.92,42.65 162.13,42.85 v4(162.13,42.86)
+VBATT: length 37.4
  TOP w0.508: v5(29.3,12.29) v1(29.3,14.27) 29.3,16.15 30.4,17.25 30.4,18.29 v3(35.14,23.03)
  IN2 w0.508: v3(35.14,23.03) 35.27,23.16 36.49,23.16 37.12,22.52 38.98,22.52 44.93,16.58 55.28,16.58 55.61,16.91
  BOTTOM w0.508: v5(29.3,12.29) 29.57,12.02 PR236.2
  vias: v3(54.07,19.5) v3(54.07,18.99) v3(54.07,18.48) v3(54.57,19.5) v3(54.57,18.99) v3(54.57,18.48) v3(54.57,17.98) v3(55.08,18.99) v3(55.59,18.99) v3(56.1,18.99) v3(56.1,18.48) v3(56.61,18.48) v3(56.61,17.98) v3(57.11,18.48) v3(57.11,17.98) v3(57.62,18.48) v3(57.62,17.98) v3(57.62,17.47) v3(58.13,18.48) v3(58.13,17.98) v3(58.64,18.48) v3(58.64,17.98) v3(59.15,18.48) v3(59.15,17.98) v3(59.65,17.98) v3(60.16,17.98) v3(60.67,17.98) v3(60.8,17.47) v4(55.59,19.37) v4(55.84,19.25) v4(55.84,18.74) v4(55.87,18.18) v4(55.87,17.8) v4(56.13,17.93) v4(56.35,18.74) v4(56.35,18.23) v4(56.86,18.74) v4(56.86,18.23) v4(56.86,17.72) v4(57.11,18.86) v4(57.37,18.74) v4(57.37,18.23) v4(57.37,17.72) v4(57.62,18.86) v4(57.88,18.74) v4(57.88,18.23) v4(57.88,17.72) v4(58.38,18.74) v4(58.38,18.23) v4(58.38,17.72) v4(58.89,18.23) v4(58.89,17.72) v4(59.4,18.23) v4(59.4,17.72) v4(59.91,18.23) v4(59.91,17.72) v4(60.16,18.48) v4(60.42,18.23) v4(60.42,17.72) v4(60.54,18.48) v4(60.92,18.23)
+VCC1.05_OUT_FET: length 68.1
  TOP w0.508: 147.92,65.68 147.58,66.02 147.58,66.83 146.9,67.51 v1(145.38,67.51) 142.43,67.51 v2(142.08,67.15) ; v5(88.23,61.16) 88.23,61.64 88.46,61.87 R123.1
  IN1 w0.508: v5(88.23,61.16) 90.59,58.79 98.9,58.79 99.12,58.56 100.39,58.56 100.95,58.01 103.06,58.01 108.47,63.42 109.59,63.42 112.56,66.39 121.5,66.39 122.47,67.35 140.47,67.35 141.15,66.67 141.87,66.67 142.08,66.87 v2(142.08,67.15)
  vias: v2(151.68,58.59) v2(151.68,58.18) v3(151.68,58.59) v3(151.68,58.18) v4(151.68,58.59) v4(151.68,58.18) v5(149.26,65.7)
+VCC1.05_OUT_PCH: length 1.7
  IN1 w0.254: v3(164.47,44.85) 163.93,45.4 v2(163.4,45.4)
  IN3 w0.254: v3(164.47,44.85) v4(164.78,45.16)
+VCC1P05_OUTPUT_PLL: length 4.5
  BOTTOM w0.127: v1(153.61,62.68) 153.28,62.35 CC148.1
  BOTTOM w0.254: UC1.CD2 UC1.CD1 153.27,60.9 153.28,60.91 CC147.1 CC148.1
+VCC1P8A: length 5.8
  TOP w0.127: v4(145.28,60.27) 146.06,59.48 v6(147.54,59.48)
  BOTTOM w0.127: 146.62,54.86 146.5,54.86 UC1.BJ9 ; 146.04,54.86 146.14,54.86 UC1.BJ9 ; UC1.BJ9 146.04,55.31 ; UC1.BJ9 146.59,55.31 ; 147.31,55.34 147.31,55.11 UC1.BM9 147.05,54.86 146.95,54.86 ; UC1.BG9 145.62,55.26 ; UC1.BG9 145.2,55.24 ; UC1.BG9 145.59,54.86 145.71,54.86
  vias: v4(145.76,55.31) v4(146.01,55.31) v4(146.65,55.31) v4(146.9,55.31) v4(149.06,58.11) v4(149.7,58.11) v4(150.41,58.34) v4(150.41,58.08)
+VCC1P8A_R:
  vias: v1(143.98,64.03)
+VCC1V8_TBT_L_LDO: length 2.1
  BOTTOM w0.203: 27.81,40.02 UPD1.35
  BOTTOM w0.254: CPD6.1 27.81,41.29 27.81,40.02
+VCC1V8_TBT_R_LDO: length 3.8
  TOP w0.127: CPD16.1 262.9,44.34 262.9,44.72 v1(263.36,45.18)
  TOP w0.203: UPD2.35 262.6,42.41
  TOP w0.254: CPD16.1 262.6,43.63 262.6,42.41
+VCC3V3_TBT_L_LDO: length 96.2
  TOP w0.508: 35.22,33.55 36.23,34.56 36.23,38.75 34.48,40.51 32.35,40.51 v4(32.02,40.84) v1(32.02,43.68) 32.02,45.43 v2(33.85,47.26) ; v5(5.55,39.24) 9.27,39.24 11.07,37.43 19.72,37.43 23.43,33.72 v3(23.97,33.72) 23.97,33.52 24.55,32.93 v3(30.06,32.93) 34.2,32.93 34.25,32.98
  IN1 w0.508: v5(38.32,61.79) 38.16,61.64 v5(38.16,48.4) 37.02,47.26 v2(33.85,47.26)
  IN2 w0.508: v3(30.06,32.93) 29.27,32.93 28.13,31.79 v4(28.13,30.69)
  IN3 w0.508: v4(23,32.36) 23,32.96 23.76,33.72 v3(23.97,33.72)
  BOTTOM w0.254: RT169.2 32.34,64.15 35.95,64.15 v5(38.32,61.79)
  BOTTOM w0.381: v4(32.02,40.84) RPD183.2 RPD129.2
  BOTTOM w0.508: v5(38.16,48.4) 38.16,49.7 38.32,49.85 RPD11.1 37.81,50.36 37.61,50.16 37.25,50.16 RPD12.1 RPD14.1 ; v5(38.32,61.79) CPD1.1 ; CPD1.1 RPD13.1 ; CPD1.1 38.35,60.99 38.35,60.65 38.73,60.27 UPD3.8 ; 22.59,30.55 22.59,30.27 24.61,28.26 RPD92.1 ; RTCD4.2 4.99,38.68 v5(5.55,39.24)
+VCC3V3_TBT_R_LDO: length 431.7
  TOP w0.254: v4(268.72,35.68) 268.49,35.45 268.49,34.49 268.21,34.2 268.03,34.2 ; RPD168.2 267.4,34.46 267.66,34.2 268.03,34.2 ; 268.03,34.2 268.03,33.73 RPD99.1 ; RPD102.1 v2(263.06,30.78)
  TOP w0.305: v5(276.19,45.69) 276.58,46.08 JDB2.1
  TOP w0.381: v3(259.81,46.82) v1(258.68,45.7) 257.92,44.94 257.92,43.94 258.18,43.68 RPD184.2 RPD137.2
  TOP w0.508: v5(232.32,2.81) 232.32,4.08 231.61,4.8 199.34,4.8 197.83,3.29 v2(197.83,3.19) ; v5(94.45,10) 93.94,10.51 41.47,10.51 v2(41.29,10.33) ; v2(171.8,3.94) 171.8,3.99 172.2,4.4 172.2,8.35 169.91,10.63 v2(169.91,11.75)
  IN1 w0.254: v2(263.06,30.78) 263.06,30.8 262.68,31.18 262.68,32.12 v3(262.22,32.58)
  IN1 w0.508: v2(169.91,11.75) 171.18,13.02 v3(171.18,13.58) ; v2(41.29,10.33) 40.02,11.6 36.74,11.6 35.02,13.33 35.02,16.05 34.01,17.05 33.85,17.05 32.46,18.45 29.54,18.45 29.18,18.08 23.97,18.08 23.58,17.7 21.12,17.7 20.24,18.58 20.24,27.43 18.69,28.98 18.69,30.52 16.91,32.3 13.83,32.3 12.54,33.6 12.51,33.6 12.49,33.62 12.49,35.22 9.86,37.84 9.6,37.84 9.29,38.15 9.04,38.4 v4(6.64,38.4) ; v3(262.22,32.58) 262.22,32.99 v2(262.27,33.04) ; v2(197.83,3.19) 197.83,2.6 196.68,1.44 173.31,1.44 171.8,2.95 v2(171.8,3.94)
  IN2 w0.508: v5(232.32,2.81) 241.92,2.81 243.14,1.59 250.2,1.59 256.27,7.66 256.27,12.88 260.95,17.55 260.95,22.04 265.62,26.71 265.62,33.22 267.21,34.82 267.86,34.82 v4(268.72,35.68) 268.62,35.78 268.01,35.78 265.55,38.24 265.55,40.45 263.16,42.84 263.16,43.81 260.14,46.82 v3(259.81,46.82) ; v3(171.18,13.58) 170.69,14.08 170.69,16.56 168.7,18.55 168.7,22.94 165.79,25.85 115.78,25.85 114.94,25.01 112,25.01 110.4,23.41 105.74,23.41 104.53,22.2 101.99,22.2 97.14,17.36 97.14,12.62 94.53,10 v5(94.45,10)
  IN3 w0.508: v4(260.29,29.28) 260.29,29.38 261.18,30.27 261.18,32.2 261.56,32.58 v3(262.22,32.58) ; 245.71,12.84 245.71,13.71 245.35,14.06 245.35,17.24 246.39,18.28 247.68,18.28 v4(249.13,19.73)
  BOTTOM w0.508: v4(249.13,19.73) 249.32,19.73 249.35,19.76 UPD4.8 249.35,22.07 CPD11.1 248.72,23.26 RPD61.1 248.67,23.65 248.59,23.73 RT170.2 248.59,25.58 250.43,27.42 258.43,27.42 v4(260.29,29.28) 260.29,30.8 260.78,31.29 260.78,33.92 261.61,34.75 267.87,34.75 268.72,35.61 v4(268.72,35.68) 269.04,36 269.55,36 275.4,41.85 275.4,44.9 v5(276.19,45.69)
  vias: v4(245.66,12.16) v4(245.68,11.83) v4(245.94,12.01)
+VCC_SFR_OC:
  vias: v6(154.47,32.56)
+VCC_SFR_OC_R: length 1.9
  BOTTOM w0.069: UC27.6 150.74,28.56 v1(150.86,28.44)
+VCCA_CLKLDO_1P8:
  vias: v1(174.64,51.35)
+VCCDPHY_1P24: length 2.6
  BOTTOM w0.254: CC184.1 172.5,43.56 171.92,44.14 170.6,44.14 UC1.DW32
+VCCDSW_1P05: length 1.3
  IN1 w0.254: v3(162.81,42.59) 162.52,42.3 v2(162.52,42.28)
  IN3 w0.254: v4(162.54,42.86) v3(162.81,42.59)
  BOTTOM w0.254: UC1.DD34 v4(162.54,42.86)
+VCCIN: length 100.8
  IN3 w0.254: v4(99.96,62.6) 99.96,59.86 100.19,59.63 100.19,58.84 100.82,58.21 100.82,56.36 v4(105.8,51.38)
  BOTTOM w0.127: 150.66,54.35 UC1.BW10 ; UC1.BW10 150.23,54.78 ; UC1.BW10 150.64,54.78 ; UC1.BW10 150.26,54.4 150.15,54.4 ; UC1.CN35 157.34,42.42 ; UC1.CN35 157.4,42.05 157.21,42.05 ; UC1.CN35 157.78,42.44 ; UC1.CN35 157.71,42.05 157.9,42.05 ; UC1.K24 127.13,46.99 ; UC1.K24 126.72,47.03 126.71,47.03 ; UC1.K24 126.71,47.41 ; UC1.K24 127.13,47.44 v5(127.13,47.66) 127.13,47.91 UC1.K23 ; 154.34,43.07 UC1.CG34 ; UC1.CG34 154.78,42.64 ; UC1.CG34 154.77,43.07 ; UC1.CG34 154.34,42.65 ; 159.03,42.56 UC1.CT35 159.68,42.51 ; 154.76,42.41 UC1.CG35 154.36,42.41 ; UC1.BP9 147.69,54.58 UC1.BN10 147.92,54.35 147.92,54.35 UC1.BP11 ; UC1.BP9 148.39,55.28 v5(148.62,55.28) ; UC1.BP9 148.35,54.84 ; UC1.BP9 147.95,55.24 ; 126.05,49.9 UC1.J20 ; UC1.K17 126.69,51.1 ; UC1.K17 126.72,50.69 126.71,50.69 ; UC1.K17 127.14,51.11 ; UC1.K17 127.22,50.57 ; UC1.CE11 153.43,54.32 ; UC1.CE11 153.38,53.86 ; UC1.CE11 153.85,54.32 ; UC1.CE11 153.87,53.88 ; 149.72,54.78 UC1.BU10 ; UC1.BU10 149.32,54.37 ; UC1.BU10 149.32,54.78 ; UC1.BU10 149.7,54.4 149.8,54.4 ; UC1.CF10 153.89,54.37 ; UC1.CF10 154.29,54.38 ; UC1.CF10 153.94,54.73 153.76,54.73 ; UC1.CF10 154.25,54.73 154.45,54.73 ; UC1.BR10 148.4,54.37 ; UC1.BR10 148.81,54.38 ; UC1.BR10 148.81,54.78 ; UC1.BR10 148.4,54.78 ; UC1.J26 126.33,46.88 126.33,47.08 ; UC1.J26 126.65,46.55 ; UC1.J26 126.24,46.55 ; UC1.J26 126.64,46.96 ; UC1.J18 126.66,50.63 126.66,50.63 ; UC1.J18 126.23,50.64 ; UC1.J18 126.66,50.21 ; UC1.J18 126.23,50.21 ; 151.47,41.67 151.65,41.67 UC1.CA36 ; 126.63,48.79 126.63,48.78 UC1.J22 ; UC1.BP11 148.35,53.91 ; UC1.BP11 148.35,54.32 ; 152.52,54.32 UC1.CC11 ; UC1.CC11 152.45,53.84 ; UC1.CC11 152.98,53.86 ; UC1.CC11 152.92,54.31 ; UC1.CA9 152.01,54.84 ; UC1.CA9 151.59,55.26 ; UC1.CA9 152.06,55.29 ; UC1.CA9 151.6,54.83 ; 126.71,46.5 UC1.K27 ; UC1.K27 127.16,46.05 ; UC1.K27 127.13,46.53 v5(127.13,46.77) 127.13,46.8 ; UC1.K27 126.72,46.12 126.71,46.12 ; UC1.BV36 149.92,41.78 149.64,41.78 ; UC1.BV36 149.79,42.03 ; UC1.BV36 150.14,41.67 150.31,41.67 ; UC1.BV36 150.18,42.03 ; UC1.CB10 152.06,54.78 ; UC1.CB10 152.06,54.37 ; UC1.CB10 152.46,54.38 ; UC1.CB10 152.46,54.78 ; UC1.CJ34 155.5,42.64 ; UC1.CJ34 155.93,43.07 ; UC1.CJ34 155.51,43.07 ; UC1.CJ34 155.94,42.64 ; 155.36,54.73 155.16,54.73 UC1.CH10 ; 132.14,52.9 UC1.AA12 ; UC1.AA12 132.14,53.66 ; UC1.AA12 132.52,53.28 ; UC1.AA12 131.76,53.28 ; 155.49,42.44 UC1.CJ35 155.92,42.41 ; 131.01,53.48 UC1.W12 ; UC1.W12 131.03,53.08 ; UC1.W12 131.43,53.48 ; UC1.W12 131.42,53.08 ; UC1.K23 127.19,48.42 ; UC1.K23 126.71,48.33 ; UC1.K23 126.71,47.93 ; UC1.J23 126.33,47.56 126.33,47.34 ; UC1.J23 126.63,47.86 126.63,47.87 ; UC1.J23 126.22,47.9 ; UC1.J23 126.66,47.46 ; UC1.BV9 149.77,54.83 ; UC1.BV9 150.23,55.29 ; UC1.BV9 150.18,54.84 ; UC1.BV9 149.76,55.26 ; 155.26,54.32 UC1.CJ11 ; UC1.CJ11 155.22,53.87 ; UC1.CJ11 155.72,53.87 ; UC1.CJ11 155.68,54.32 ; 130.6,53.1 130.6,52.98 UC1.V13 ; UC1.BT9 148.86,54.83 ; UC1.BT9 148.82,55.28 ; UC1.BT9 149.28,55.26 ; UC1.BT9 149.26,54.84 ; UC1.BW9 150.7,55.24 ; UC1.BW9 151.09,54.84 ; UC1.BW9 151.09,55.24 ; UC1.BW9 150.69,54.83 ; UC1.K31 127.16,44.72 ; UC1.K31 127.14,44.24 ; UC1.K31 126.71,44.67 ; UC1.K31 126.71,44.27 ; UC1.CL34 156.44,42.66 ; UC1.CL34 156.85,43.07 ; UC1.CL34 156.83,42.66 ; UC1.CL34 156.43,43.07 ; 158.13,42.05 158.31,42.05 UC1.CR35 ; UC1.AB13 132.81,53.03 ; UC1.AB13 132.81,52.6 ; UC1.AB13 132.35,52.57 ; UC1.AB13 132.38,53.03 ; UC1.CF33 153.89,43.53 ; UC1.CF33 153.9,43.12 ; UC1.CF33 154.29,43.13 ; UC1.CF33 154.3,43.53 ; UC1.CT34 159.58,43.06 ; UC1.CT34 159.17,43.07 ; UC1.CT34 159.58,42.66 ; UC1.CT34 159.2,42.68 159.2,42.66 ; UC1.CC9 152.5,55.26 ; UC1.CC9 152.52,54.83 ; UC1.CC9 152.93,54.83 ; UC1.CC9 152.95,55.26 ; 152.48,42.08 UC1.CC36 ; UC1.CC36 152.95,42.05 ; UC1.CC36 152.57,41.67 152.39,41.67 ; UC1.CC36 152.89,41.67 153.05,41.67 ; UC1.CL35 156.79,42.05 157.01,42.05 ; UC1.CL35 156.44,42.41 ; UC1.CL35 156.86,42.43 ; 155.72,54.37 UC1.CK10 155.77,54.73 155.59,54.73 ; UC1.CH10 154.81,54.37 ; UC1.CH10 154.86,54.73 154.67,54.73 ; UC1.CH10 155.21,54.38 ; 153.38,41.95 UC1.CE35 ; UC1.CE35 153.44,42.41 ; UC1.CE35 153.84,42.41 ; UC1.V13 130.98,52.6 ; UC1.V13 130.6,52.65 130.6,52.52 ; UC1.V13 130.98,53.03 ; UC1.CD10 153.38,54.38 ; UC1.CD10 152.98,54.37 ; UC1.CD10 152.98,54.78 ; UC1.CD10 153.4,54.8 ; UC1.K21 126.71,49.24 ; UC1.K21 127.19,48.76 ; UC1.K21 126.7,48.84 ; UC1.K21 127.13,49.27 ; UC1.J28 126.24,45.64 ; UC1.J28 126.65,45.64 ; UC1.J28 126.23,46.06 ; UC1.J28 126.64,46.04 ; 126.65,44.72 UC1.J30 ; UC1.J30 126.64,45.13 ; UC1.J30 126.33,44.81 126.33,44.57 ; UC1.J30 126.3,44.93 126.15,45.08 ; 126.73,43.83 126.63,43.83 UC1.J32 ; UC1.BW36 150.74,41.67 150.56,41.67 ; UC1.BW36 150.7,42.03 ; UC1.BW36 151.09,42.03 ; UC1.BW36 151.06,41.67 151.22,41.67 ; UC1.CR35 158.69,42.43 ; UC1.CR35 158.24,42.44 ; UC1.CT33 158.72,43.53 ; UC1.CT33 159.13,43.53 ; UC1.CT33 159.12,43.13 ; UC1.CT33 158.72,43.12 ; UC1.AC12 132.86,53.08 ; UC1.AC12 133.29,53.04 ; UC1.AC12 132.84,53.48 ; UC1.AC12 133.26,53.48 ; 126.71,45.59 UC1.K29 ; UC1.K29 127.16,45.64 v5(127.16,45.86) ; UC1.K29 126.7,45.18 ; UC1.K29 127.16,45.14 ; UC1.CN34 157.32,42.63 ; UC1.CN34 157.75,43.06 ; UC1.CN34 157.8,42.61 ; UC1.CN34 157.34,43.07 ; UC1.BY10 151.58,54.35 ; UC1.BY10 151.15,54.78 ; UC1.BY10 151.14,54.37 ; UC1.BY10 151.55,54.78 ; UC1.J32 126.63,44.2 126.63,44.21 ; UC1.J32 126.33,44.13 126.33,44.37 ; 158.66,43.06 UC1.CR34 ; UC1.CR34 158.69,42.64 ; UC1.CR34 158.26,43.07 ; UC1.CR34 158.24,42.64 ; 154.32,53.88 UC1.CG11 ; UC1.CG11 154.8,53.87 ; UC1.CG11 154.35,54.32 ; UC1.CG11 154.75,54.31 ; 151.56,42.08 UC1.CA36 ; UC1.CA36 152.03,42.05 ; UC1.CA36 151.97,41.67 152.13,41.67 ; UC1.J22 126.23,48.37 ; UC1.J22 126.66,48.38 ; UC1.J22 126.33,48.71 126.33,48.91 ; UC1.CP33 157.8,43.53 ; UC1.CP33 158.21,43.53 ; UC1.CP33 157.81,43.12 ; UC1.CP33 158.21,43.13 ; UC1.CE34 153.43,42.65 ; UC1.CE34 153.43,43.07 ; UC1.CE34 153.84,43.06 ; UC1.CE34 153.84,42.66 ; UC1.Y13 131.9,52.6 ; UC1.Y13 131.46,52.6 ; UC1.Y13 131.89,53.03 ; UC1.Y13 131.47,53.03 ; UC1.BT11 149.26,54.31 ; UC1.BT11 148.86,54.32 ; UC1.BT11 148.86,53.91 ; 159.6,43.55 159.61,43.55 UC1.CU33 159.91,43.25 159.91,42.94 ; 127.3,49.57 UC1.K19 127.3,50.36
  BOTTOM w0.203: UC1.AB1 v5(132.53,59.22) ; UC1.U1 130.05,59.13 129.98,59.2 v5(129.86,59.2) ; UC1.M1 127.58,59.02 v5(127.73,59.16)
  BOTTOM w0.254: PR1119.1 100.94,67.33 101.56,67.33 101.79,67.09 101.79,63.97 100.42,62.6 v4(99.96,62.6) ; v5(125.29,59.12) 125.07,58.91 UC1.G1
  vias: v2(116.65,46.12) v2(116.91,46.12) v2(117.18,46.12) v2(117.92,46.12) v2(118.05,50.18) v2(118.18,46.12) v2(118.31,50.18) v2(118.45,46.12) v2(118.58,50.18) v2(119.19,46.12) v2(119.27,50.18) v2(119.45,46.12) v2(119.52,50.18) v2(119.72,46.12) v2(119.8,50.18) v3(106.31,51.38) v3(106.82,51.38) v3(107.33,51.38) v3(107.84,51.38) v3(108.93,51.38) v3(109.44,51.38) v3(109.44,32.28) v3(109.95,51.38) v3(109.95,32.28) v3(110.45,51.38) v3(110.45,32.28) v3(110.96,51.38) v3(110.96,32.28) v3(111.52,32.28) v3(115.71,52.9) v3(116.22,52.9) v3(116.73,52.9) v3(117.23,52.9) v3(117.74,52.9) v4(106.31,51.38) v4(106.82,51.38) v4(107.33,51.38) v4(107.84,51.38) v4(108.93,51.38) v4(109.44,51.38) v4(109.44,32.71) v4(109.44,31.67) v4(109.95,51.38) v4(109.95,32.71) v4(109.95,31.67) v4(110.45,51.38) v4(110.45,32.71) v4(110.45,31.67) v4(110.96,51.38) v4(110.96,32.71) v4(110.96,31.67) v4(111.52,32.71) v4(111.49,31.69) v4(115.71,52.9) v4(116.22,52.9) v4(116.73,52.9) v4(116.68,46.11) v4(116.93,46.11) v4(117.23,52.9) v4(117.18,46.11) v4(117.74,52.9) v4(117.95,46.11) v4(118.2,46.11) v4(118.45,46.11) v4(119.24,46.11) v4(119.5,46.11) v4(119.75,46.11) v5(105.63,38.04) v5(105.63,37.03) v5(105.63,36.14) v5(106.01,39.82) v5(106.01,38.8) v5(106.26,40.84) v5(106.77,38.04) v5(106.77,37.03) v5(106.77,36.14) v5(107.15,39.82) v5(107.15,38.8) v5(107.41,40.84) v5(107.79,38.04) v5(107.79,37.03) v5(107.79,36.14) v5(108.29,39.82) v5(108.29,38.8) v5(108.55,47.95) v5(108.55,46.93) v5(108.55,45.92) v5(108.55,44.9) v5(108.55,43.88) v5(108.55,42.99) v5(108.55,41.85) v5(108.55,40.84) v5(108.65,32.58) v5(108.73,37.08) v5(108.73,36.19) v5(108.73,35.3) v5(108.73,34.41) v5(108.73,33.52) v5(108.93,38.04) v5(109.44,39.82) v5(109.44,38.8) v5(109.51,36.11) v5(109.59,37.08) v5(109.59,35.3) v5(109.69,47.95) v5(109.69,46.93) v5(109.69,45.92) v5(109.69,44.9) v5(109.69,43.88) v5(109.69,42.99) v5(109.69,41.85) v5(109.69,40.84) v5(109.74,34.41) v5(109.74,33.52) v5(109.92,38.14) v5(110.43,38.91) v5(110.71,39.82) v5(110.66,33.39) v5(110.96,47.95) v5(110.96,46.93) v5(110.96,45.92) v5(110.96,44.9) v5(110.96,43.88) v5(110.96,42.99) v5(110.96,41.85) v5(110.96,40.84) v5(111.7,40.23) v5(112.1,48.96) v5(112.1,47.95) v5(112.1,46.93) v5(112.1,45.92) v5(112.1,44.9) v5(112.1,43.88) v5(112.1,42.99) v5(112.1,41.85) v5(112.1,40.84) v5(113.37,48.96) v5(113.37,47.95) v5(113.37,46.93) v5(113.37,45.92) v5(113.37,44.9) v5(113.37,43.88) v5(113.37,42.99) v5(114.52,48.96) v5(114.52,47.95) v5(114.52,46.93) v5(114.52,45.92) v5(114.52,44.9) v5(114.52,43.88) v5(114.52,42.99) v5(115.53,48.96) v5(115.53,47.95) v5(115.53,46.93) v5(115.53,45.92) v5(115.53,44.9) v5(115.53,43.88) v5(115.53,42.99) v5(116.65,46.86) v5(116.68,49.09) v5(117.31,49.09) v5(117.29,46.86) v5(117.95,49.09) v5(117.92,46.86) v5(118.58,49.09) v5(118.56,46.86) v5(119.22,49.09) v5(119.19,46.86) v5(119.85,49.09) v5(119.83,46.86) v5(120.49,49.09) v5(120.49,48.07) v5(120.88,48.56) v5(120.87,47.44) v5(121.12,49.09) v5(121.25,48.07) v5(121.5,47.44) v5(121.62,48.56) v5(121.75,45.81) v5(122.41,50.46) v5(122.39,46.75) v5(122.41,45.83) v5(123.07,50.46) v5(123.07,46.75) v5(123.07,45.86) v5(123.7,50.46) v5(123.71,49.5) v5(123.73,46.75) v5(123.7,45.83) v5(124.37,47.67) v5(124.36,46.75) v5(124.35,45.84) v5(125.02,46.75) v5(125.02,45.83) v5(125.67,46.75) v5(125.68,45.83) v5(127.22,50.49) v5(127.16,44.92) v5(130.9,52.27) v5(131.54,52.27) v5(132.17,52.27) v5(132.81,52.27) v5(148.16,53.55) v5(148.62,53.91) v5(149.05,53.53) v5(149.54,55.26) v5(149.94,42.45) v5(150.56,42.44) v5(151.19,42.44) v5(151.85,53.47) v5(151.82,42.45) v5(152.29,53.84) v5(152.48,42.71) v5(152.74,53.47) v5(152.86,43.45) v5(153.07,42.84) v5(153.07,42.25) v5(153.17,53.86) v5(153.5,43.42) v5(153.62,53.47) v5(154.08,53.88) v5(154.11,42.58) v5(154.49,53.45) v5(154.98,53.87) v5(155.1,42.56) v5(155.39,53.46) v5(156.16,42.67) v5(158.96,42.56) v5(159.78,42.51) v6(131.23,47.16)
+VCCIN_AUX: length 63.7
  IN2 w0.254: v5(188.48,70.43) 187.9,70.43 182.23,64.76 182.23,60.8 184.75,58.29 186.45,58.29 v5(186.65,58.49)
  IN3 w0.254: v5(188.48,70.43) 188.48,71.1 189.98,72.6 190.67,72.6 192.34,74.27 192.36,74.27 v4(192.6,74.5) ; v3(160.52,59.3) 160.26,59.05 v4(160.21,59.05)
  BOTTOM w0.127: UC1.P13 128.88,52.54 ; UC1.P13 128.4,52.52 ; UC1.P13 128.4,53.03 ; UC1.P13 128.87,52.99 ; 159.38,53.87 UC1.CT11 ; UC1.CT11 159.32,54.31 ; UC1.CT11 158.92,54.32 ; UC1.CT11 158.88,53.87 ; 160.72,53.88 UC1.CY11 ; UC1.CY11 161.23,53.85 ; UC1.CY11 160.75,54.32 ; UC1.CY11 161.19,54.35 ; 159.91,54.73 159.74,54.73 UC1.CU10 ; UC1.DE12 163.74,53.72 ; UC1.DE12 163.69,53.25 ; UC1.DE12 163.26,53.24 ; UC1.DE12 163.26,53.68 ; 142.89,54.81 UC1.BB9 ; UC1.BB9 142.43,55.26 ; UC1.BB9 142.46,54.84 ; 157.42,54.73 157.6,54.73 UC1.CN10 ; UC1.CL10 156.38,54.12 UC1.CK11 ; UC1.CL10 156.69,54.73 156.53,54.73 ; UC1.CL10 157.04,54.38 ; UC1.CL10 156.99,54.73 157.16,54.73 ; v5(140.37,53.86) 140.17,53.86 UC1.AT11 ; UC1.CR10 158.52,54.73 158.33,54.73 ; UC1.CR10 158.82,54.73 159.02,54.73 ; UC1.CR10 158.87,54.38 ; UC1.CN10 157.96,54.37 ; UC1.CN10 157.54,54.37 ; UC1.CN10 157.91,54.73 158.13,54.73 ; 162.58,54.32 UC1.DC11 ; UC1.DC11 163.02,54.35 ; UC1.DC11 162.52,53.85 162.52,53.85 ; UC1.DC11 163.03,53.87 ; UC1.CK11 156.63,53.87 ; UC1.CK11 156.12,53.85 ; 140.17,54.78 UC1.AU10 ; UC1.AU10 140.57,54.78 ; UC1.AU10 140.6,54.35 ; UC1.AU10 140.17,54.38 ; 130.04,53.46 130.12,53.46 UC1.U12 130.32,53.27 130.32,52.88 ; UC1.AY11 141.97,53.88 v5(142.19,53.88) ; UC1.AY11 141.54,54.32 ; UC1.AY11 141.95,54.32 ; UC1.CW10 160.65,54.73 160.82,54.73 ; UC1.CW10 160.35,54.73 160.19,54.73 ; UC1.CW10 160.69,54.38 ; UC1.CW10 160.31,54.39 160.31,54.37 ; 159.86,54.32 159.86,54.3 UC1.CV11 ; UC1.AV9 141.03,54.83 ; UC1.AV9 140.6,55.26 ; UC1.AV9 140.63,54.84 ; UC1.AV9 141.05,55.26 ; 141.54,54.84 UC1.AY9 ; UC1.AY9 141.52,55.26 ; UC1.AY9 141.97,55.26 ; UC1.AY9 141.95,54.83 ; UC1.AT11 140.12,54.32 ; UC1.AT11 139.69,54.34 ; UC1.AT11 139.63,53.83 v5(139.5,53.83) ; 141.09,54.78 UC1.AW10 ; UC1.AW10 141.49,54.37 ; UC1.AW10 141.49,54.78 ; UC1.CP11 158.01,54.32 ; UC1.CP11 158.46,53.87 ; UC1.CP11 157.99,53.89 ; 157.11,54.32 157.11,54.3 UC1.CM11 ; 157.6,53.82 UC1.CM11 ; UC1.CM11 157.04,53.85 ; UC1.CM11 157.49,54.31 ; UC1.R12 129.59,53.08 ; UC1.R12 129.57,53.46 129.66,53.46 ; UC1.R12 129.21,53.46 129.1,53.46 ; UC1.R12 129.15,53.03 ; 159.27,54.73 159.43,54.73 UC1.CU10 ; UC1.DF12 163.89,53.7 ; UC1.DF12 163.9,53.22 ; UC1.DF12 164.35,53.24 ; UC1.DF12 164.38,53.71 ; 130.24,52.42 UC1.T13 129.45,52.42 ; 159.8,53.87 UC1.CV11 ; UC1.CV11 160.32,53.84 160.32,53.84 ; UC1.CV11 160.24,54.31 160.24,54.31 ; 140.12,54.83 UC1.AT9 ; UC1.AT9 140.14,55.26 140.14,55.26 ; UC1.AT9 139.69,55.26 139.69,55.26 ; UC1.AT9 139.69,54.81 ; UC1.CU10 159.38,54.37 ; UC1.CU10 159.79,54.37 ; 142,54.78 142,54.78 UC1.BA10 ; 142.4,54.37 UC1.BA10 ; UC1.BA10 142,54.37 ; UC1.BA10 142.4,54.78
  BOTTOM w0.203: UC1.DC1 162.49,59.15 162.19,59.45 160.47,59.45 160.21,59.2 v4(160.21,59.05) 160.21,58.89 UC1.CV1 ; v5(154.75,59.32) 154.75,59.01 UC1.CH1 ; v5(157.9,59.4) 157.9,59.35 157.55,59 UC1.CN1
  BOTTOM w0.254: v5(188.48,70.43) 188.91,70.86 PR903.1
  vias: v5(128.61,52.27) v5(129.25,52.27) v5(129.88,52.27) v5(136.97,60.24) v5(137.05,59.68) v5(137.53,60.14) v5(137.61,59.58) v5(138.06,59.91) v5(139.94,53.48) v5(141.76,53.48) v5(157.34,53.46) v5(157.97,53.45) v5(158.53,53.45) v5(159.1,53.45) v5(159.7,53.45) v5(160.28,53.45) v5(160.85,53.46) v5(182.72,61.28) v5(182.97,64.51) v5(182.97,61.92) v5(183.1,62.55) v5(183.35,60.8) v5(183.48,64.97) v5(183.48,61.41) v5(183.61,62.04) v5(183.88,60.29) v5(183.99,65.47) v5(183.99,60.9) v5(184.11,61.54) v5(184.39,59.78) v5(184.49,65.98) v5(184.49,60.39) v5(184.62,61.03) v5(185,59.89) v5(185.13,60.52) v5(185.43,59.43) v5(185.64,60.01) v5(185.76,60.65) v5(186.15,59.5) v5(186.09,58.95) v5(186.53,60.01) v5(186.73,59.07) v5(187.03,60.39) v5(187.11,57.93) v5(187.16,59.76) v5(187.24,58.56) v5(187.62,57.42) v5(187.75,58.06) v5(187.8,60.27) v5(188.13,56.91) v5(188.25,57.55) v5(188.63,56.41) v5(188.76,57.04) v5(189.14,55.9) v5(189.27,56.53) v5(189.65,55.39) v5(189.78,56.02) v5(190.16,56.91) v5(190.16,54.88) v5(190.29,56.28) v5(190.29,55.64) v6(139.97,52.6)
+VCCIO_OUT: length 236.4
  TOP w0.254: R178.1 R274.1 107.02,60.6 110.15,57.47 110.15,54.93 110.35,54.73 v2(110.35,54.32) ; R164.2 v3(96.74,61.37) 97.42,61.37 97.47,61.42 R165.2 R166.2 99.99,61.42 R167.2 v2(100.04,60.67) 100.04,58.31 ; R164.2 96.23,61.05 96.41,60.88 96.41,59.35 95.92,58.87 95.92,49.09 96.46,48.56 96.46,46.96 96.17,46.66 R161.1 95.8,46.66 95.72,46.59 R160.1 ; R164.2 R163.2 R162.2 ; 100.04,58.31 99.59,57.87 v5(99.59,57.85) ; 100.04,58.31 101.28,58.31 103.29,56.3 104.1,56.3 108.37,52.04 108.37,49.14 108.75,48.76 109.75,48.76 R168.1 R169.1 R170.1 ; R175.2 R174.2 103.91,61.37 103.73,61.19 103.73,60.77 104.85,59.66 105.12,59.66 v2(108.9,55.87) ; R171.2 102.58,60.7 v2(103.29,59.99) 103.38,59.99 104.52,58.85 104.66,58.85 v2(108.08,55.44) 108.08,55.36 v2(109.31,54.12) 109.36,54.12 110.17,53.31 116.3,53.31 117.73,54.74 R172.1 R173.1 119.18,54.68 121.58,54.68 v1(121.91,55.01) 122.22,55.32 v2(130.05,55.32) RC724.1
  IN1 w0.254: v3(133.82,55.42) 133.67,55.42 133.51,55.25 130.45,55.25 130.39,55.32 v2(130.05,55.32) ; v2(103.29,59.99) 101.18,59.99 100.5,60.67 v2(100.04,60.67) ; v2(109.31,54.12) 110.15,54.12 v2(110.35,54.32) ; v2(92.08,75.13) 93.6,73.6 97.19,73.6 v3(97.6,74.01) 98,73.6 100,73.6 100.42,74.03 v2(100.42,74.4) ; v2(108.9,55.87) 108.41,55.87 108.08,55.54 v2(108.08,55.44)
  IN2 w0.254: v4(158.51,26.92) 115.81,26.92 114.44,25.54 111.85,25.54 110.78,24.48 108.19,24.48 107.92,24.75 100.92,24.75 100.07,25.6 96.23,25.6 88.94,32.88 88.94,49.11 93.61,53.78 93.61,55.89 95.29,57.57 99.3,57.57 99.58,57.85 v5(99.59,57.85) ; v3(97.6,74.01) 96.99,73.4 96.99,66.62 96.58,66.21 96.58,64.48 96.94,64.13 96.94,62.88 96.74,62.68 v3(96.74,61.37)
  IN3 w0.254: v4(133.51,55.69) 133.55,55.69 v3(133.82,55.42)
  BOTTOM w0.254: QE15.1 155.99,29.06 158.13,26.92 v4(158.51,26.92)
+VCCLDOSTD_OUT_0P85: length 2.9
  BOTTOM w0.254: UC1.DW37 170.53,41.37 172.78,41.37 CC260.1 CC185.1
+VCCPFUSE_3P3: length 5.1
  TOP w0.381: v2(163.4,42.11) v1(164.02,42.11) 164.44,42.11 165.04,41.51 165.04,40.18 RC747.2
  IN1 w0.381: v2(163.4,42.11) v3(163.4,42.64)
  IN3 w0.254: v3(163.4,42.64) 162.72,43.32 v4(162.58,43.32)
+VCCPRIM_1P8: length 13.7
  IN3 w0.254: v4(163.96,42.86) 163.96,42.47 163.69,42.21 v4(163.04,42.21)
  BOTTOM w0.127: UC1.DG18 164.56,50.36 164.56,50.36 ; UC1.DG18 165,50.36 165,50.36 ; UC1.DG18 165.01,49.91 ; UC1.DG18 164.56,49.91 164.56,49.91 ; 165.01,50.74 UC1.DG17 ; UC1.DG17 165.03,51.22 ; UC1.DG17 164.53,50.72 ; UC1.DG17 164.53,51.22 ; UC1.DF18 164.38,49.89 164.38,49.89 ; UC1.DF18 163.87,49.88 ; UC1.DF18 163.91,50.36 163.91,50.36 ; UC1.DF18 164.35,50.36 164.35,50.36 ; 164.51,49.04 UC1.DG20 ; UC1.DG20 165.05,49.04 ; UC1.DG20 164.52,49.57 ; UC1.DG20 164.99,49.52 ; UC1.DF20 164.4,49.04 ; UC1.DF20 164.39,49.57 ; UC1.DF20 163.89,49.07 ; UC1.DF20 163.84,49.6 ; UC1.DF17 163.88,51.22 ; UC1.DF17 164.35,50.75 ; UC1.DF17 163.87,50.71 ; UC1.DF17 164.38,51.22 ; UC1.DF15 164.37,52.04 ; UC1.DF15 163.87,51.54 ; UC1.DF15 164.38,51.55 ; UC1.DF15 163.89,52.04
  BOTTOM w0.254: v5(162.96,44.75) 162.96,43.46 163.32,43.11 163.71,43.11 v4(163.96,42.86)
  vias: v1(163.11,50.61) v2(162.4,51.07) v2(162.42,50.11) v2(162.45,49.34) v2(162.42,48.61) v2(162.9,51.07) v2(162.85,50.11) v2(162.85,49.6) v2(162.85,49.09) v2(162.85,48.58) v2(163.23,49.8) v3(162.4,51.07) v3(162.42,50.11) v3(162.45,49.34) v3(162.42,48.61) v3(162.9,51.07) v3(162.85,50.11) v3(162.85,49.6) v3(162.85,49.09) v3(162.85,48.58) v3(163.23,49.8) v3(177.64,51) v3(177.89,50.61) v3(178.14,51) v3(178.4,50.61) v3(178.65,51) v3(178.91,50.61) v3(179.16,51) v3(179.41,50.61) v3(179.67,51) v3(179.92,50.61) v4(162.4,51.07) v4(162.42,50.11) v4(162.45,49.34) v4(162.42,48.61) v4(162.9,51.07) v4(162.85,50.11) v4(162.85,49.6) v4(162.85,49.09) v4(162.85,48.58) v4(163.23,49.8) v4(177.69,50.24) v4(177.69,49.98) v4(177.95,50.24) v4(177.95,49.99) v4(177.89,49.6) v4(178.2,50.24) v4(178.2,49.99) v4(178.27,49.6)
+VCCPRTC_3P3: length 0.7
  IN1 w0.254: v2(165.44,43.28) v3(165.05,43.28)
  IN3 w0.254: v4(164.78,43.5) 164.79,43.5 165.01,43.28 v3(165.05,43.28)
  vias: v1(170.32,43.2)
+VCCST_CPU: length 0.8
  TOP w0.127: v3(152.36,62.04) v6(152.36,61.28)
  vias: v2(152.87,62.04) v3(152.87,62.04) v4(151.43,62.42) v4(151.43,61.78)
+VCCST_R: length 0.6
  TOP w0.069: 151.58,63.82 v1(151.58,64.38)
+VCCSTG_CPU: length 1.3
  BOTTOM w0.127: RC639.2 151.14,63.75 v6(151.93,63.75)
+VCCSTG_OUT: length 6.2
  BOTTOM w0.127: 131,42.99 UC1.V34 ; UC1.V34 130.96,42.56 ; UC1.V34 130.53,42.99 130.49,42.99 ; UC1.V34 130.55,42.54 ; 132.33,43.02 UC1.AB34 ; UC1.AB34 132.86,43.02 ; UC1.AB34 132.38,42.54 132.35,42.54 ; 130.6,42.13 130.47,42.13 UC1.U35 ; UC1.U35 130.17,42.16 129.99,42.16 ; UC1.U35 130.32,42.3 130.32,42.64 ; 129.4,42.66 129.39,42.66 UC1.R35 ; UC1.R35 129.64,42.29 129.76,42.18 ; UC1.R35 129.18,42.29 129.07,42.18 ; 130.04,42.56 UC1.T34 129.63,42.54
  BOTTOM w0.305: UC1.F33 v5(124.4,43.96) ; UC1.G33 125.08,43.91 v5(125.05,43.96)
  vias: v1(127.57,43.48) v5(129.76,43.38) v5(130.52,43.38) v5(131.15,43.38) v5(132.17,43.38)
+VCCSTG_OUT_LGC: length 5.5
  TOP w0.762: RC659.1 119.62,58.49 v1(121.48,58.49) 122.98,58.49 v3(124.45,57.02)
  vias: v4(124.45,57.02)
+VCCSTG_R: length 1.2
  BOTTOM w0.069: RC639.1 149.14,63.62 v1(148.3,63.62)
+VDDQ_MEM: length 54.3
  TOP w0.254: RD4.1 128.54,27.37 128.84,27.07 128.84,24.44 v2(128.43,24.02) 128.44,24.02 ; v2(146.85,24.02) 147.26,24.44 147.26,26.89 146.69,27.46 RD21.1 ; v2(160.43,24.02) 160.87,24.46 160.87,27.12 160.62,27.37 160.55,27.44 RD2.1 ; v2(130.83,24.02) 130.42,24.44 130.42,24.99 131.03,25.6 131.03,27.12 131.24,27.33 RD3.1 ; RD24.1 117.06,27.38 116.8,27.12 116.8,24.46 UD4.B8 ; RD1.1 162.61,27.33 162.4,27.12 162.4,24.46 v2(162.83,24.02) ; RD23.1 114.94,27.33 115.28,26.99 115.28,24.46 UD4.B5 ; UD1.U3 158.65,14.27 v3(158.51,14.42) ; RD22.1 149.06,27.37 148.81,27.12 148.81,24.46 UD2.B8
  IN1 w0.203: v2(156.86,13.05) v3(156.85,13.05)
  IN1 w0.254: v3(130.62,23.77) 130.62,23.81 v2(130.83,24.02) ; v2(160.43,24.02) 160.52,24.02 v3(160.72,24.22) ; v3(160.9,11.68) 160.9,11.67 v2(160.43,11.67) ; v3(119.27,11.37) 119.14,11.37 v2(118.84,11.67) ; v2(118.84,14.27) 118.85,14.27 119.1,14.03 119.13,14.03 119.16,14.05 v3(119.16,14.04) ; v3(147.3,11.66) 147.31,11.66 147.31,11.64 147.27,11.67 v2(146.85,11.67) ; v3(148.85,11.68) 148.85,11.67 v2(149.25,11.67) ; v3(115.1,22.98) v2(114.84,22.72) ; v2(126.83,11.67) v3(126.56,11.41) ; v3(147.24,12.66) 147.24,12.67 147.2,12.67 146.9,12.97 v2(146.85,12.97) ; v3(144.9,14.27) v2(145.24,14.27) ; v2(126.83,21.42) 126.63,21.23 v3(126.63,21.1) ; v2(158.83,24.02) 159.09,24.28 v3(159.09,24.33) ; v3(145.03,24.29) 145.24,24.07 v2(145.24,24.02) ; v2(146.85,24.02) v3(147.18,24.02) ; v3(132.12,21.15) 132.16,21.15 v2(132.43,21.42) ; v3(127.1,24.32) 126.83,24.05 v2(126.83,24.02) ; v2(125.23,12.97) v3(124.77,12.97) ; v2(132.43,11.67) 132.27,11.67 132.09,11.5 v3(132.09,11.47) ; v3(115.13,11.94) 115.11,11.94 v2(114.84,11.67) ; v2(117.24,12.97) 117.21,12.97 v3(116.78,12.55) ; v2(130.83,11.67) 130.83,11.67 v3(130.5,11.35) ; v2(164.43,24.02) 164.18,24.27 164.15,24.27 v3(164.11,24.24) ; v2(150.85,21.42) 150.64,21.21 150.64,21.14 v3(150.61,21.14) ; v2(158.83,21.42) 158.71,21.42 v3(158.48,21.2) ; v3(150.53,24.25) 150.51,24.25 150.55,24.29 150.58,24.29 v2(150.85,24.02) ; v3(162.42,24.07) 162.66,24.07 162.71,24.02 v2(162.83,24.02) ; v3(156.85,13.05) 157.15,13.05 v2(157.23,12.97) ; v2(132.43,24.02) 132.23,24.22 132.2,24.22 132.14,24.28 v3(132.15,24.28) ; v2(128.43,24.02) 128.87,24.02 128.89,24 v3(128.94,24) ; v3(116.78,11.97) 117.08,11.67 v2(117.24,11.67) ; v2(128.43,22.72) 128.93,22.72 v3(128.94,22.71) ; v3(129.23,12.93) 129.18,12.97 v2(128.43,12.97) ; v2(150.85,14.27) 150.85,14.32 v3(150.91,14.32) ; v3(131.14,12.67) 130.83,12.97 v2(130.83,12.97) ; v3(148.72,12.64) 148.75,12.64 149.09,12.97 v2(149.25,12.97) ; v2(162.83,22.72) 162.6,22.96 v3(162.44,22.96) ; v3(166.33,12.66) 166.03,12.95 v2(166.03,12.97) ; v2(120.44,12.97) 120.77,12.64 120.79,12.64 120.82,12.62 v3(120.82,12.59) ; v2(113.24,11.67) 113.58,11.67 v3(113.61,11.65) ; v3(119.14,21.23) 119.04,21.23 v2(118.84,21.42) ; v2(114.84,12.97) 114.8,12.97 v3(114.5,12.67) ; v2(164.43,11.67) 164.63,11.67 v3(164.86,11.45) ; v2(128.43,11.67) 128.51,11.67 128.7,11.48 128.7,11.46 v3(128.72,11.46) ; v2(160.43,12.97) v3(160.78,12.63) ; v3(160.74,22.44) 160.45,22.72 v2(160.43,22.72) ; v2(118.84,24.02) 119.1,23.77 v3(119.24,23.77) ; v2(150.85,11.67) 151.15,11.37 v3(151.19,11.37) ; v2(166.03,22.72) v3(166.42,22.72) ; v2(130.83,22.72) v3(130.37,22.72) ; v3(152.84,12.97) v2(152.45,12.97)
  vias: v1(106.49,25.47) v2(106.39,22.55) v2(106.39,22.04) v2(106.39,21.53) v2(106.77,22.8) v2(106.77,22.29) v2(106.77,21.79) v2(106.77,21.28) v2(107.15,22.55) v2(107.15,22.04) v2(107.15,21.53) v2(125.63,14.58) v2(126.45,14.58) v2(132.43,14.27) v2(141.93,22.96) v2(145.24,21.42) v2(146.85,22.72) v2(157.23,22.72) v3(106.39,22.55) v3(106.39,22.04) v3(106.39,21.53) v3(106.77,22.8) v3(106.77,22.29) v3(106.77,21.79) v3(106.77,21.28) v3(107.15,22.55) v3(107.15,22.04) v3(107.15,21.53) v3(125.63,14.58) v3(126.45,14.58) v3(132.43,14.27) v3(141.93,22.96) v3(145.24,21.42) v3(146.85,22.72) v3(157.23,22.72) v4(106.39,22.55) v4(106.39,22.04) v4(106.39,21.53) v4(106.77,22.8) v4(106.77,22.29) v4(106.77,21.79) v4(106.77,21.28) v4(107.15,22.55) v4(107.15,22.04) v4(107.15,21.53) v5(110.36,8.91) v5(110.55,25.16) v5(110.92,8.91) v5(112.03,23.04) v5(120.82,25.11) v5(120.83,23.69) v5(136.82,23.87) v9(106.39,22.55) v9(106.39,22.04) v9(106.39,21.53) v9(106.77,22.8) v9(106.77,22.29) v9(106.77,21.79) v9(106.77,21.28) v9(107.15,22.55) v9(107.15,22.04) v9(107.15,21.53)
+VIN_3V3_L_TBT: length 4.5
  BOTTOM w0.203: UPD1.5 29.01,30.85 CPD5.1
  BOTTOM w0.254: CPD5.1 29.67,30.19 29.67,29.25 29.42,29 RPD84.2
+VIN_3V3_R_TBT: length 4.6
  TOP w0.203: CP10.1 261.4,33.19 v1(261.4,33.96) UPD2.5
  TOP w0.254: CP10.1 260.73,32.53 260.73,31.76 261.27,31.22 RPD93.2
AGND: length 10.6
  TOP w0.127: v6(257.95,69.59) v6(255.77,69.59) 255.64,69.46 v6(255.64,67.51) 255.77,67.38 255.77,66.08 v11(256.25,65.6)
  TOP w0.203: v10(264.48,62.94) 264.42,62.88 264.07,62.88 264.03,62.84 UA1.22 ; UA1.37 257.5,63.64 257.21,63.92 257.21,64.69 v5(257.24,64.71)
  BOTTOM w0.508: v5(267.62,62.55) 267.43,62.36 CA78.2 CA81.2
  vias: v3(262.93,67.07) v3(263.01,65.73) v5(266.54,68.01) v5(267.62,68.78) v11(255.51,65.35) v11(255.66,63.85) v11(256.43,63.64) v11(257.01,65.73) v11(259.55,67.28) v11(262.35,66.95) v11(262.98,66.95) v11(263.87,67.73) v11(265.67,62.3) v11(266.08,63.06) v11(266.41,62.2) v12(255.87,63.85) v12(259.93,64.48) v12(263.49,62.32) v12(264.5,62.32) v12(265.19,63.06) v12(265.39,62.32) v12(269.17,61.8) v12(273.17,61.8) v12(276.39,67.99)
DV12S: length 3.6
  BOTTOM w0.508: v1(9.48,46.3) 9.48,46.62 9.94,47.07 12.6,47.07
DV33_18: length 3.3
  TOP w0.069: v1(18.3,42.51) 17.79,43.02 v5(15.2,43.02)
GND: length 4874.6
  TOP w0.203: UC25.5 272.25,42.26 v11(272,42) ; UC13.5 v11(151.19,61.62) ; v3(94.81,37.3) 95.09,37.58 95.09,38.45 94.73,38.8 93.82,38.8 90.26,42.36 90.26,45.38 91.35,46.47 92.8,46.47 93.05,46.22 v5(93.77,46.22) 94.17,46.22 94.25,46.14 96.25,46.14 96.81,46.7 96.81,56.96 97.5,57.65 97.37,57.78 97.37,59.71 v5(97.23,59.84) ; U31.11 v11(183.99,47.64) ; UA2.15 23.3,21.78 v5(23.53,22.01) 23.7,21.85 UA2.16 ; UA2.19 v11(24.9,20.44)
  TOP w0.254: v11(272.15,40.66) 272.15,41.04 C234.2 ; v10(280.48,68.09) 280.18,68.09 v5(279.95,68.32) ; v10(280.48,68.09) 280.81,68.09 v5(281.09,68.37) ; v10(280.48,68.09) v5(280.48,68.57) ; D411.2 11.34,74.97 v3(11.49,75.13) ; v11(166.84,54.63) 166.93,54.72 RH9.2 ; v11(185.79,51.22) 185.93,51.08 C1468.2 ; v11(275.93,32.58) 275.93,32.71 RA82.1 ; v5(281.04,66.49) 280.84,66.69 v10(280.48,66.69) ; v11(128.41,47.51) 128.82,47.51 v8(128.82,47.52) ; v8(128.72,49.52) 128.44,49.8 v11(128.44,50.05) ; v5(279.9,66.49) 280.1,66.69 v10(280.48,66.69) ; v5(279.97,63.31) v14(280.51,63.31) v5(281.04,63.31) ; v11(125.9,62.35) 126.07,62.53 D471.1 ; v11(192.83,48.35) 193,48.18 JDEBUG1.8 ; v11(37,38.85) 37,39.16 JDB1.12 ; JDEBUG1.5 v11(192.57,46.68) ; v5(14.16,70.55) v14(13.68,70.55) 13.68,71.14 v5(13.7,71.16) ; v14(12.28,70.55) 12.28,70.15 v5(12.43,69.99) ; v11(192.88,25.02) 193.75,25.02 193.93,24.85 JAPS1.8 ; C1469.2 v11(186.09,42.74) ; v5(23.74,22.8) 23.74,22.88 23.48,23.14 UA2.10 ; v14(280.51,61.92) v5(281.04,61.92) ; v14(280.51,61.92) v5(279.97,61.92) ; v14(280.51,61.92) v5(280.51,61.43) ; v11(128.39,46.12) v8(128.82,46.12) ; v10(280.48,66.69) v5(280.48,66.21) ; v5(9.84,69.87) 10,70.02 v11(10,70.55) ; JAPS1.10 v11(193.23,25.85) ; v11(176.24,22.42) v11(175.55,23.11) v11(174.46,23.11) 174.46,22.37 v11(174.27,22.18) 174.16,22.07 v11(173.29,22.07) v11(172.43,22.07) v11(171.72,22.07) 171.64,22.14 v11(171.64,22.88) v11(171.64,24.15) v11(171.64,25.04) v11(171.64,25.52) 171.64,25.87 171.85,26.08 172.28,26.08 v11(172.33,26.13) v11(173.34,26.13) 173.78,26.13 174.03,25.87 v11(174.03,25.62) 174.03,25.47 174.33,25.16 v11(174.64,25.16) 175.2,25.72 v11(175.76,25.72) v11(176.54,25.72) v11(177.18,25.72) 177.23,25.67 177.74,25.67 v11(177.85,25.56) 177.86,25.54 177.86,24.99 v11(177.94,24.91) v11(177.94,24.1) v11(178.32,23.72) 178.73,23.31 v11(178.73,22.93) ; UA2.2 v11(24.58,25.7) ; RC434.1 169.89,54.3 v11(169.51,54.68) ; C451.2 127.14,63.44 127.24,63.34 v11(127.24,63.09) ; v8(128.16,49.52) 128.44,49.24 v11(128.44,48.81) ; C1540.2 v11(162.13,63.51) 162.35,63.29 CC17.2 ; JDB1.11 v11(36.49,32.35)
  TOP w0.305: CC191.2 125.83,45.09 v5(125.67,44.93)
  TOP w0.356: v11(167.09,46.51) CC656.2
  TOP w0.381: JDEBUG2.11 v5(150.01,2.79) ; v5(156.51,2.67) JDEBUG2.12 ; CA105.2 v5(18.43,21.15) ; CA93.2 v5(18.71,22.29)
  TOP w0.508: v5(205.32,42.36) 204.86,42.82 PC811.2 ; v5(123.7,47.65) 123.67,47.68 PC1314.2 ; v5(122.42,49.5) 122.39,49.53 PC1312.2 ; CA104.2 v5(18.8,26.23) ; 83.78,27.88 85.03,29.13 92.85,29.13 93.32,29.6 PC214.2 ; PC1319.2 125.7,47.65 v5(125.68,47.67) ; v5(125.62,49.53) 125.59,49.49 PC1315.2 ; PC415.2 v5(23.14,18.48) ; H9.1 254.1,32.34 251.88,30.12 251.88,28.47 ; PR706.1 v5(101.94,10.86) ; v5(126.38,54.14) 126.57,53.95 PC1008.2 ; JDB2.12 v5(282.36,51.58)
  GND1 w0.203: HSSD1.1 106.8,15.64 ; HSSD1.1 107.35,17.15 ; HSSD1.1 103.79,18.66 ; HSSD1.1 103.23,17.15 ; HSSD1.1 105.29,19.21 ; HSSD1.1 106.8,18.66 ; HSSD1.1 103.79,15.64 ; HSSD1.1 105.29,15.09 ; 202.33,56.84 H7.1 ; H7.1 202.33,53.61 ; H7.1 203.95,53.01 ; H7.1 203.95,57.43 ; H7.1 205.56,53.61 ; H7.1 205.56,56.84 ; H7.1 201.74,55.22 ; H7.1 206.16,55.22 ; JUSBC1.1 3.35,71.53 ; JUSBC1.1 3.35,70.19 ; JUSBC1.1 4.56,71.53 ; JUSBC1.1 2.14,71.53 ; JUSBC1.1 2.14,70.86 ; JUSBC1.1 4.56,70.19 ; JUSBC1.1 4.56,70.86 ; JUSBC1.1 2.14,70.19 ; H5.1 21.51,4.41 ; H5.1 19.9,0.59 ; H5.1 22.11,2.8 ; H5.1 18.28,4.41 ; H5.1 21.51,1.19 ; H5.1 18.28,1.19 ; H5.1 19.9,5.01 ; H5.1 17.69,2.8 ; JBATT1.11 38.02,12.64 ; JBATT1.11 37.54,12.16 ; JBATT1.11 37.33,13.33 ; JBATT1.11 36.37,12.38 ; JBATT1.11 36.16,13.55 ; JBATT1.11 36.64,14.02 ; JBATT1.11 37.07,11.69 ; JBATT1.11 35.68,13.07 ; 284.09,71.03 JUSBC2.2 ; JUSBC2.2 284.6,71.03 ; JUSBC2.2 285.11,71.03 ; JP1.20 17.1,50.15 ; JP1.20 17.1,52.05 ; JP1.20 16.4,52.05 ; JP1.20 17.1,51.1 ; JP1.20 16.4,50.15 ; 46.59,23.98 JBATT1.13 ; JBATT1.13 46.11,23.5 ; JBATT1.13 47.5,22.12 ; JBATT1.13 48.45,23.07 ; JBATT1.13 47.07,24.45 ; JBATT1.13 46.8,22.81 ; JBATT1.13 47.97,22.59 ; JBATT1.13 47.76,23.76 ; H4.1 40.46,29.54 ; H4.1 41.72,26.59 ; H4.1 39.21,26.59 ; H4.1 40.46,26.14 ; H4.1 42.16,27.84 ; H4.1 38.76,27.84 ; H4.1 41.72,29.1 ; H4.1 39.21,29.1 ; 38.14,10.61 JBATT1.12 ; JBATT1.12 39.78,10.87 ; JBATT1.12 40,9.71 ; JBATT1.12 39.52,9.23 ; JBATT1.12 39.09,11.57 ; JBATT1.12 38.83,9.92 ; JBATT1.12 40.48,10.18 ; JBATT1.12 38.62,11.09 ; JUSBC2.1 290.76,70.7 ; JUSBC2.1 289.55,72.05 ; JUSBC2.1 288.34,72.05 ; JUSBC2.1 290.76,72.05 ; JUSBC2.1 288.34,70.7 ; JUSBC2.1 290.76,71.38 ; JUSBC2.1 288.34,71.38 ; JUSBC2.1 289.55,70.7 ; JUSBC1.5 8.3,82.22 ; JUSBC1.5 8.81,82.22 ; JUSBC1.5 7.79,82.22 ; JP1.19 6.89,47.85 ; JP1.19 6.89,47.15 ; JP1.19 4.89,47.15 ; JP1.19 4.89,47.85 ; JP1.19 5.89,47.15 ; 177.52,34.81 HCPU3.1 ; HCPU3.1 179.02,38.38 ; HCPU3.1 180.53,34.81 ; HCPU3.1 180.53,37.83 ; HCPU3.1 181.08,36.32 ; HCPU3.1 176.97,36.32 ; HCPU3.1 179.02,34.26 ; HCPU3.1 177.52,37.83 ; HCPU1.1 115.81,62.02 ; HCPU1.1 114.31,65.58 ; HCPU1.1 112.25,63.52 ; HCPU1.1 112.8,65.03 ; HCPU1.1 115.81,65.03 ; HCPU1.1 114.31,61.47 ; HCPU1.1 116.37,63.52 ; HCPU1.1 112.8,62.02 ; JUSBC1.6 4.56,82.56 ; JUSBC1.6 3.35,83.23 ; JUSBC1.6 2.14,82.56 ; JUSBC1.6 4.56,81.89 ; JUSBC1.6 2.14,81.89 ; JUSBC1.6 4.56,83.23 ; JUSBC1.6 2.14,83.23 ; JUSBC1.6 3.35,81.89 ; JUSBC2.3 283.95,71.03 ; JUSBC2.3 285.1,70.45 ; JUSBC2.3 285.1,71.03 ; JUSBC2.3 283.95,69.87 ; JUSBC2.3 282.79,69.87 ; JUSBC2.3 285.1,69.87 ; JUSBC2.3 282.79,70.45 ; JUSBC2.3 282.79,71.03 ; 288.34,60.35 JUSBC2.6 ; JUSBC2.6 288.34,59 ; JUSBC2.6 290.76,59.68 ; JUSBC2.6 290.76,59 ; JUSBC2.6 288.34,59.68 ; JUSBC2.6 289.55,59 ; JUSBC2.6 290.76,60.35 ; JUSBC2.6 289.55,60.35 ; 49.52,22 JBATT1.14 ; JBATT1.14 49.05,21.52 ; JBATT1.14 48.57,21.04 ; JBATT1.14 50.43,20.14 ; JBATT1.14 50.91,20.61 ; JBATT1.14 49.26,20.35 ; JBATT1.14 50.21,21.3 ; JBATT1.14 49.95,19.66 ; 113.87,34.26 HCPU2.1 ; HCPU2.1 111.82,36.32 ; HCPU2.1 115.38,34.81 ; HCPU2.1 113.87,38.38 ; HCPU2.1 112.37,37.83 ; HCPU2.1 115.38,37.83 ; HCPU2.1 112.37,34.81 ; HCPU2.1 115.93,36.32 ; 7.79,71.78 JUSBC1.3 ; JUSBC1.3 8.95,71.2 ; JUSBC1.3 10.1,71.2 ; JUSBC1.3 8.95,72.37 ; JUSBC1.3 7.79,71.2 ; JUSBC1.3 7.79,72.37 ; JUSBC1.3 10.1,71.78 ; JUSBC1.3 10.1,72.37 ; 11.6,81.64 H1.1 ; H1.1 10.39,82.85 ; H1.1 12.81,82.85 ; H1.1 10.7,83.75 ; H1.1 12.5,81.95 ; H1.1 11.6,84.06 ; H1.1 12.5,83.75 ; H1.1 10.7,81.95 ; 88.95,53.01 H6.1 ; H6.1 90.56,56.84 ; H6.1 87.33,56.84 ; H6.1 86.74,55.22 ; H6.1 91.16,55.22 ; H6.1 90.56,53.61 ; H6.1 87.33,53.61 ; H6.1 88.95,57.43 ; H8.1 275.21,2.8 ; H8.1 270.79,2.8 ; H8.1 274.61,4.41 ; H8.1 273,0.59 ; H8.1 274.61,1.19 ; H8.1 273,5.01 ; H8.1 271.38,1.19 ; H8.1 271.38,4.41 ; JUSBC1.4 10.1,82.22 ; JUSBC1.4 10.1,81.64 ; JUSBC1.4 7.79,82.22 ; JUSBC1.4 8.95,81.05 ; JUSBC1.4 10.1,81.05 ; JUSBC1.4 8.95,82.22 ; JUSBC1.4 7.79,81.64 ; JUSBC1.4 7.79,81.05 ; 284.85,54.64 H10.1 ; H10.1 285.45,56.25 ; H10.1 285.45,53.03 ; H10.1 287.06,56.85 ; H10.1 288.68,56.25 ; H10.1 289.27,54.64 ; H10.1 287.06,52.43 ; H10.1 288.68,53.03 ; HCPU4.1 180.65,63.52 ; HCPU4.1 178.59,65.58 ; HCPU4.1 180.09,65.03 ; HCPU4.1 178.59,61.47 ; HCPU4.1 176.53,63.52 ; HCPU4.1 180.09,62.02 ; HCPU4.1 177.08,65.03 ; HCPU4.1 177.08,62.02 ; JP1.22 6.89,64.35 ; JP1.22 4.89,64.35 ; JP1.22 4.89,63.65 ; JP1.22 5.89,64.35 ; JP1.22 6.89,63.65 ; 284.09,60.02 JUSBC2.5 ; JUSBC2.5 284.6,60.02 ; JUSBC2.5 285.11,60.02 ; H9.1 254.6,34.04 ; H9.1 253.34,31.08 ; H9.1 254.6,30.63 ; H9.1 255.85,31.08 ; H9.1 255.85,33.59 ; H9.1 256.3,32.34 ; H9.1 252.9,32.34 ; H9.1 253.34,33.59 ; H2.1 6.46,66.09 ; H2.1 2.64,67.7 ; H2.1 3.23,66.09 ; H2.1 4.85,69.91 ; H2.1 3.23,69.31 ; H2.1 4.85,65.49 ; H2.1 6.46,69.31 ; H2.1 7.06,67.7 ; 283.95,60.02 JUSBC2.4 ; JUSBC2.4 282.79,60.6 ; JUSBC2.4 285.1,60.02 ; JUSBC2.4 283.95,61.18 ; JUSBC2.4 282.79,60.02 ; JUSBC2.4 282.79,61.18 ; JUSBC2.4 285.1,61.18 ; JUSBC2.4 285.1,60.6 ; JP1.21 16.4,62.65 ; JP1.21 17.1,61.7 ; JP1.21 17.1,60.75 ; JP1.21 16.4,60.75 ; JP1.21 17.1,62.65 ; JUSBC1.2 8.81,71.2 ; JUSBC1.2 8.3,71.2 ; JUSBC1.2 7.79,71.2
  IN1 w0.127: 174.08,59 174.45,59 175.96,57.49 178.53,57.49 arc(178.88,57.42) 179.19,57.22 179.58,56.82 180.59,56.27 arc(181.18,55.99) 181.8,55.78 183.26,55.34 183.55,55.34 183.96,54.93 ; 183.59,38.32 184.58,37.33 187.08,37.33 187.39,37.02 188.01,37.02 188.46,36.58 188.46,36.41 v9(188.91,35.96) ; v9(183.28,40.15) 185.13,38.3 187.59,38.3 187.86,38.03 188.45,38.03 v9(188.64,37.84) ; v9(202.86,29.48) 203.12,29.74 203.12,33.06 202.81,33.37 v9(202.25,33.37) ; v9(176.04,42) v9(174.66,42) v13(173.5,42) ; v9(35.65,23.92) 35.65,23.69 35.93,23.41 35.93,22.88 36.39,22.42 ; v9(246.25,8.8) 247.76,8.8 v9(247.99,9.03) ; v13(191.81,34.99) 191.81,34.3 192.94,33.18 193.04,33.18 v13(193.05,33.16) ; v13(174,48.89) 174.38,48.89 174.72,48.55 178.86,48.55 179.06,48.35 181.01,48.35 181.55,47.82 v13(181.55,47.29) 181.55,46.75 v9(181.95,46.35) 181.95,45.99 183.3,44.65 v13(183.3,44.54) 183.3,44.32 186.7,40.92 188.86,40.92 189.4,40.38
  IN1 w0.254: v9(246.25,8.8) v9(244.34,8.8) 244.33,8.8 244.23,8.7 v9(243.43,8.7) v9(242.79,8.7) 242.64,8.7 242.1,8.16 v9(242,8.16) v13(240.81,8.16) v13(239.69,8.16) v13(238.42,8.16) v9(237.15,8.16) 236.22,8.16 v13(235.85,8.53) 235.29,9.09 v9(235.29,9.47) ; v13(193.05,30.79) 193.05,31.13 192.57,31.62 v9(192.57,31.82) 192.55,31.84 192.55,32.12 191.86,32.81 v9(191.86,32.81) 191.86,32.81 190.87,33.8 v9(190.87,33.8) 190.64,34.03 v13(190.64,34.51) 190.64,35.02 190.17,35.49 v9(189.8,35.49) 189.34,35.49 188.91,35.93 v9(188.91,35.96) ; v13(193.05,30.79) 192.38,30.79 v13(192.24,30.93) 191.96,31.21 191.96,31.92 v13(191.64,32.24) v9(190.77,33.11) 190.13,33.75 190.13,33.85 v13(190.12,33.86) 190.12,34.34 189.48,34.97 188.86,34.97 v13(188.79,35.05) v9(188.31,35.53) 188.29,35.53 188.14,35.68 186.37,35.68 v9(186.27,35.58) 185.99,35.3 v9(185.33,35.3) 183.64,35.3 v13(183.61,35.27) 183.59,35.3 182.28,35.3 v13(181.74,34.75) 181.42,34.43 181.42,33.22 v13(181.19,32.99) 180.86,32.66 v13(180.86,31.74) ; v13(193.05,30.79) 193.55,30.79 v13(194.59,29.75) 195.39,28.95 v13(195.39,28.39) 195.39,27.96 195,27.56 ; 241.26,14.75 v13(241.97,14.75) 242.86,14.75 v9(243.57,15.46) 243.75,15.64 v9(244.18,15.64) v9(245.33,15.64) v13(246.57,15.64) 246.92,15.64 v13(247.34,16.06) 247.59,16.3 v9(248.38,16.3) v13(249.29,16.3) 249.32,16.3 v13(250.14,17.12) v9(250.99,17.98) v13(252.01,18.99) v13(252.47,19.45) v13(254.06,21.05) 254.12,21.1 v9(254.98,21.1) 255.06,21.1 v9(255.92,21.96) 255.93,21.96 256.62,22.65 256.62,22.66 ; 241.26,14.75 242.38,15.87 243.24,15.87 v13(243.62,16.25) v13(245.72,16.25) v13(246.4,16.93) 246.41,16.93 v13(246.98,17.5) v13(248.45,17.5) 248.54,17.59 248.79,17.59 arc(249.42,17.72) 249.95,18.08 v13(250.13,18.25) v9(250.89,19.02) 251.68,19.8 251.68,20.3 v9(251.83,20.46) 252.12,20.74 252.57,20.74 v13(252.83,21.01) v13(253.67,21.85) 253.72,21.85 254.22,22.34 254.65,22.34 v9(254.88,22.57) 255.11,22.8 v13(256.03,22.8) 256.46,22.8 256.6,22.66 256.62,22.66 ; 241.26,14.75 v9(240.78,14.75) v9(239.43,14.75) 239.32,14.75 v13(238.91,14.34) v13(237.61,14.34) v9(236.34,14.34) v9(235.07,14.34) v9(233.24,14.34) v9(230.93,14.34) 229.25,14.34 228.97,14.62 v13(228.69,14.62) v9(227.8,14.62) 227.7,14.62 227.01,13.94 v13(226.86,13.94) v9(225.59,13.94) 224.32,13.94 v9(224.22,14.04) 224.09,14.17 v9(222.84,14.17) v13(221.57,14.17) v9(220.3,14.17) v9(219.03,14.17) v13(217.76,14.17) v13(216.49,14.17) v13(215.22,14.17) v9(214.15,14.17) 214.13,14.17 213.27,15.03 v9(213.27,15.03) 211.98,15.03 v9(211.91,15.09) 210.86,16.15 v13(210.81,16.15) v9(209.54,16.15) v9(207.89,16.15) v13(206.92,17.11) v13(206.08,17.95) v9(205.12,18.92) v13(203.98,20.06) v13(202.99,21.05) v13(201.99,22.04) 201.69,22.34 v9(201.69,23.28) v9(201.69,24.68) v9(201.69,26) v9(201.69,27.58) 201.69,28.31 ; v9(235.29,9.47) v13(233.52,9.47) v13(232.32,9.47) v13(231.05,9.47) v9(229.86,9.47) v13(228.49,9.47) v13(227.24,9.47) v13(226.02,9.47) 224.73,9.47 v13(224.68,9.42) v9(223.41,9.42) 222.57,9.42 222.29,9.14 v13(222.14,9.14) v13(220.92,9.14) v13(219.57,9.14) v13(218.38,9.14) 217.31,9.14 v13(216.98,9.47) 216.73,9.72 v13(216.4,9.72) v13(214.92,9.72) v13(213.7,9.72) v9(212.69,9.72) 212.66,9.72 v9(211.86,10.52) 211.56,10.83 v9(210.26,10.83) v9(208.99,10.83) v9(207.72,10.83) v9(206.45,10.83) v9(205.41,10.83) v9(204.56,11.68) v13(203.8,12.44) v9(202.66,13.58) v13(201.66,14.57) v9(200.67,15.56) v9(199.71,16.53) v13(198.51,17.72) v13(197.6,18.64) v9(197.6,19.93) v9(197.6,21.2) v9(197.6,22.47) v13(197.6,23.74) v13(197.6,25.01) v13(197.6,26.28) 197.6,26.94 v9(197.14,27.4) v13(196.51,28.03) v13(196.51,29.1) 196.51,29.68 ; v9(235.29,9.47) 235.34,9.52 v13(236.11,9.52) 236.49,9.52 v13(236.96,9.04) 237.29,8.71 v13(238.11,8.71) v13(239.4,8.71) 240.76,8.71 241.21,9.16 v13(241.21,9.64) 241.21,9.82 v13(241.54,10.15) 241.77,10.38 v13(242.36,10.38) v13(243.85,10.38) v13(244.92,11.45) 245.31,11.83 v13(246.06,11.83) v13(247.49,11.83) v13(249.21,11.83) v13(250.51,11.83) v13(251.85,13.17) v13(252.99,14.31) v13(253.84,15.16) v13(254.55,15.16) v13(255.69,16.3) v13(255.69,17.09) v13(256.25,17.65) v13(257.14,18.53) v13(258.12,19.51) v3(258.76,20.16) 258.79,20.13 259.3,20.13 259.55,20.39 v3(259.55,21.38) 259.55,21.63 v13(259.2,21.99) ; v9(176.04,42) v13(176.85,42) 177.51,41.34 178.37,41.34 v9(178.41,41.31) v9(179.49,40.23) 180.53,40.23 v9(181.12,39.64) 181.17,39.59 181.17,39.5 v13(181.93,38.73) 182.25,38.41 v13(183.5,38.41) 183.59,38.32 ; 201.69,28.31 201.72,28.29 v9(202.5,28.29) 202.86,28.64 v9(202.86,29.48) 202.48,29.48 202.3,29.66 202.25,29.66 ; 201.69,28.31 v9(201.69,29.08) 201.69,29.1 202.25,29.66 ; v13(174,48.89) 173.24,49.65 v13(173.24,49.7) 173.24,50.06 v13(172.4,50.89) v9(171.13,50.89) v9(169.94,50.89) v13(168.72,50.89) 167.58,50.89 v13(167.55,50.92) 166.71,50.92 166.51,50.72 v13(165.95,50.72) v13(164.68,50.72) 164.55,50.72 v9(163.74,51.53) v13(162.73,52.54) 162.32,52.95 v13(162.32,53.71) 162.32,54.35 v13(161.48,55.19) 161.17,55.5 v9(160.54,55.5) v13(159.27,55.5) v9(158,55.5) v9(157.04,55.5) v13(155.46,55.5) v5(154.1,55.5) 153.6,56.01 v5(152.25,56.01) ; 256.62,22.66 256.62,22.67 256.75,22.8 257.49,22.8 v9(257.76,23.07) 258.93,23.07 v13(259.02,23.16) v9(259.7,23.84) v9(261.1,23.84) 261.63,23.84 v13(261.98,24.19) v13(262.99,25.2) 263.71,25.91 v13(263.74,25.91) 264.59,25.91 v13(264.81,26.13) v13(265.67,26.99) 265.85,27.17 v13(267.5,27.17) 269.13,27.17 v9(269.25,27.3) v13(270,28.05) v9(270.78,28.82) 271.29,29.33 v9(271.29,30.04) v9(272.15,30.9) ; v9(188.64,37.84) 189.35,37.13 v13(189.75,37.13) 190.04,37.13 190.49,36.68 190.68,36.68 v13(191.07,36.29) v9(191.79,35.56) 191.81,35.55 v13(191.81,34.99) ; 196.51,29.68 196.52,29.68 196.94,29.68 v13(197.17,29.91) 197.45,30.19 v13(197.45,30.52) 197.45,31.03 197.19,31.29 v13(197.14,31.29) 197.07,31.36 197.07,31.72 v9(196.48,32.3) v13(195.68,33.1) v13(195.68,34.16) 195.68,34.58 v13(194.59,35.67) v13(193.51,36.75) 193.37,36.89 192.89,36.89 v9(192.47,37.31) v13(191.2,38.58) v13(190.11,39.67) 189.4,40.38 ; 196.51,29.68 195.8,30.4 v13(195.77,30.4) 195.77,30.42 195.27,30.93 195.27,31.39 v13(195.01,31.65) 194.21,32.45 v13(193.82,32.45) 193.77,32.45 v13(193.05,33.16) ; v9(247.99,9.03) 248.1,9.14 v13(249.39,9.14) 250.43,9.14 v13(250.46,9.16) 250.86,9.57 v9(250.89,9.57) v13(251.85,9.57) v13(253.25,9.57) v13(254.55,9.57) v13(255.77,9.57) v13(257.04,9.57) 257.09,9.57 v9(257.49,9.16) 257.49,8.25 v9(257.42,8.17) 257.19,7.94 v13(256.53,7.94) v9(255.39,7.94) v9(254.17,7.94) v13(252.92,7.94) v13(251.78,7.94) v13(250.89,7.94) v13(249.85,7.94) 249.35,7.45 v13(249.35,7.07) ; 195,27.56 v9(195.37,27.2) v9(196.43,26.13) v13(196.43,24.78) v13(196.43,23.51) v9(196.43,22.24) v9(196.43,20.97) v9(196.43,19.7) v9(196.43,18.43) 196.43,17.98 v13(196.94,17.47) v13(197.85,16.55) v13(199,15.41) v9(199.99,14.42) v9(201.09,13.31) v9(202.36,12.04) v9(203.23,11.18) v13(204.05,10.36) v13(205.14,9.26) 205.58,8.83 v9(206.13,8.83) v9(207.43,8.83) v13(208.73,8.83) v13(210.02,8.83) v13(211.14,8.83) 211.62,8.83 v9(211.82,8.63) 211.83,8.63 v9(212.64,8.63) v9(213.7,8.63) v9(214.59,8.63) v9(215.84,8.63) 216.02,8.63 v9(216.9,7.74) v13(218.17,7.74) v13(219.44,7.74) v13(220.71,7.74) v13(221.98,7.74) v9(223.25,7.74) v9(224.52,7.74) v9(225.72,7.74) v13(227.06,7.74) v13(228.41,7.74) v13(229.66,7.74) v9(230.93,7.74) v9(232.12,7.74) 232.78,7.74 232.86,7.66 v9(233.64,7.66) 234.23,7.66 v9(234.56,7.33) v13(235.1,6.79) 235.19,6.7 v13(236.72,6.7) v9(238.11,6.7) v9(239.41,6.7) v13(240.68,6.7) v13(241.95,6.7) v9(243.17,6.7) v9(243.98,6.7) 245.1,6.7 v9(245.54,7.14) 246.06,7.66 246.23,7.66 v9(246.24,7.68) v13(247.33,7.68) 248.62,7.68 248.63,7.66 v13(248.76,7.66) v13(249.35,7.07) ; 195,27.56 194.84,27.56 194.4,28.01 v9(194.4,28.21) 194.4,28.52 v9(193.94,28.97) v13(193.36,28.97) 192.65,28.97 v9(191.53,30.09) v13(190.54,31.08) v13(189.94,31.68) 189.7,31.92 v9(188.53,31.92) 188.28,31.92 v13(187.43,32.77) 187.16,33.04 v9(186.58,33.04) 186.5,33.04 v5(186.04,33.5) 186.04,33.5 186.04,34 185.81,34.23 v3(185.51,34.23) 185.46,34.18 v3(184.82,34.18) v3(183.88,34.18) v3(183.22,34.18) v3(182.67,34.18) 182.39,33.9 v9(182.39,33.22) 182.49,33.11 182.49,32.66 v9(181.94,32.11) 181.57,31.74 v13(180.86,31.74) ; v5(152.25,56.01) 151.61,56.01 v9(151.6,56) 150.94,56 v9(150.43,55.49) v13(149.72,54.78) v13(148.45,54.78) v13(147.18,54.78) v13(145.91,54.78) v9(144.64,54.78) v13(143.37,54.78) v13(142.1,54.78) 141.92,54.6 v9(140.83,54.6) v9(139.56,54.6) v9(138.29,54.6) 137.55,54.6 v9(137.14,55.02) 136.16,56 v13(135.9,56) 135.8,56 v9(135.13,56.67) v13(134.35,57.45) 133.62,58.18 v9(133.54,58.18) v9(132.53,58.18) v13(131.31,58.18) 131.29,58.2 130.25,58.2 v9(130.25,58.19) 129.38,59.06 v13(129.38,59.07) 129.31,59.07 v13(128.81,59.57) 128.76,59.62 v9(127.39,59.62) v13(126.12,59.62) v13(124.85,59.62) v13(123.51,59.62) v13(122.67,59.62) 122.02,58.97 v9(121.88,58.97) v13(120.97,58.06) v13(120.08,57.17) 119.31,56.39 v9(118.78,56.39) v13(117.9,56.39) v9(116.55,56.39) v9(115.28,56.39) v13(114.01,56.39) v9(112.74,56.39) v9(111.47,56.39) v9(110.12,56.39) v9(108.78,56.39) 108.7,56.39 arc(108.26,56.3) 107.88,56.05 v13(107.24,55.41) v13(106.71,54.88) v13(105.51,53.68) v9(104.24,52.41) v9(103.22,51.39) 103.18,51.35 v9(102.35,51.35) v13(101.03,51.35) v13(100.01,51.35) v13(98.74,51.35) v9(97.42,51.35) 96.39,51.35 v9(96.36,51.32) v13(95.49,50.44) v9(94.62,49.58) v9(93.61,48.56) v13(92.89,47.85) v9(92.34,46.96) 92.14,46.56 arc(92.04,46.3) 92.01,46.03 v9(92.01,45.66) v9(92.01,44.72) v13(92.01,43.55) v13(92.01,42.05) v13(92.01,40.78) v13(92.01,39.51) v13(92.01,38.24) v13(92.01,36.97) v9(92.01,35.7) v9(92.01,34.43) v9(92.01,32.99) v9(92.01,31.89) v9(92.01,30.62) v13(92.01,29.33) 92.01,28.72 v9(91.76,28.47) v13(91.02,27.73) v9(90.18,26.89) v13(89.27,25.98) v9(88.43,25.14) v13(87.59,24.3) v13(86.6,23.31) v9(85.66,22.37) v13(84.67,21.38) v9(83.63,20.34) v9(82.56,19.27) v9(81.73,18.43) v13(80.81,17.52) v13(79.8,16.5) v9(78.75,15.46) v9(77.74,14.44) v9(76.91,13.62) v13(75.96,12.67) 75.27,11.98 v9(75.25,11.98) v9(73.95,11.98) v9(72.68,11.98) v9(71.41,11.98) v13(70.24,11.98) 69.23,10.97 v9(69.18,10.97) v13(67.91,10.97) v9(66.64,10.97) v13(65.37,10.97) v9(64.1,10.97) v13(62.83,10.97) v9(61.56,10.97) v13(60.29,10.97) v13(59.02,10.97) v13(57.75,10.97) v13(56.48,10.97) v9(55.21,10.97) v9(53.94,10.97) v13(52.67,10.97) v9(51.4,10.97) v9(50.13,10.97) v13(48.86,10.97) v9(47.79,10.97) v13(46.83,11.93) v9(45.81,12.95) v13(44.9,13.86) v13(44.06,14.7) v13(42.99,15.77) v13(41.95,16.81) v13(40.96,17.8) v9(40.02,18.74) v9(39.03,19.73) v9(38.39,20.36) v13(37.17,20.36) v13(36.03,20.36) 35.68,20.36 v9(34.63,21.4) 34.02,22.01 v9(34.02,22.32) v13(33.31,23.03) v13(32.6,23.74) 32.5,23.84 v9(32.5,24.99) v9(32.5,26.31) 32.5,26.36 v13(31.89,26.97) 31.41,27.45 v13(31.41,28.24) v9(31.41,29.35) v9(31.41,30.4) 31.41,30.42 v13(32.02,31.03) v9(32.73,31.74) 32.73,31.75 32.73,33.01 v13(32.73,33.01) v13(32.73,34.28) v13(32.73,35.65) v13(32.73,37.15) v13(31.97,37.91) 31.13,38.75 v9(31.1,38.75) v9(30.29,39.57) 30.01,39.84 v9(30.01,41.11) 29.48,41.65 v13(29,41.65) v13(28.23,42.41) v9(27.37,43.27) v9(26.63,44.01) v9(25.9,44.75) v9(24.68,44.75) v13(23.74,44.75) v9(22.59,44.75) 22.37,44.75 v13(21.64,45.47) v13(20.83,46.28) v13(19.84,47.27) 19.29,47.82 v13(19.29,48.3) v9(19.29,49.57) v13(19.29,50.84) v9(19.29,52.11) v9(19.29,53.38) v9(19.29,54.65) v9(19.29,55.92) v13(19.29,57.19) v13(19.29,58.46) v13(19.29,59.73) v9(19.29,61) v13(19.29,62.27) v13(19.29,63.44) 19.29,64.03 v13(19.78,64.51) v13(20.92,65.65) v13(21.81,66.54) v13(22.52,67.25) v9(23.13,67.86) v9(24.04,67.86) 24.93,67.86 v13(25.1,67.7) 25.19,67.61 25.19,66.62 v13(25.17,66.6) 25.01,66.44 v13(24.09,66.44) v9(23.13,66.44) v9(21.96,65.27) v13(21.07,64.38) v13(20.23,63.54) 20.08,63.39 v9(20.08,62.63) v13(20.08,61.31) v9(20.08,60.11) v9(20.08,58.84) v9(20.08,57.57) v13(20.08,56.3) v9(20.08,55.03) v13(20.08,53.76) v13(20.08,52.49) v9(20.08,51.22) v9(20.08,49.95) v13(20.08,48.68) 20.08,48.09 v13(20.58,47.59) v9(21.59,46.59) v9(22.27,45.9) 22.64,45.53 v13(23.18,45.53) v9(24.3,45.53) v13(25.46,45.53) v13(26.46,45.53) 26.48,45.53 v13(27.23,44.79) 27.8,44.21 v9(28.28,44.21) v13(29.12,43.38) v13(29.94,42.56) v9(30.77,41.72) v13(30.77,40.23) 30.77,40.2 v13(31.66,39.31) v13(32.68,38.3) 33.52,37.46 v13(33.52,37.43) v9(33.52,36.31) v13(33.52,35.04) v9(33.52,33.77) v13(33.52,32.43) v9(33.52,31.31) v9(32.86,30.65) v13(32.2,29.99) v9(32.2,28.16) 32.2,27.78 v13(32.7,27.27) 33.29,26.69 v13(33.29,26.64) v13(33.29,25.39) 33.29,24.17 v9(33.41,24.05) v13(34.25,23.21) v13(35.04,22.42) 35.04,22.14 35.98,21.2 v9(36.29,21.2) v13(37.17,21.2) 37.35,21.2 v9(37.83,21.68) ; v5(152.25,56.01) 152.25,56.47 v13(153.05,57.27) 153.71,57.93 v13(153.99,57.93) v13(155.28,57.93) v13(156.55,57.93) v13(157.82,57.93) 158.71,57.93 v8(159.09,57.55) 159.48,57.93 v9(160.39,57.93) v13(161.63,57.93) 161.99,57.93 162.5,57.42 v13(163.03,57.42) 163.34,57.42 v9(163.95,56.81) v9(164.89,55.87) 165.04,55.72 v13(165.04,54.83) 165.04,53.92 v13(165.19,53.76) 165.34,53.61 166.27,53.61 v3(166.5,53.84) 166.72,53.61 v13(167.65,53.61) 168.03,53.61 168.44,54.02 v13(168.97,54.02) v9(170.04,54.02) v9(171.06,54.02) 172.28,54.02 v9(172.29,54.01) v9(172.82,53.47) v9(173.64,52.66) v13(174.65,51.64) 174.8,51.49 v9(175.22,51.49) v13(176.49,51.49) v13(177.76,51.49) v9(179.03,51.49) v13(180.3,51.49) 181.2,51.49 v9(181.47,51.22) v9(182.49,50.21) v13(183.12,49.57) v9(184.14,48.56) 184.65,48.05 v13(184.65,47.34) 184.65,46.86 v13(185.21,46.3) 186.12,45.38 186.12,45.38 v9(186.35,45.15) 186.35,44.14 v13(186.45,44.04) 187.2,43.29 189.11,43.29 v5(189.14,43.31) 189.28,43.31 v13(189.68,42.92) v13(190.69,41.9) v9(191.4,41.19) v9(192.29,40.3) v13(193.13,39.46) v13(194.15,39.46) 194.86,39.46 v9(195.04,39.29) v9(196.05,38.27) 196.3,38.02 v13(198.13,38.02) 198.15,38.02 v9(198.59,37.58) v9(199.6,36.57) 199.92,36.25 v13(199.92,35.81) 199.93,35.8 199.93,34.38 v13(199.91,34.36) 200.24,34.03 v13(200.24,32.45) v9(200.24,31.67) v9(200.24,30.8) 200.24,30.35 199.71,29.81 v13(199.71,29.74) v9(199.71,28.97) v13(199.71,27.7) v13(199.71,26.64) v9(199.71,25.29) v9(199.71,23.97) v9(199.71,22.7) v13(199.71,21.48) v13(199.71,20.26) 199.71,19.68 v9(199.99,19.4) v9(200.98,18.41) v13(201.97,17.42) v13(203.11,16.27) v13(204.08,15.31) v9(205.09,14.29) 205.25,14.14 v9(206.08,14.14) v13(207.25,14.14) v13(208.65,14.14) v13(209.92,14.14) 210,14.14 211.14,13 v9(211.19,13) v9(212.51,13) 213.25,12.26 v13(213.5,12.26) v9(214.58,12.26) v13(215.85,12.26) v9(217.14,12.26) v9(218.28,12.26) v9(219.66,12.26) 220.46,12.26 v13(220.5,12.22) 221.15,11.57 v13(222.31,11.57) v9(224.58,11.57) v9(225.24,11.57) 225.31,11.65 v9(226.78,11.65) v13(228.05,11.65) v13(229.32,11.65) v13(230.59,11.65) v13(231.74,11.65) v13(233.14,11.65) 233.14,11.65 233.27,11.51 v13(234.4,11.51) v13(235.67,11.51) 236.8,11.51 236.94,11.65 v9(237.5,11.65) v13(238.77,11.65) 239.11,11.65 239.84,12.37 v13(239.84,12.37) v13(241.31,12.37) v13(242.61,12.37) 243,12.37 v13(243.7,13.08) 244.46,13.84 v9(244.97,13.84) 246.07,13.84 v13(246.07,13.84) 246.07,13.84 v9(247.13,13.84) v9(248.27,13.84) 249.67,13.84 v9(249.68,13.85) 249.99,14.15 249.99,14.15 v13(250.33,14.5) v9(250.92,15.08) v9(251.6,15.77) v13(252.31,16.48) v13(253.02,17.19) 253.65,17.81 v9(253.75,17.81) 254.4,17.81 v13(254.88,18.28) v13(255.89,19.3) 256.25,19.65 v13(256.25,20.46) 256.25,21.02 v9(256.81,21.58) 257.21,21.99 v13(257.49,21.99) 258.48,21.99 v3(258.54,21.94) 258.59,21.99 v13(259.2,21.99) ; v13(173.5,42) 173.17,42.33 v13(172.3,42.33) 171.9,42.33 v9(171.24,42.99) 170.3,43.93 v13(169.79,43.93) v13(168.26,43.93) v13(167.3,43.93) 166.94,44.29 166.59,44.29 v3(166.41,44.47) 166.23,44.47 165.93,44.77 165.93,45.15 166.18,45.41 v13(167.25,45.41) v3(167.76,45.41) 168.31,45.41 v13(168.44,45.28) 168.62,45.1 v13(169.51,45.1) v13(170.7,45.1) v13(171.91,43.9) 172.33,43.48 v9(173.04,43.48) 173.7,43.48 v13(174.05,43.12) v9(175.38,43.12) v13(176.39,43.12) 177.26,43.12 v9(177.49,42.9) 177.96,42.43 178.87,42.43 v9(178.98,42.31) 179.87,41.42 v9(180.07,41.42) 180.91,41.42 181.17,41.17 v13(181.19,41.17) 182.08,40.28 182.18,40.28 182.18,40.28 v13(182.23,40.28) 182.31,40.28 182.42,40.16 183.26,40.16 v9(183.28,40.15) ; v9(37.83,21.68) 37.86,21.71 38.37,21.71 v13(38.85,21.23) v9(39.87,20.21) 40.55,19.52 v13(40.55,19.5) 41.42,18.64 v9(41.42,18.43) v13(42.43,17.42) v9(43.45,16.4) v13(44.51,15.33) v13(45.35,14.5) v9(46.27,13.58) v13(47.28,12.57) 48.05,11.8 v9(48.55,11.8) v13(49.82,11.8) v9(51.09,11.8) v13(52.36,11.8) v9(53.63,11.8) v13(54.9,11.8) v13(56.17,11.8) v13(57.44,11.8) v9(58.71,11.8) v9(59.98,11.8) v9(61.25,11.8) v9(62.52,11.8) v9(63.79,11.8) v13(65.06,11.8) v13(66.33,11.8) v9(67.6,11.8) v13(68.9,11.8) v13(69.97,12.87) v13(71.18,12.87) v9(72.45,12.87) v9(73.72,12.87) v13(75.02,12.87) v9(75.91,13.76) v13(76.85,14.7) v9(77.81,15.66) v13(78.86,16.71) v9(79.87,17.72) v13(80.79,18.64) v9(81.62,19.47) v13(82.69,20.54) v9(83.73,21.58) v13(84.72,22.57) v13(85.66,23.51) v9(86.65,24.5) v13(87.49,25.34) v9(88.33,26.18) v9(89.24,27.09) v9(90.08,27.93) v13(90.82,28.67) 91.15,29 v9(91.15,29.79) v13(91.15,31.08) v9(91.15,32.35) v9(91.15,33.62) v13(91.15,34.89) v13(91.15,36.16) v9(91.15,37.43) v13(91.15,38.7) v9(91.15,39.97) v13(91.15,41.24) v13(91.15,42.51) v13(91.15,43.81) v13(91.15,44.95) 91.15,45.05 arc(91.18,45.69) 91.28,46.32 v9(91.28,46.32) arc(91.35,46.87) v9(91.56,47.39) 91.55,47.39 92.07,48.05 v9(92.07,48.1) 92.86,48.94 v13(92.91,48.94) v13(94.16,50.19) 94.16,50.22 v9(95.04,51.1) 96.05,52.11 96.1,52.11 v13(96.13,52.14) v13(97.17,52.14) v9(98.44,52.14) v13(99.71,52.14) v13(100.98,52.14) 101.02,52.18 v9(101.79,52.18) 101.82,52.18 101.83,52.19 102.28,52.19 arc(102.52,52.21) v3(102.76,52.28) arc(103.03,52.41) 103.26,52.6 v9(103.39,52.72) 103.44,52.72 v9(104.43,53.71) v9(105.53,54.81) v9(106.72,56) 107.35,56.63 107.36,56.63 v13(107.37,56.65) 107.44,56.71 arc(107.89,57.02) 108.43,57.12 v13(108.55,57.12) v13(109.87,57.12) v13(111.21,57.12) v9(112.48,57.12) v9(113.75,57.12) v13(115.02,57.12) v9(116.29,57.12) v9(117.56,57.12) 118.87,57.12 v9(119.11,57.37) 119.53,57.79 119.66,57.79 v9(120.24,58.37) v13(121.24,59.36) v13(122.15,60.28) 122.77,60.9 v13(122.98,60.9) v9(124.42,60.9) v13(125.69,60.9) v9(126.96,60.9) arc(127.3,61.13) 127.7,61.21 v9(128,61.21) 128.21,61.21 arc(128.6,61.47) 129.07,61.56 v13(129.1,61.56) v9(130.67,61.56) 131.38,61.56 arc(132.16,61.41) 132.82,60.96 v13(132.91,60.88) 132.92,60.87 arc(133.14,60.55) 133.21,60.16 v13(133.64,59.73) v13(134.61,58.77) v9(135.48,57.89) 136.36,57.02 v9(136.49,57.02) 136.49,57 v9(137.14,56.35) 138.02,55.47 v9(138.75,55.47) 139.7,55.47 v8(139.71,55.49) 140.6,55.49 v8(140.63,55.47) 140.83,55.67 v9(141.34,55.67) v9(142.33,55.67) v13(143.6,55.67) v13(144.87,55.67) v13(146.29,55.67) v9(147.66,55.67) v13(148.63,56.63) 148.91,56.91 v13(150.1,56.91) v11(151.22,56.91) v9(151.65,57.35) v13(152.46,58.16) 153.02,58.72 v13(153.79,58.72) v13(155.06,58.72) v9(156.33,58.72) v9(157.6,58.72) v9(158.87,58.72) v13(160.14,58.72) v13(161.35,58.72) 161.58,58.72 v13(162.12,59.25) 162.4,59.53 v13(164.07,59.53) 164.47,59.92 v13(164.54,59.92) v4(165.61,59.92) 165.61,60.05 165.93,60.37 v9(166.71,60.37) v9(168.21,60.37) v13(169.51,60.37) v13(170.6,60.37) v9(171.24,60.37) 171.34,60.37 arc(172.02,60.23) 172.59,59.85 v9(172.85,59.59) v9(173.37,59.07) 174,59.07 174.08,59 ; v9(37.83,21.68) 37.58,21.94 36.87,21.94 v9(36.82,21.99) 36.39,22.42 ; 183.96,54.93 v9(184.54,54.35) v9(185.59,53.31) v13(186.75,52.14) 187.62,51.27 v9(187.62,50.94) 187.62,50.59 v9(188.23,49.98) 188.86,49.34 v9(188.86,48.94) 188.86,48.38 v9(189.07,48.18) v13(190.29,46.96) v9(190.92,46.32) v13(192.19,45.05) v13(193.46,43.78) v9(194.73,42.51) v13(195.26,41.98) 195.27,41.97 196.16,41.97 v9(196.82,41.32) 197.76,40.37 v13(198.02,40.37) v9(198.47,40.37) v9(199.29,39.56) v13(200.56,38.29) 201.89,36.96 v13(201.89,36.95) v9(201.89,35.88) 201.89,35.23 202.25,34.87 v9(202.25,34.79) v9(202.25,33.37) v13(202.25,31.95) v9(202.25,30.42) 202.25,29.66 ; v9(272.15,30.9) 272.21,30.84 272.98,30.84 273.17,31.03 v13(273.17,31.06) 273.22,31.06 v9(273.95,31.79) v13(274.87,32.71) v13(276.01,33.85) v9(277.18,35.02) v13(278.35,36.19) v13(279.46,37.3) 280.15,37.99 v13(280.15,38.35) v9(280.15,39.62) v9(280.15,40.89) v13(280.15,42.16) v13(280.15,43.43) v13(280.15,44.7) v9(280.15,45.97) v9(280.15,47.24) v9(280.15,48.51) v9(280.15,49.78) v9(280.15,51.05) v9(280.15,52.32) v13(280.15,53.59) v13(280.15,54.86) v9(280.15,55.92) 280.15,56.25 280.85,56.95 280.85,57.05 v13(281.14,57.35) 281.55,57.35 281.83,57.07 v8(281.83,56.63) 281.83,56.1 v13(281.42,55.69) 280.96,55.24 v13(280.96,54.37) v13(280.96,53.1) v9(280.96,51.83) v13(280.96,50.56) v9(280.96,49.29) v9(280.96,48.02) v13(280.96,46.75) v13(280.96,45.48) v13(280.96,44.21) v9(280.96,42.94) v9(280.96,41.67) v13(280.96,40.4) v13(280.96,39.13) v9(280.96,37.76) 280.96,37.74 v9(280.18,36.95) v13(279.29,36.06) v13(278.35,35.12) v9(277.28,34.05) v9(276.21,32.99) v13(275.3,32.07) 274.44,31.21 v13(274.44,30.95) v9(274.44,30.09) 274.44,29.33 v13(274.17,29.06) v13(273.38,28.28) v9(272.71,27.6) 272.4,27.3 v13(271.34,27.3) 270.65,27.3 v13(270.44,27.08) v13(269.77,26.42) 269.69,26.33 v9(268.54,26.33) v13(267.32,26.33) 266.16,26.33 v9(265.65,25.82) v13(265.02,25.2) 264.83,25.01 264.17,25.01 v13(264.02,24.86) v9(263.42,24.26) v13(262.41,23.25) 261.82,22.66 v13(261.58,22.66) 261.57,22.67 v13(260.14,22.67) 260.08,22.67 259.4,21.99 v13(259.2,21.99) ; v9(272.15,30.9) 272.07,30.98 272.07,31.36 v13(272.1,31.39) 272.08,31.41 272.08,31.51 272.68,32.11 272.68,32.43 272.78,32.53 v9(272.78,32.81) 272.78,33.57 v9(273.19,33.98) 273.62,34.41 v13(273.62,34.79) v13(273.62,36.21) v9(273.62,37.33) v13(273.62,38.6) v13(273.62,39.87) v13(273.62,41.14) v13(273.62,42.54) v9(273.62,43.55) 273.62,43.6 v9(273.04,44.19) 271.83,45.39 v9(271.83,45.43) v9(271.83,46.4) v13(271.83,47.34) 271.83,47.38 v13(271.02,48.19) 270.5,48.71 v13(269.79,48.71) v13(268.75,48.71) v9(267.83,48.71) v9(266.97,48.71) 266.95,48.71 v5(266.26,49.4) 265.71,49.95 265.44,49.95 v5(264.86,50.54) 264.76,50.64 264.76,51.48 265.14,51.86 v9(265.14,52.21) 265.14,53.15 v9(265.11,53.18) v9(264.35,53.94) 263.97,54.32 v9(263.34,54.32) 263.08,54.32 262.88,54.12 v9(262.88,53.46) v9(262.88,52.19) v13(262.88,50.82) v9(263.64,50.06) v9(264.58,49.12) 265.22,48.48 v13(265.22,48.05) v13(265.22,47.16) 265.22,46.17 v13(265.39,45.99) v9(265.75,45.64) 266,45.38 266.49,45.38 v9(267.2,44.67) 267.78,44.09 v9(267.78,43.45) 267.78,43.05 v9(268.36,42.46) 269.49,41.33 arc(269.92,40.7) v9(270.07,39.95) v13(270.07,38.91) 270.07,37.94 v9(269.74,37.61) 269.18,37.05 v13(269.18,36.37) 269.18,35.4 v9(268.94,35.16) v9(268.11,34.33) v9(267.4,33.62) 266.74,32.96 v9(266.74,32.66) 266.74,32.33 v13(266.29,31.88) 265.75,31.34 264.89,31.34 v9(264.55,31.01) v13(263.54,29.99) 263.39,29.84 v13(262.4,29.84) v9(261.38,28.82) v13(260.64,28.08) 260.03,27.48 v9(260.01,27.48) 259.96,27.42 v9(258.84,27.42) v9(257.57,27.42) v13(256.3,27.42) v9(254.95,27.42) 254.94,27.41 252.94,27.41 v13(252.93,27.39) v13(252.22,26.69) v9(251.21,25.67) v9(250.15,24.61) v9(249,23.46) v9(248.2,22.67) 247.98,22.45 v9(247.29,22.45) v9(246.19,22.45) 245.1,22.45 v13(244.64,22.32) 243.67,21.5 v9(243.55,21.51) 243.51,21.41 v9(242.5,21.02) 242.47,21.02 241.75,20.29 v9(241.69,20.29) 241.36,20.29 v9(240.7,19.63) 239.68,18.6 arc(239.46,18.46) 239.21,18.41 v13(239.21,18.41) v9(237.68,18.41) v13(236.41,18.41) v13(235.14,18.41) v13(234.13,18.41) v9(233.11,18.41) v9(231.84,18.41) v13(230.57,18.41) v9(229.3,18.41) v9(228.03,18.41) 226.76,18.41 v9(226.75,18.42) 226.56,18.61 v9(225.57,18.61) v13(224.55,18.61) v13(223.31,18.61) v9(221.4,18.61) v13(220.27,18.61) v9(219.25,18.61) 219.17,18.61 218.53,17.98 v9(217.31,17.98) v9(216.04,17.98) v9(214.97,19.04) v13(214.16,19.04) v13(213.25,19.04) v13(212.61,19.68) v9(211.72,19.68) v9(210.53,19.68) v9(209.41,19.68) v13(208.62,20.46) v13(207.81,21.28) v9(206.97,22.12) v13(206.16,22.93) v9(205.45,23.64) 205.25,23.84 v9(205.25,24.78) v9(205.25,25.77) v9(205.83,26.36) v9(206.59,27.12) v9(206.59,28.16) v9(206.59,29.56) v9(206.59,30.83) v9(206.59,32.07) v9(206.59,33.34) v9(206.59,34.61) 206.59,35.93 v13(206.5,36.02) 205.55,36.97 v9(205.55,37.05) 205.47,37.13 v13(205.47,37.97) 205.47,38.77 arc(205.35,39.38) v9(205.01,39.89) v9(203.95,40.95) v13(202.68,42.22) v13(201.41,43.49) v9(200.67,44.23) arc(200.49,44.35) 200.28,44.39 199.51,44.39 arc(199.34,44.4) v13(199.18,44.44) arc(198.9,44.56) 198.66,44.75 v13(198.36,45.05) 198.36,45.05 198.34,45.07 arc(197.96,45.39) v13(197.52,45.63) arc(196.99,45.81) 196.42,45.86 v13(196.42,45.87) 196.4,45.87 v9(195.85,46.42) v13(194.83,47.44) v13(193.99,48.28) v13(192.8,49.47) 192.5,49.78 v5(192.5,50.49) 192.5,51.07 192.22,51.35 v13(192.22,51.83) 192.22,52.39 v9(191.63,52.98) 191.16,53.45 190.88,53.45 v9(190.41,53.92) v9(189.47,54.86) v13(188.53,55.8) v9(187.44,56.89) v13(186.48,57.85) v13(185.61,58.72) 185.33,59 v13(184.82,59) v13(183.81,59) 183.68,59 183.12,59.56 182.74,59.56 v13(182.68,59.62) 182.2,60.1 v9(181.41,60.1) 180.65,60.86 v13(180.56,60.86) 177.98,60.86 arc(177.52,60.95) 177.12,61.21 v9(175.5,62.83) v9(174.64,63.7) v9(173.52,64.81) v13(172.4,64.81) v13(171.08,64.81) v9(169.81,64.81) v13(168.54,64.81) v9(167.27,64.81) 167.15,64.69 v13(166.16,64.69) v13(164.78,64.69) v13(163.51,64.69) 163.49,64.69 163.36,64.81 v13(162.29,64.81) v13(161,64.81) 160.93,64.88 160.23,64.88 v13(159.6,64.25) 159.35,64 158.38,64 v13(158.31,63.92) v13(157.44,63.92) v9(156.17,63.92) v9(154.9,63.92) v9(153.63,63.92) v9(152.36,63.92) 151.3,63.92 v9(151.09,63.72) v13(150.2,62.83) v9(149.24,61.87) 148.43,61.05 v9(148.38,61.05) v9(147.26,61.05) v9(145.89,61.05) v13(144.54,61.05) v13(143.07,61.05) v13(141.8,61.05) 140.55,61.05 v13(140.48,61.13) 140.37,61.13 139.56,61.94 139.56,62.1 v13(139.45,62.21) v9(138.58,63.07) v9(137.55,64.1) v9(136.7,64.95) 136.7,65.69 v13(136.45,65.94) 136.45,66.1 135.8,66.74 v9(135.78,66.74) v13(134.58,66.74) v9(133.34,66.74) v13(132.02,66.74) v13(130.75,66.74) v13(129.53,66.74) v9(128.26,66.74) v13(126.94,66.74) v9(125.69,66.74) v13(124.37,66.74) v13(122.87,66.74) 122.8,66.74 v9(122.33,66.27) v13(121.38,65.32) 121.35,65.32 v13(120.66,64.64) 119.95,64.64 v9(119.55,64.23) v13(118.28,62.96) 116.97,61.65 v9(116.79,61.65) v9(115.96,60.83) 115.74,60.6 112.66,60.6 v9(111.85,61.41) 111.82,61.43 v9(110.53,61.43) 110,61.43 v9(109.72,61.16) 109.28,60.72 v9(108.62,60.72) v9(106.77,60.72) 106.47,60.72 v13(105.58,59.83) v13(104.46,58.71) v13(103.34,57.6) v13(102.48,56.73) 102.28,56.53 v13(100.83,56.53) v9(99.51,56.53) v13(98.24,56.53) v13(97.04,56.53) v9(95.72,56.53) v13(94.25,56.53) 94.22,56.53 v13(92.95,55.26) v9(92.04,54.35) v9(91.05,53.36) v13(90.08,52.39) 89.24,51.55 v13(89.22,51.55) 88.41,51.55 v5(87.91,51.06) 87.47,50.61 v5(87.4,50.61) v5(87.4,49.98) v5(87.4,49.41) v5(87.4,48.84) v5(87.4,48.27) 87.42,48.25 v13(87.42,47.26) v13(87.42,45.99) v13(87.42,44.72) v9(87.42,43.45) v9(87.42,42.18) 87.4,42.17 v5(87.4,40.39) v5(87.4,39.76) 87.39,39.74 v5(87.39,38.24) v13(87.39,37.3) v9(87.39,36.03) v13(87.39,34.76) v9(87.39,33.49) v13(87.39,32.15) v9(87.39,30.45) v13(86.5,29.56) v13(85.76,28.82) v13(84.93,27.98) v9(84.01,27.07) v9(83.17,26.23) v9(82.34,25.39) v13(81.34,24.4) v9(80.4,23.46) v9(79.41,22.47) v9(78.37,21.43) v13(77.31,20.36) v9(76.47,19.52) v9(75.55,18.61) v13(74.56,17.62) v9(73.78,16.83) 73.65,16.71 v9(72.66,16.71) v13(71.36,16.71) v9(70.09,16.71) v9(68.82,16.71) 68.44,16.71 v13(68.02,16.29) 67.45,15.71 v9(67.3,15.71) v9(66.03,15.71) v13(64.76,15.71) v13(63.49,15.71) v9(62.22,15.71) v13(60.95,15.71) v9(59.68,15.71) v13(58.41,15.71) v9(57.14,15.71) v13(55.92,15.71) v9(54.55,15.71) v9(53.28,15.71) v9(51.91,15.71) v9(50.74,15.71) v13(49.75,15.71) 49.42,15.71 v9(48.6,16.53) v9(47.94,17.19) v9(47,18.13) v9(46.17,18.97) v9(45.1,20.03) v13(44.06,21.07) v13(43.07,22.06) v13(42.13,23) v9(41.14,24) v13(40.3,24.83) 39.51,25.62 v5(39.51,26.19) 38.99,26.19 38.11,27.07 v13(38.11,30.09) v9(38.11,32.02) v13(38.11,33.93) v13(38.11,35.55) v13(38.11,37.08) v9(38.11,38.4) 38.11,38.42 37.89,38.65 37.89,39.74 37.76,39.87 v9(37.76,40.45) 37.76,40.91 v9(37.45,41.22) v13(36.97,41.7) 36.54,42.13 36.54,42.82 v13(36.29,43.07) v9(35.27,44.09) v9(34.81,44.54) v13(33.85,45.51) v9(33.06,46.3) v13(32.25,47.11) v9(31.31,48.05) 31.28,48.07 v9(31.28,49.27) 31.28,49.47 31.48,49.67 31.48,50.56 v13(31.26,50.79) 30.9,51.15 v9(29.99,51.15) v13(28.72,51.15) v9(27.45,51.15) v9(26.18,51.15) v13(24.91,51.15) 24.78,51.15 24.62,50.99 24.62,50.07 v5(24.87,49.81) 24.63,49.56 v9(24.63,48.61) v13(25.26,47.97) v13(26.05,47.19) v13(27.01,46.22) 27.98,45.26 v9(28.36,45.26) 28.39,45.26 v13(29.48,44.16) v13(30.49,43.15) 31.51,42.13 v9(31.51,42.11) 31.51,40.61 v9(31.52,40.59) v13(32.48,39.64) v9(33.36,38.75) 34.25,37.86 v9(34.25,37.84) v13(34.25,36.64) v13(34.25,35.58) v13(34.25,34.43) v9(34.25,33.16) v13(34.25,31.89) v13(34.25,30.62) v9(34.25,29.28) v13(34.25,28.01) v9(34.25,26.89) 34.25,25.67 v9(34.53,25.39) v9(35.12,24.81) 35.65,24.27 v9(35.65,23.92) ; v13(180.86,31.74) 179.74,31.74 v13(179.69,31.79) 179.64,31.74 v13(178.86,31.74) 178.8,31.74 v13(177.84,32.71) 176.93,33.62 v13(176.92,33.62) 176.92,33.62 v9(176.01,34.54) v13(174.99,35.55) 174.26,36.29 v13(174.05,36.29) 173.68,36.29 v9(173.03,36.94) v13(172.01,37.96) 171.85,38.12 v9(171.13,38.12) v13(170.22,39.03) v13(169.43,39.82) v9(167.96,39.82) v9(166.66,39.82) v9(165.47,39.82) 164.76,39.82 v13(164.42,39.48) 164.05,39.11 v13(164.05,38.57) 164.05,38.12 v9(164.38,37.79) 164.38,37.56 164.96,36.97 v13(164.96,36.92) 165.01,36.92 165.24,36.7 v9(166.1,36.7) v9(167.27,36.7) v9(168.39,36.7) 168.87,36.7 v9(169.15,36.42) 169.46,36.11 v9(170.32,36.11) 171.16,36.11 v13(171.54,35.73) v9(172.38,34.89) 173.04,34.23 v13(173.34,34.23) 173.57,34.23 v9(174.12,33.69) v13(175.05,32.76) 176.06,31.74 v13(176.06,31.72) 176.09,31.72 v13(177.05,30.75) 178.12,29.68 v9(178.14,29.68) v13(179.46,29.68) v13(180.79,29.68) v13(182.03,29.68) v9(183.2,29.68) 183.88,29.68 v9(184.29,29.28) 184.7,28.87 v13(185.38,28.87) 185.59,28.87 v13(186.02,28.44) 186.2,28.26 186.55,28.26 v13(187.3,27.51) v9(188.25,26.56) 189.5,26.56 v13(189.6,26.46) 189.68,26.46 v9(190.36,25.77) v13(191,25.14) 191.07,25.06 v13(191.07,23.79) 191.07,23.41 v13(192,22.48) 191.99,22.47 v9(191.99,21.73) v9(191.99,20.46) v9(191.99,19.35) v13(191.99,18.08) v13(191.99,16.81) v9(191.99,15.54) 191.99,15.23 v9(192.44,14.78) 192.94,14.28 v9(193.83,14.28) v13(194.77,13.34) v13(196.01,12.1) v13(197.11,11) v13(197.99,10.12) v13(198.93,9.18) v13(199.99,8.12) 200.13,7.98 200.13,7.55 v13(200.65,7.03) v9(201.51,6.16) 202.63,5.05 v9(202.68,5.05) v13(204.26,5.05) v13(205.53,5.05) v9(206.82,5.05) v9(208.04,5.05) v9(209.44,5.05) 209.95,5.05 210.12,4.87 v9(210.48,4.87) v9(211.57,4.87) v13(212.69,4.87) 213.45,4.87 v9(213.63,4.69) v9(214.39,3.93) 214.64,3.68 v9(215.1,3.68) v13(216.47,3.68) v13(217.74,3.68) v9(219.01,3.68) v9(220.28,3.68) v9(221.55,3.68) v13(222.82,3.68) v9(224.09,3.68) v9(225.36,3.68) v13(226.63,3.68) v13(227.9,3.68) v9(229.17,3.68) v13(230.44,3.68) 231.08,3.68 v13(231.31,3.45) 231.49,3.26 232.81,3.26 233.39,2.69 v13(233.39,2.68) 233.93,2.68 v13(234.4,2.22) 234.71,1.91 v9(235.4,1.91) v9(236.67,1.91) v13(237.81,1.91) v13(239.08,1.91) v9(240.35,1.91) v9(241.62,1.91) v9(242.89,1.91) v13(244.03,1.91) v9(245.35,1.91) v13(246.7,1.91) v9(247.92,1.91) 247.97,1.91 v9(248.78,2.72) v13(249.49,3.43) 249.64,3.58 249.64,3.8 v3(249.8,3.95) 249.92,4.08 250.14,4.08 v13(250.5,4.44) 250.64,4.57 v13(250.64,5.71) 250.46,5.89 v13(249.65,5.89) 249.35,6.18 v13(249.35,7.07) ; v9(273.11,60.72) v9(274.59,60.72) 275.05,60.72 v9(275.71,61.38) v13(276.57,62.25) 277.13,62.81 v13(277.13,63.39) v9(277.13,64.76) v9(277.13,65.6) 277.13,66.16 v13(277.78,66.81) v9(278.52,67.56) v13(279.26,68.29) 279.92,68.29 v5(279.95,68.32) 280.2,68.57 v5(280.48,68.57) 280.89,68.57 v5(281.09,68.37) 281.09,66.54 v5(281.04,66.49) v9(281.04,65.65) v9(281.04,64.28) 281.04,64.28 v5(281.04,63.31) v5(281.04,61.92) 280.55,61.43 v5(280.51,61.43) v13(279.72,61.43) 279.01,61.43 278.8,61.23 v13(278.68,61.1) v9(277.81,60.24) v9(276.59,59.02) v13(275.63,58.06) v13(274.77,58.06) v13(273.29,58.06) v9(272.02,58.06) v13(270.75,58.06) 270.04,57.35 v9(270.04,56.74) 270.04,55.65 v5(270.04,55.65) v5(269.12,55.65) v5(268.2,55.65) 268.12,55.57 v4(267.28,55.57) 266.37,55.57 v4(266.36,55.58) 266.1,55.84 v9(266.1,56.35) 265.95,56.51 265.95,57.42 v13(266.79,58.26) v9(267.69,59.16) v9(268.45,59.92) v9(269.25,60.72) v9(270.55,60.72) v9(271.84,60.72) v9(273.11,60.72)
  IN1 w0.508: v3(128.97,20.82) 128.92,20.77 v10(128.43,20.77)
  GND2 w0.203: 4.89,47.15 JP1.19 ; JP1.19 6.89,47.15 ; JP1.19 5.89,47.15 ; JP1.19 6.89,47.85 ; JP1.19 4.89,47.85 ; JBATT1.12 39.52,9.23 ; JBATT1.12 40.48,10.18 ; JBATT1.12 38.62,11.09 ; JBATT1.12 40,9.71 ; JBATT1.12 39.78,10.87 ; JBATT1.12 38.83,9.92 ; JBATT1.12 39.09,11.57 ; JBATT1.12 38.14,10.61 ; HCPU2.1 115.93,36.32 ; HCPU2.1 115.38,34.81 ; HCPU2.1 111.82,36.32 ; HCPU2.1 113.87,34.26 ; HCPU2.1 115.38,37.83 ; HCPU2.1 112.37,34.81 ; HCPU2.1 113.87,38.38 ; HCPU2.1 112.37,37.83 ; 39.21,26.59 H4.1 ; H4.1 42.16,27.84 ; H4.1 40.46,26.14 ; H4.1 41.72,26.59 ; H4.1 39.21,29.1 ; H4.1 41.72,29.1 ; H4.1 40.46,29.54 ; H4.1 38.76,27.84 ; 35.68,13.07 JBATT1.11 ; JBATT1.11 37.07,11.69 ; JBATT1.11 37.54,12.16 ; JBATT1.11 38.02,12.64 ; JBATT1.11 37.33,13.33 ; JBATT1.11 36.37,12.38 ; JBATT1.11 36.64,14.02 ; JBATT1.11 36.16,13.55 ; 285.45,53.03 H10.1 ; H10.1 288.68,56.25 ; H10.1 285.45,56.25 ; H10.1 289.27,54.64 ; H10.1 287.06,52.43 ; H10.1 284.85,54.64 ; H10.1 287.06,56.85 ; H10.1 288.68,53.03 ; 7.79,81.64 JUSBC1.4 ; JUSBC1.4 10.1,81.05 ; JUSBC1.4 10.1,82.22 ; JUSBC1.4 10.1,81.64 ; JUSBC1.4 7.79,82.22 ; JUSBC1.4 7.79,81.05 ; JUSBC1.4 8.95,82.22 ; JUSBC1.4 8.95,81.05 ; H9.1 255.85,31.08 ; H9.1 254.6,34.04 ; H9.1 255.85,33.59 ; H9.1 252.9,32.34 ; H9.1 256.3,32.34 ; H9.1 253.34,33.59 ; H9.1 254.6,30.63 ; H9.1 253.34,31.08 ; JUSBC2.2 284.6,71.03 ; JUSBC2.2 284.09,71.03 ; JUSBC2.2 285.11,71.03 ; 7.79,72.37 JUSBC1.3 ; JUSBC1.3 8.95,72.37 ; JUSBC1.3 10.1,71.2 ; JUSBC1.3 8.95,71.2 ; JUSBC1.3 7.79,71.2 ; JUSBC1.3 10.1,71.78 ; JUSBC1.3 7.79,71.78 ; JUSBC1.3 10.1,72.37 ; H6.1 91.16,55.22 ; H6.1 88.95,53.01 ; H6.1 86.74,55.22 ; H6.1 87.33,56.84 ; H6.1 87.33,53.61 ; H6.1 90.56,56.84 ; H6.1 90.56,53.61 ; H6.1 88.95,57.43 ; 288.34,72.05 JUSBC2.1 ; JUSBC2.1 289.55,70.7 ; JUSBC2.1 290.76,71.38 ; JUSBC2.1 288.34,71.38 ; JUSBC2.1 289.55,72.05 ; JUSBC2.1 290.76,72.05 ; JUSBC2.1 288.34,70.7 ; JUSBC2.1 290.76,70.7 ; HSSD1.1 105.29,19.21 ; HSSD1.1 103.79,18.66 ; HSSD1.1 105.29,15.09 ; HSSD1.1 106.8,18.66 ; HSSD1.1 103.23,17.15 ; HSSD1.1 106.8,15.64 ; HSSD1.1 103.79,15.64 ; HSSD1.1 107.35,17.15 ; JUSBC1.6 3.35,83.23 ; JUSBC1.6 4.56,83.23 ; JUSBC1.6 2.14,82.56 ; JUSBC1.6 4.56,82.56 ; JUSBC1.6 4.56,81.89 ; JUSBC1.6 3.35,81.89 ; JUSBC1.6 2.14,83.23 ; JUSBC1.6 2.14,81.89 ; JUSBC2.4 285.1,61.18 ; JUSBC2.4 282.79,60.02 ; JUSBC2.4 285.1,60.02 ; JUSBC2.4 283.95,60.02 ; JUSBC2.4 285.1,60.6 ; JUSBC2.4 282.79,61.18 ; JUSBC2.4 282.79,60.6 ; JUSBC2.4 283.95,61.18 ; JBATT1.14 50.91,20.61 ; JBATT1.14 50.43,20.14 ; JBATT1.14 49.95,19.66 ; JBATT1.14 48.57,21.04 ; JBATT1.14 49.52,22 ; JBATT1.14 50.21,21.3 ; JBATT1.14 49.26,20.35 ; JBATT1.14 49.05,21.52 ; 177.52,34.81 HCPU3.1 ; HCPU3.1 179.02,34.26 ; HCPU3.1 180.53,37.83 ; HCPU3.1 179.02,38.38 ; HCPU3.1 177.52,37.83 ; HCPU3.1 176.97,36.32 ; HCPU3.1 180.53,34.81 ; HCPU3.1 181.08,36.32 ; 177.08,65.03 HCPU4.1 ; HCPU4.1 180.65,63.52 ; HCPU4.1 180.09,62.02 ; HCPU4.1 176.53,63.52 ; HCPU4.1 178.59,61.47 ; HCPU4.1 178.59,65.58 ; HCPU4.1 177.08,62.02 ; HCPU4.1 180.09,65.03 ; 2.14,71.53 JUSBC1.1 ; JUSBC1.1 4.56,70.86 ; JUSBC1.1 4.56,71.53 ; JUSBC1.1 2.14,70.86 ; JUSBC1.1 4.56,70.19 ; JUSBC1.1 3.35,71.53 ; JUSBC1.1 3.35,70.19 ; JUSBC1.1 2.14,70.19 ; 7.79,71.2 JUSBC1.2 ; JUSBC1.2 8.3,71.2 ; JUSBC1.2 8.81,71.2 ; HCPU1.1 115.81,62.02 ; HCPU1.1 114.31,65.58 ; HCPU1.1 115.81,65.03 ; HCPU1.1 116.37,63.52 ; HCPU1.1 112.25,63.52 ; HCPU1.1 112.8,62.02 ; HCPU1.1 112.8,65.03 ; HCPU1.1 114.31,61.47 ; 284.09,60.02 JUSBC2.5 ; JUSBC2.5 285.11,60.02 ; JUSBC2.5 284.6,60.02 ; JP1.21 17.1,60.75 ; JP1.21 17.1,61.7 ; JP1.21 16.4,60.75 ; JP1.21 17.1,62.65 ; JP1.21 16.4,62.65 ; 10.7,83.75 H1.1 ; H1.1 10.7,81.95 ; H1.1 12.81,82.85 ; H1.1 12.5,81.95 ; H1.1 11.6,81.64 ; H1.1 11.6,84.06 ; H1.1 10.39,82.85 ; H1.1 12.5,83.75 ; H2.1 4.85,69.91 ; H2.1 3.23,66.09 ; H2.1 4.85,65.49 ; H2.1 7.06,67.7 ; H2.1 6.46,66.09 ; H2.1 2.64,67.7 ; H2.1 6.46,69.31 ; H2.1 3.23,69.31 ; JP1.20 17.1,50.15 ; JP1.20 16.4,50.15 ; JP1.20 16.4,52.05 ; JP1.20 17.1,51.1 ; JP1.20 17.1,52.05 ; JBATT1.13 48.45,23.07 ; JBATT1.13 47.76,23.76 ; JBATT1.13 46.59,23.98 ; JBATT1.13 47.5,22.12 ; JBATT1.13 46.8,22.81 ; JBATT1.13 46.11,23.5 ; JBATT1.13 47.97,22.59 ; JBATT1.13 47.07,24.45 ; H8.1 274.61,4.41 ; H8.1 273,0.59 ; H8.1 270.79,2.8 ; H8.1 274.61,1.19 ; H8.1 275.21,2.8 ; H8.1 273,5.01 ; H8.1 271.38,1.19 ; H8.1 271.38,4.41 ; 288.34,59 JUSBC2.6 ; JUSBC2.6 289.55,60.35 ; JUSBC2.6 290.76,59.68 ; JUSBC2.6 289.55,59 ; JUSBC2.6 290.76,60.35 ; JUSBC2.6 288.34,60.35 ; JUSBC2.6 290.76,59 ; JUSBC2.6 288.34,59.68 ; H5.1 21.51,4.41 ; H5.1 18.28,4.41 ; H5.1 18.28,1.19 ; H5.1 21.51,1.19 ; H5.1 19.9,0.59 ; H5.1 22.11,2.8 ; H5.1 17.69,2.8 ; H5.1 19.9,5.01 ; JUSBC2.3 285.1,69.87 ; JUSBC2.3 283.95,71.03 ; JUSBC2.3 282.79,69.87 ; JUSBC2.3 285.1,70.45 ; JUSBC2.3 282.79,71.03 ; JUSBC2.3 282.79,70.45 ; JUSBC2.3 283.95,69.87 ; JUSBC2.3 285.1,71.03 ; 202.33,53.61 H7.1 ; H7.1 203.95,57.43 ; H7.1 203.95,53.01 ; H7.1 201.74,55.22 ; H7.1 206.16,55.22 ; H7.1 205.56,53.61 ; H7.1 202.33,56.84 ; H7.1 205.56,56.84 ; 4.89,63.65 JP1.22 ; JP1.22 6.89,64.35 ; JP1.22 4.89,64.35 ; JP1.22 5.89,64.35 ; JP1.22 6.89,63.65 ; JUSBC1.5 8.81,82.22 ; JUSBC1.5 8.3,82.22 ; JUSBC1.5 7.79,82.22
  VCC w0.203: 270.79,2.8 H8.1 ; H8.1 274.61,4.41 ; H8.1 271.38,1.19 ; H8.1 273,0.59 ; H8.1 271.38,4.41 ; H8.1 274.61,1.19 ; H8.1 273,5.01 ; H8.1 275.21,2.8 ; JP1.19 6.89,47.85 ; JP1.19 6.89,47.15 ; JP1.19 5.89,47.15 ; JP1.19 4.89,47.85 ; JP1.19 4.89,47.15 ; H1.1 12.81,82.85 ; H1.1 10.39,82.85 ; H1.1 12.5,83.75 ; H1.1 11.6,81.64 ; H1.1 10.7,81.95 ; H1.1 11.6,84.06 ; H1.1 12.5,81.95 ; H1.1 10.7,83.75 ; JUSBC2.1 289.55,72.05 ; JUSBC2.1 288.34,70.7 ; JUSBC2.1 288.34,72.05 ; JUSBC2.1 290.76,70.7 ; JUSBC2.1 289.55,70.7 ; JUSBC2.1 290.76,71.38 ; JUSBC2.1 290.76,72.05 ; JUSBC2.1 288.34,71.38 ; 3.23,69.31 H2.1 ; H2.1 6.46,66.09 ; H2.1 7.06,67.7 ; H2.1 4.85,69.91 ; H2.1 4.85,65.49 ; H2.1 2.64,67.7 ; H2.1 6.46,69.31 ; H2.1 3.23,66.09 ; 283.95,69.87 JUSBC2.3 ; JUSBC2.3 285.1,70.45 ; JUSBC2.3 285.1,71.03 ; JUSBC2.3 285.1,69.87 ; JUSBC2.3 282.79,71.03 ; JUSBC2.3 282.79,69.87 ; JUSBC2.3 283.95,71.03 ; JUSBC2.3 282.79,70.45 ; JUSBC1.6 4.56,82.56 ; JUSBC1.6 2.14,81.89 ; JUSBC1.6 3.35,83.23 ; JUSBC1.6 3.35,81.89 ; JUSBC1.6 4.56,83.23 ; JUSBC1.6 4.56,81.89 ; JUSBC1.6 2.14,82.56 ; JUSBC1.6 2.14,83.23 ; 288.34,59 JUSBC2.6 ; JUSBC2.6 290.76,59.68 ; JUSBC2.6 290.76,60.35 ; JUSBC2.6 289.55,59 ; JUSBC2.6 288.34,60.35 ; JUSBC2.6 288.34,59.68 ; JUSBC2.6 289.55,60.35 ; JUSBC2.6 290.76,59 ; 7.79,81.64 JUSBC1.4 ; JUSBC1.4 10.1,82.22 ; JUSBC1.4 7.79,81.05 ; JUSBC1.4 7.79,82.22 ; JUSBC1.4 10.1,81.05 ; JUSBC1.4 8.95,81.05 ; JUSBC1.4 8.95,82.22 ; JUSBC1.4 10.1,81.64 ; 7.79,71.2 JUSBC1.2 ; JUSBC1.2 8.81,71.2 ; JUSBC1.2 8.3,71.2 ; 2.14,70.19 JUSBC1.1 ; JUSBC1.1 4.56,70.86 ; JUSBC1.1 2.14,70.86 ; JUSBC1.1 4.56,71.53 ; JUSBC1.1 2.14,71.53 ; JUSBC1.1 3.35,71.53 ; JUSBC1.1 3.35,70.19 ; JUSBC1.1 4.56,70.19 ; JUSBC2.4 285.1,60.6 ; JUSBC2.4 283.95,61.18 ; JUSBC2.4 283.95,60.02 ; JUSBC2.4 282.79,61.18 ; JUSBC2.4 285.1,61.18 ; JUSBC2.4 282.79,60.6 ; JUSBC2.4 285.1,60.02 ; 284.6,60.02 JUSBC2.5 ; JUSBC2.5 285.11,60.02 ; JUSBC2.5 284.09,60.02 ; 4.89,63.65 JP1.22 ; JP1.22 5.89,64.35 ; JP1.22 6.89,64.35 ; JP1.22 6.89,63.65 ; JP1.22 4.89,64.35 ; H5.1 19.9,5.01 ; H5.1 17.69,2.8 ; H5.1 21.51,1.19 ; H5.1 18.28,4.41 ; H5.1 22.11,2.8 ; H5.1 18.28,1.19 ; H5.1 19.9,0.59 ; H5.1 21.51,4.41 ; 285.45,56.25 H10.1 ; H10.1 287.06,52.43 ; H10.1 287.06,56.85 ; H10.1 285.45,53.03 ; H10.1 289.27,54.64 ; H10.1 288.68,53.03 ; H10.1 284.85,54.64 ; H10.1 288.68,56.25 ; 7.79,71.78 JUSBC1.3 ; JUSBC1.3 7.79,72.37 ; JUSBC1.3 8.95,71.2 ; JUSBC1.3 7.79,71.2 ; JUSBC1.3 10.1,71.2 ; JUSBC1.5 8.3,82.22 ; JUSBC1.5 8.81,82.22 ; JUSBC1.5 7.79,82.22 ; JUSBC2.2 285.11,71.03 ; JUSBC2.2 284.6,71.03 ; JUSBC2.2 284.09,71.03
  IN2 w0.127: 125.65,12.65 126.37,12.65 v8(126.38,12.64) 126.39,12.65 126.66,12.65 v3(127.26,12.04) 127.61,11.7 128.18,11.7 128.48,12 128.96,12 128.98,12.02 132.16,12.02 132.89,11.29 143.48,11.29 143.8,10.97 v3(147.56,10.97) v3(148.86,10.97) 150.02,10.97 v8(150.13,11.08) 150.21,11 162.42,11 v3(162.44,11.02) 165.33,11.02 v8(165.62,11.32) 167.06,12.76 167.06,13.35 v8(166.68,13.72) 166.68,14.03 167.55,14.9 167.55,23.06 166.16,24.45 164.89,24.45 v8(164.12,23.69) 164.05,23.77 v8(163.29,23.77) 163.05,23.53 158.66,23.53 158.47,23.72 157.72,23.72 v8(157.67,23.77) 157.63,23.72 157.16,23.72 v3(156.81,23.37) 156.38,23.8 153.31,23.8 152.52,23.01 151.25,23.01 151.25,23.02 ; 125.65,12.65 v8(125.66,12.64) ; 125.65,12.65 124.96,12.65 v8(124.78,12.46) 123.71,11.4 121.75,11.4 121.04,10.69 v8(118.45,10.69) 117.44,10.69 v8(116.85,11.27) 116.85,11.28 115.2,11.28 v8(115.18,11.3) 114.71,11.77 114.66,11.77 v8(114.44,11.98) 114.19,12.23 114.07,12.23 v8(113.65,12.64) 113.56,12.55 112.78,12.55 112.03,13.3 v8(112.03,13.35) 111.93,13.35 110.94,14.34 110.94,19.28 111.4,19.74 v3(111.41,19.72) 111.41,21.83 v8(112.03,22.45) 112.22,22.64 112.33,22.64 v8(112.74,23.05) 112.76,23.03 113.68,23.03 v8(113.75,22.95) 114.16,22.55 116.55,22.55 117.02,23.02 v8(117.6,23.02) 117.77,22.85 119.03,22.85 v3(119.26,23.09) 119.59,23.42 120.45,23.42 120.61,23.26 121.27,23.26 121.53,23.52 127.09,23.52 v8(127.24,23.67) 127.39,23.52 128.82,23.52 128.9,23.43 128.9,23.39 v3(128.94,23.39) 128.94,23.39 129.17,23.16 131.23,23.16 v8(131.26,23.13) 131.63,23.13 132.13,23.64 ; 132.13,23.64 132.49,23.99 135.03,23.99 135.65,23.38 137.34,23.38 137.55,23.59 v3(140.91,23.59) 140.93,23.61 144.02,23.61 v8(144.08,23.67) 144.14,23.61 146.45,23.61 v8(146.46,23.6) 146.73,23.33 147.66,23.33 147.67,23.32 149.23,23.32 149.65,22.9 150.28,22.9 v8(150.46,23.08) 150.56,23.18 151.09,23.18 151.25,23.03 151.25,23.02 ; 132.13,23.64 v3(132.15,23.64) ; 151.25,23.02 v8(151.26,23.02)
  GND3 w0.203: JUSBC1.5 8.81,82.22 ; JUSBC1.5 7.79,82.22 ; JUSBC1.5 8.3,82.22 ; JUSBC1.1 4.56,70.19 ; JUSBC1.1 2.14,71.53 ; JUSBC1.1 4.56,71.53 ; JUSBC1.1 2.14,70.19 ; JUSBC1.1 2.14,70.86 ; JUSBC1.1 3.35,70.19 ; JUSBC1.1 4.56,70.86 ; JUSBC1.1 3.35,71.53 ; JUSBC2.5 285.11,60.02 ; JUSBC2.5 284.6,60.02 ; JUSBC2.5 284.09,60.02 ; JBATT1.11 37.07,11.69 ; JBATT1.11 37.54,12.16 ; JBATT1.11 36.64,14.02 ; JBATT1.11 37.33,13.33 ; JBATT1.11 38.02,12.64 ; JBATT1.11 36.37,12.38 ; JBATT1.11 36.16,13.55 ; JBATT1.11 35.68,13.07 ; JUSBC2.4 285.1,60.6 ; JUSBC2.4 285.1,60.02 ; JUSBC2.4 282.79,60.02 ; JUSBC2.4 283.95,61.18 ; JUSBC2.4 285.1,61.18 ; JUSBC2.4 282.79,60.6 ; JUSBC2.4 283.95,60.02 ; JUSBC2.4 282.79,61.18 ; H9.1 255.85,33.59 ; H9.1 254.6,34.04 ; H9.1 252.9,32.34 ; H9.1 253.34,33.59 ; H9.1 256.3,32.34 ; H9.1 253.34,31.08 ; H9.1 255.85,31.08 ; H9.1 254.6,30.63 ; H5.1 22.11,2.8 ; H5.1 19.9,0.59 ; H5.1 17.69,2.8 ; H5.1 19.9,5.01 ; H5.1 18.28,4.41 ; H5.1 21.51,1.19 ; H5.1 21.51,4.41 ; H5.1 18.28,1.19 ; HCPU2.1 115.93,36.32 ; HCPU2.1 113.87,34.26 ; HCPU2.1 115.38,34.81 ; HCPU2.1 113.87,38.38 ; HCPU2.1 115.38,37.83 ; HCPU2.1 112.37,34.81 ; HCPU2.1 111.82,36.32 ; HCPU2.1 112.37,37.83 ; 112.25,63.52 HCPU1.1 ; HCPU1.1 112.8,62.02 ; HCPU1.1 115.81,65.03 ; HCPU1.1 114.31,61.47 ; HCPU1.1 114.31,65.58 ; HCPU1.1 115.81,62.02 ; HCPU1.1 112.8,65.03 ; HCPU1.1 116.37,63.52 ; 176.97,36.32 HCPU3.1 ; HCPU3.1 180.53,34.81 ; HCPU3.1 181.08,36.32 ; HCPU3.1 179.02,38.38 ; HCPU3.1 179.02,34.26 ; HCPU3.1 180.53,37.83 ; HCPU3.1 177.52,37.83 ; HCPU3.1 177.52,34.81 ; 39.09,11.57 JBATT1.12 ; JBATT1.12 40,9.71 ; JBATT1.12 38.14,10.61 ; JBATT1.12 39.78,10.87 ; JBATT1.12 38.62,11.09 ; JBATT1.12 40.48,10.18 ; JBATT1.12 38.83,9.92 ; JBATT1.12 39.52,9.23 ; H1.1 12.81,82.85 ; H1.1 11.6,81.64 ; H1.1 11.6,84.06 ; H1.1 10.7,83.75 ; H1.1 12.5,81.95 ; H1.1 10.7,81.95 ; H1.1 12.5,83.75 ; H1.1 10.39,82.85 ; 49.52,22 JBATT1.14 ; JBATT1.14 49.26,20.35 ; JBATT1.14 48.57,21.04 ; JBATT1.14 49.05,21.52 ; JBATT1.14 50.43,20.14 ; JBATT1.14 50.21,21.3 ; JBATT1.14 49.95,19.66 ; JBATT1.14 50.91,20.61 ; JUSBC2.6 290.76,60.35 ; JUSBC2.6 289.55,60.35 ; JUSBC2.6 288.34,59 ; JUSBC2.6 290.76,59.68 ; JUSBC2.6 288.34,59.68 ; JUSBC2.6 288.34,60.35 ; JUSBC2.6 290.76,59 ; JUSBC2.6 289.55,59 ; JP1.19 6.89,47.85 ; JP1.19 4.89,47.85 ; JP1.19 4.89,47.15 ; JP1.19 6.89,47.15 ; JP1.19 5.89,47.15 ; 271.38,1.19 H8.1 ; H8.1 271.38,4.41 ; H8.1 275.21,2.8 ; H8.1 274.61,4.41 ; H8.1 273,5.01 ; H8.1 270.79,2.8 ; H8.1 274.61,1.19 ; H8.1 273,0.59 ; 3.35,81.89 JUSBC1.6 ; JUSBC1.6 2.14,81.89 ; JUSBC1.6 4.56,83.23 ; JUSBC1.6 4.56,81.89 ; JUSBC1.6 4.56,82.56 ; JUSBC1.6 2.14,82.56 ; JUSBC1.6 3.35,83.23 ; JUSBC1.6 2.14,83.23 ; 4.89,64.35 JP1.22 ; JP1.22 4.89,63.65 ; JP1.22 6.89,64.35 ; JP1.22 6.89,63.65 ; JP1.22 5.89,64.35 ; JP1.21 17.1,61.7 ; JP1.21 17.1,60.75 ; JP1.21 16.4,60.75 ; JP1.21 16.4,62.65 ; JP1.21 17.1,62.65 ; 7.79,82.22 JUSBC1.4 ; JUSBC1.4 10.1,81.05 ; JUSBC1.4 10.1,82.22 ; JUSBC1.4 8.95,81.05 ; JUSBC1.4 8.95,82.22 ; JUSBC1.4 10.1,81.64 ; JUSBC1.4 7.79,81.05 ; JUSBC1.4 7.79,81.64 ; H7.1 205.56,53.61 ; H7.1 206.16,55.22 ; H7.1 203.95,53.01 ; H7.1 202.33,53.61 ; H7.1 202.33,56.84 ; H7.1 201.74,55.22 ; H7.1 203.95,57.43 ; H7.1 205.56,56.84 ; JUSBC2.2 284.6,71.03 ; JUSBC2.2 285.11,71.03 ; JUSBC2.2 284.09,71.03 ; H4.1 41.72,29.1 ; H4.1 39.21,26.59 ; H4.1 40.46,29.54 ; H4.1 38.76,27.84 ; H4.1 41.72,26.59 ; H4.1 42.16,27.84 ; H4.1 39.21,29.1 ; H4.1 40.46,26.14 ; 289.55,70.7 JUSBC2.1 ; JUSBC2.1 290.76,71.38 ; JUSBC2.1 288.34,71.38 ; JUSBC2.1 290.76,70.7 ; JUSBC2.1 290.76,72.05 ; JUSBC2.1 289.55,72.05 ; JUSBC2.1 288.34,70.7 ; JUSBC2.1 288.34,72.05 ; 285.45,53.03 H10.1 ; H10.1 285.45,56.25 ; H10.1 289.27,54.64 ; H10.1 288.68,56.25 ; H10.1 287.06,56.85 ; H10.1 287.06,52.43 ; H10.1 284.85,54.64 ; H10.1 288.68,53.03 ; H6.1 88.95,57.43 ; H6.1 88.95,53.01 ; H6.1 87.33,56.84 ; H6.1 87.33,53.61 ; H6.1 90.56,53.61 ; H6.1 90.56,56.84 ; H6.1 91.16,55.22 ; H6.1 86.74,55.22 ; 282.79,70.45 JUSBC2.3 ; JUSBC2.3 285.1,69.87 ; JUSBC2.3 282.79,69.87 ; JUSBC2.3 285.1,71.03 ; JUSBC2.3 283.95,71.03 ; JUSBC2.3 282.79,71.03 ; JUSBC2.3 283.95,69.87 ; JUSBC2.3 285.1,70.45 ; JBATT1.13 48.45,23.07 ; JBATT1.13 46.11,23.5 ; JBATT1.13 47.5,22.12 ; JBATT1.13 46.59,23.98 ; JBATT1.13 46.8,22.81 ; JBATT1.13 47.97,22.59 ; JBATT1.13 47.76,23.76 ; JBATT1.13 47.07,24.45 ; H2.1 4.85,69.91 ; H2.1 6.46,66.09 ; H2.1 6.46,69.31 ; H2.1 2.64,67.7 ; H2.1 3.23,66.09 ; H2.1 3.23,69.31 ; H2.1 7.06,67.7 ; H2.1 4.85,65.49 ; JUSBC1.3 10.1,72.37 ; JUSBC1.3 10.1,71.78 ; JUSBC1.3 7.79,72.37 ; JUSBC1.3 10.1,71.2 ; JUSBC1.3 8.95,72.37 ; JUSBC1.3 8.95,71.2 ; JUSBC1.3 7.79,71.2 ; JUSBC1.3 7.79,71.78 ; 103.79,18.66 HSSD1.1 ; HSSD1.1 106.8,18.66 ; HSSD1.1 103.79,15.64 ; HSSD1.1 105.29,15.09 ; HSSD1.1 107.35,17.15 ; HSSD1.1 103.23,17.15 ; HSSD1.1 105.29,19.21 ; HSSD1.1 106.8,15.64 ; JP1.20 17.1,51.1 ; JP1.20 16.4,52.05 ; JP1.20 16.4,50.15 ; JP1.20 17.1,50.15 ; JP1.20 17.1,52.05 ; 8.3,71.2 JUSBC1.2 ; JUSBC1.2 8.81,71.2 ; JUSBC1.2 7.79,71.2
  IN3 w0.102: 128.79,65.02 128.79,64.43 129.14,64.08 129.25,64.08 129.9,63.43 132.38,63.43 132.76,63.8 132.76,64.86
  IN3 w0.127: v5(133.73,65.06) 133.73,65.03 133.56,64.86 132.68,64.86 132.25,65.3 131.74,65.3 v8(131.48,65.04) v8(130.82,65.04) 130.27,65.04 130.2,65.1 128.88,65.1 128.79,65.02 ; v4(261.48,17.24) 261.46,17.21 261.46,16.86 261.29,16.69 260.78,16.69 260.69,16.78 v4(260.62,16.78) ; v15(142.71,66.02) 143.37,66.02 143.69,66.34 v16(144.34,66.34) ; v16(164.86,54.65) 163.51,54.65 v15(163.26,54.91)
  IN3 w0.254: v3(165.08,47.36) 165.07,47.36 v4(164.78,47.65) ; v15(163.26,54.91) v16(162.83,55.34) 162.62,55.54 161.96,55.54 161.71,55.29 v16(161.43,55.29) v15(159.98,55.29) v16(158.71,55.29) v16(157.44,55.29) v16(156.17,55.29) 156.15,55.29 155.93,55.5 v15(154.98,55.5) v5(154.1,55.5) 153.6,56.01 v15(153.15,56.01) v5(152.25,56.01) 152.05,56.01 151.78,56.28 v16(151.78,56.96) 152.31,57.5 v15(152.31,57.75) v16(152.31,58.72) 152.31,59.35 v15(152.01,59.66) 151.98,59.68 v15(151.02,59.68) 150.97,59.68 v16(150.19,60.46) v15(149.39,61.26) v16(149.39,62.53) 149.39,63.24 v16(148.91,63.72) 148.39,64.24 v16(147.92,64.24) v15(146.85,64.24) 146.28,64.24 v16(145.81,63.77) 145.23,63.19 v15(144.77,63.19) v15(143.5,63.19) 143.19,63.19 142.61,63.77 v15(142.05,63.77) v8(141.26,63.77) v16(140.73,63.77) 139.97,63.77 v8(139.79,63.95) 139.28,64.46 v16(139.26,64.46) v15(137.88,64.46) v16(136.69,64.46) v15(135.6,64.46) v15(135.22,64.46) 134.98,64.7 134.14,64.7 133.77,65.06 v5(133.73,65.06) ; v4(261.48,17.24) 261.49,17.25 261.49,17.73 v16(261.02,18.2) 261.02,19.52 260.82,19.73 v4(260.64,19.73) v16(259.63,19.73) v16(259.2,19.3) v16(257.24,19.3) v16(256.48,18.53) v16(255.72,17.77) v16(254.7,16.76) ; v14(154.56,41.56) 154.44,41.56 v5(154.11,41.9) ; v15(142.71,66.02) 141.99,66.02 v15(141.36,66.64) 140.64,67.37 v16(140.54,67.37) v15(139.22,67.37) v16(138.2,67.37) 138.15,67.37 v16(137.66,67.86) v16(136.39,67.86) v16(135.12,67.86) v16(133.85,67.86) v16(132.58,67.86) v15(131.31,67.86) v16(130.04,67.86) v16(128.77,67.86) v16(127.5,67.86) v16(126.23,67.86) v15(124.96,67.86) v15(123.69,67.86) v16(122.42,67.86) v15(121.02,67.86) v15(119.88,67.86) v15(118.61,67.86) 118.59,67.85 117.35,67.85 v16(117.34,67.86) 116.93,67.86 116.53,68.03 v16(116.52,68.04) 116.12,68.21 115.3,69.03 v15(115.3,69.05) 114.62,69.74 v16(114.49,69.74) v15(113.04,69.74) v15(112.03,69.74) 110.81,69.74 v15(110.53,70.02) 110.22,70.32 v15(109.13,70.32) v15(107.86,70.32) 107.61,70.32 v16(106.8,71.14) v16(106.01,71.93) v16(104.66,71.93) v16(103.49,71.93) v16(102.48,71.93) v16(101.26,71.93) 101.21,71.93 101.13,71.85 v16(99.51,71.85) 99.43,71.93 v15(98.64,71.93) v16(97.47,71.93) v15(96.18,71.93) v15(94.96,71.93) v16(93.54,71.93) 93.51,71.93 v15(92.46,70.87) v16(91.31,69.73) v15(90.03,68.45) 90.01,68.42 v16(90.01,67.15) v16(90.01,65.88) v15(90.01,64.61) v16(90.01,63.34) v16(90.01,62.07) v16(90.01,60.6) v15(90.01,59.58) 90.01,59.1 v15(90.59,58.51) v16(91.61,57.5) 92.42,56.69 v15(92.42,55.97) v15(92.42,54.96) 92.42,53.76 v15(92.22,53.56) 92.22,53.54 v16(91.5,52.82) v16(90.64,51.96) v16(89.85,51.17) v15(89.04,50.36) v16(88.34,49.66) 88.22,49.54 v16(88.22,48.62) v16(88.22,44.81) v16(88.22,43.54) v16(88.22,42.27) v16(88.22,41.48) v16(88.22,39.73) v15(88.22,37.19) v15(88.22,35.86) v15(88.22,34.61) v15(88.22,33.38) v15(88.22,31.95) v15(88.22,30.76) 88.22,30.74 v15(87.34,29.86) v15(86.31,28.83) v15(85.43,27.96) v16(84.57,27.09) v16(83.58,26.1) v16(82.59,25.11) v15(81.75,24.27) v15(80.91,23.44) v15(80,22.52) v15(78.91,21.43) v15(77.92,20.44) v15(76.65,19.17) v16(75.53,18.05) v15(74.64,17.16) v15(73.72,16.25) v15(72.33,16.25) v15(71.06,16.25) v15(69.91,16.25) v16(68.64,16.25) v15(67.37,16.25) v16(66.1,16.25) v15(64.83,16.25) v16(63.56,16.25) v15(62.29,16.25) v15(61.1,16.25) v16(59.75,16.25) v16(58.48,16.25) v15(57.21,16.25) v16(55.94,16.25) v15(54.67,16.25) v16(53.4,16.25) v15(52.13,16.25) v15(50.86,16.25) v15(49.59,16.25) v16(48.32,16.25) v15(46.8,16.25) v15(46.04,17.01) v15(45.33,17.72) v16(44.46,18.59) v16(43.45,19.6) v16(42.48,20.57) v15(41.44,21.61) v15(40.53,22.52) v15(39.61,23.44) v16(38.49,24.55) 37.25,25.8 v16(37.25,25.85) v15(37.25,26.87) v15(37.25,27.93) v16(36.29,28.9) v15(35.57,29.61) v15(34.48,30.7) 34.46,30.73 v16(33.19,30.73) v16(31.99,30.73) 31.97,30.73 30.9,29.66 v15(30.87,29.66) v15(29.58,29.66) v15(28.41,29.66) v15(26.73,29.66) v16(25.29,29.66) v15(23.89,29.66) 23.38,29.66 v16(22.28,30.76) 21.73,31.31 v16(21.73,31.79) 21.73,32.25 21.02,32.96 v16(21.02,32.99) v15(21.02,34.21) v16(21.02,35.58) v16(20.18,36.42) v15(19.29,37.3) 18.9,37.69 v15(17.94,37.69) v15(16.67,37.69) v15(15.4,37.69) v15(14.13,37.69) v15(12.86,37.69) 12.84,37.71 11.72,37.71 v15(11.62,37.8) v15(10.28,39.15) v15(9.87,39.56) v16(9.36,40.06) 8.9,40.52 v15(8.9,41.01) 8.9,41.65 8.19,42.36 v16(8.19,42.46) v15(8.19,43.86) 8.19,44.34 v15(7.74,44.8) 6.87,44.8 6.72,44.65 v5(6.67,44.65) 6.57,44.54 6.57,44.19 6.02,43.64 v16(6.02,43.57) 5.45,42.99 v15(5.45,42) 5.45,41.82 v16(12.53,34.73) 12.73,34.54 v15(13.32,34.54) v15(14.59,34.54) v16(15.66,34.54) v16(16.8,34.54) v15(18.3,34.54) 18.33,34.54 18.89,33.98 v16(18.89,33.42) v15(18.89,32.2) 18.89,31.74 19.19,31.44 v16(19.19,30.95) 19.19,30.5 v15(19.6,30.09) v15(20.46,29.23) v15(21.58,28.11) 22.19,27.5 v15(22.95,27.5) v16(24.25,27.5) v16(25.54,27.5) v16(26.84,27.5) 27.34,26.99 v15(27.42,26.99) v16(28.64,26.99) v15(29.76,26.99) v15(30.95,26.99) 31.46,26.48 v16(31.97,26.48) v16(33.29,26.48) 34.41,26.48 34.79,26.1 v15(34.79,25.67) v15(34.79,24.71) 35.37,24.12 35.37,23.79 v16(35.93,23.23) v16(36.69,22.47) 37.33,21.84 v16(37.4,21.84) 38.16,21.84 v15(38.8,21.2) 39.61,20.39 v15(39.61,20.19) v15(40.37,19.42) v15(41.26,18.53) v15(42.05,17.74) v16(43.23,16.57) v15(44.02,15.78) v15(44.78,15.02) v15(45.63,14.17) 45.68,14.11 v16(46.7,14.11) v16(47.97,14.11) v16(49.24,14.11) v16(50.51,14.11) v15(51.78,14.11) v15(53.05,14.11) v16(54.32,14.11) v15(55.59,14.11) v16(56.86,14.11) v15(58.13,14.11) v16(59.4,14.11) v15(60.67,14.11) v15(61.94,14.11) v15(63.21,14.11) v15(64.48,14.11) v16(65.75,14.11) v15(67.02,14.11) v16(68.29,14.11) v16(69.56,14.11) v15(70.83,14.11) v15(72.1,14.11) v15(73.37,14.11) v15(74.64,14.11) v15(75.81,15.28) v16(76.95,16.43) v15(78.07,17.54) v15(79.21,18.69) v15(80.48,19.96) 81.37,20.85 v16(81.4,20.85) 82.21,20.85 v15(82.77,21.4) v15(83.71,22.34) v15(84.88,23.51) v15(85.71,24.35) v15(86.48,25.11) v16(87.21,25.85) v15(88.23,26.87) v16(89.24,27.88) v16(90.02,28.66) 90.31,28.95 v15(90.31,29.86) v15(90.31,31.03) v15(90.31,32.35) v16(90.31,33.66) v16(90.31,34.94) v16(90.31,36.21) v16(90.31,37.41) v15(90.31,39.67) v16(90.31,42.56) v16(90.31,43.83) v16(90.31,45.1) v16(90.31,46.37) v15(90.31,47.64) 90.31,48.66 v16(90.39,48.75) v15(91.41,49.76) 91.48,49.83 91.48,49.83 v16(92.29,50.64) v15(93.26,51.61) v16(94.02,52.37) 94.6,52.95 v15(94.6,54.8) v15(94.6,56.07) v16(94.6,57.49) v15(93.61,58.48) v16(92.34,59.75) 92.3,59.79 v16(92.3,60.85) v16(92.3,62.08) v15(92.3,63.34) v16(92.3,64.61) v15(92.3,65.85) v15(92.3,67.05) 92.3,67.16 93.74,68.6 v15(93.77,68.6) 94.83,69.66 v16(94.83,69.69) v16(96.25,69.69) v15(97.78,69.69) v15(99,69.69) v16(100.34,69.69) v15(101.56,69.69) v16(102.55,69.69) 103.35,69.69 103.45,69.59 v15(103.5,69.59) 104.23,68.86 v16(104.23,68.86) v8(105.59,68.86) v15(106.16,68.29) 106.46,67.99 v15(107.43,67.99) v16(108.9,67.99) 109.26,67.63 v16(109.79,67.63) v15(111.24,67.63) v16(112.41,67.63) v16(113.6,67.63) v15(114.29,66.95) 114.96,66.28 116.48,65.66 v16(117.44,65.66) v15(118.71,65.66) v15(119.98,65.66) v16(121.25,65.66) v16(122.52,65.66) v15(123.79,65.66) 125.11,65.66 125.75,65.02 v15(125.79,65.02) v15(127.37,65.02) v16(128.31,65.02) 128.79,65.02 ; v4(95.26,37.28) 94.83,37.28 v3(94.81,37.3) ; v16(164.86,54.65) v15(165.6,55.39) v15(166.38,56.18) v15(167.65,56.18) v16(168.92,56.18) v15(170.19,56.18) 170.8,56.18 v16(171.41,55.57) v16(171.9,55.08) v15(172.76,54.22) v16(173.5,53.48) v15(174.44,52.54) 174.89,52.09 v16(175.32,52.09) v16(176.42,52.09) v15(177.69,52.09) v16(179.21,52.09) 180.46,52.09 v15(180.54,52) v15(181.56,50.98) v16(182.28,50.26) v15(183.15,49.4) v15(184.05,48.49) 184.41,48.13 184.84,48.13 v15(185.63,47.33) v16(186.52,46.44) 186.72,46.25 187.49,46.25 v16(187.57,46.17) v16(188.34,45.39) v15(189.35,44.39) v15(190.25,43.49) 191.36,42.37 v15(191.7,42.37) v16(192.56,42.37) v16(193.36,41.57) 193.86,41.08 v16(193.86,41.04) 193.86,39.95 v16(194.57,39.24) 195.93,37.87 v16(195.93,37.81) 195.93,37.67 v16(196.87,36.73) v15(197.7,35.9) v16(198.59,35.01) 199,34.6 v16(199,34.16) v16(199,32.7) 199,31.65 v15(198.71,31.36) 198.53,31.18 v16(198.53,30.08) 198.53,29.37 v16(199,28.89) v16(199,27.65) v15(199,26.36) v16(199,24.94) 199,24.85 199,24.85 199,24.05 v16(199,24.04) 199,24.01 198.2,23.21 v16(198.16,23.21) v16(197.42,22.47) v16(196.56,21.61) 195.62,20.67 v16(195.62,20.62) v16(195.62,19.52) v15(195.62,18.25) v16(195.62,17.24) v15(195.62,16.63) 195.62,15.82 v16(196,15.44) 196,14.32 v16(196.23,14.09) 196.41,13.91 v15(196.71,13.91) v15(198.01,13.91) v16(199.28,13.91) v16(200.55,13.91) v16(201.82,13.91) 201.87,13.91 v15(202.66,14.7) 203.32,15.36 v16(203.32,15.61) 203.32,16.35 202.93,16.73 v16(202.93,17.11) 202.93,18.17 v16(202.92,18.18) 202.93,18.19 v15(202.93,19.42) 202.93,19.81 v16(203.02,19.89) v15(203.76,20.63) 203.96,20.63 204.9,21.57 204.9,21.6 204.92,21.61 v16(204.92,22.7) v15(204.92,23.97) v15(204.92,25.54) v15(204.92,26.79) 205.68,27.55 v16(205.68,28.14) v16(205.68,29.35) v15(205.68,30.55) v15(205.68,32.07) v15(205.68,33.34) v16(205.68,34.61) 205.68,35.88 v15(205.63,35.93) v15(205.11,36.45) 204.81,36.75 v16(204.81,37.33) v16(204.81,38.52) 204.81,38.89 v15(204.24,39.46) v16(202.97,40.73) 202.97,40.73 202.13,41.57 v15(202.12,41.57) 202.12,41.58 201.45,42.25 200.81,42.25 v15(200.47,42.59) v16(199.45,43.6) v15(198.59,44.47) v16(197.58,45.48) v16(196.53,46.53) v15(195.75,47.31) 195.09,47.97 v15(195.09,48) 195.06,48 v15(194.34,48.72) 194.14,48.92 192.66,48.92 v15(192.58,49) 191.55,50.03 v16(191.53,50.03) v15(190.39,51.17) v15(189.6,51.96) v15(188.33,53.23) v16(187.31,54.25) v15(186.3,55.26) v16(185.38,56.18) v16(184.39,57.17) v16(183.55,58.01) v16(182.92,58.64) 182.69,58.87 v15(182,58.87) 181.7,58.87 v15(180.86,59.71) 180.46,60.11 v15(179.64,60.11) v16(178.55,60.11) v15(177.36,60.11) v16(176.26,60.11) v15(175.15,61.23) v15(174.21,62.17) v15(173.32,63.06) v16(172.38,64) 172.05,64.33 v15(171.36,64.33) v16(170.02,64.33) v16(168.75,64.33) v16(167.48,64.33) v15(166.21,64.33) v15(164.94,64.33) v15(163.79,64.33) v15(162.4,64.33) 162.35,64.33 v15(161.93,64.75) 161.74,64.94 v15(160.75,64.94) 160.21,64.94 v15(159.74,64.47) 159.74,63.94 158.48,62.68 v15(158.41,62.68) v16(157.09,62.68) v15(155.77,62.68) v16(154.73,62.68) v16(153.73,63.67) v15(153.07,64.33) v15(152.01,65.4) v16(151.27,66.13) v15(150.84,66.57) 150.81,66.59 v15(149.42,66.59) 148.68,66.59 148.43,66.34 v15(148.35,66.34) v16(147.23,66.34) v16(145.76,66.34) v16(144.34,66.34) ; v14(154.56,40.26) 154.87,39.95 v3(154.9,39.95) ; v14(153.64,41.56) 153.93,41.27 v3(154.11,41.27) ; v16(254.7,16.76) v16(255.18,16.27) v16(255.18,15.16) v16(255.18,14.39) v16(254.04,13.25) v16(253.15,12.36) v16(252.64,11.85) v16(251.63,10.84) v16(250.64,10.84) v16(250.36,11.12) v16(250.36,12.46) v16(250.36,13.48) v16(251.19,14.32) v16(252.21,15.33) v16(252.79,15.33) v16(253.81,16.35) v4(253.81,16.76) ; v16(254.7,16.76) v4(253.81,16.76) ; v15(139.89,57.27) 139.89,57.73 140.63,58.46 v15(140.63,58.64) 140.93,58.95 140.96,58.95 141.38,59.37 v16(141.38,59.42) 142.51,60.55 v15(142.89,60.55) 142.89,60.55 143.83,60.55 143.98,60.39 v8(143.98,59.83) 143.98,59.3 143.8,59.12 v15(143.04,59.12) 142.58,59.12 v16(141.87,58.41) 141.26,57.8 v8(141.26,57.35) 141.26,56.13 v15(141.09,55.95) 140.3,55.95 v16(140.15,56.1) ; v4(253.81,16.76) v4(253.81,17.24) v4(253.81,17.75) v4(253.81,18.23) v4(253.81,18.76) v16(253.15,18.76) v16(252.46,18.76) v16(251.8,18.1) 251.29,17.59 v16(251.29,17.23) v16(250.53,16.47) v16(249.77,15.71) v16(249.01,14.95) v16(248.43,14.37) v16(248.43,13.61) v16(248.43,12.84) v16(248.43,12.08) v16(248.43,11.07) v16(248.43,10.03) v16(247.16,8.76) v16(246.39,7.99) v16(245.63,7.23) v16(244.72,6.32) v16(244.72,4.74) 245.12,4.34 v3(245.33,4.34) 245.38,4.34 245.68,4.03 246.62,4.03 v3(246.65,4.01) 248.27,4.01 v3(248.35,4.08) 248.43,4.01 249.75,4.01 v3(249.8,3.95) 249.98,3.95 250.71,4.69 250.71,5.33 v16(250.33,5.72) v16(250.33,6.7) v16(251.35,7.71) v16(252.36,8.73) v16(253.38,9.75) v16(254.39,10.76) v16(255.28,11.65) v16(256.43,12.79) v16(257.16,13.53) v16(257.16,14.55) v16(257.16,15.97) v16(258.05,16.86) v16(259.3,16.86) 260.54,16.86 v4(260.62,16.78) ; v15(276.67,62.43) 276.67,62.53 v16(277.53,63.39) v16(277.53,64.28) v16(277.53,65.27) v15(277.53,66.46) v16(277.53,67.23) 278.47,68.16 v15(278.47,68.22) 278.8,68.56 278.8,69.03 279.01,69.23 279.77,69.23 v15(280,69) 280.43,68.57 v5(280.48,68.57) 280.89,68.57 v5(281.09,68.37) 281.01,68.29 281.01,66.52 v5(281.04,66.49) v15(281.04,65.78) v16(281.04,64.43) 281.04,64.43 v5(281.04,63.31) v5(281.04,61.92) 280.55,61.43 v5(280.51,61.43) v16(279.79,61.43) 278.96,61.43 278.96,61.43 v15(278.78,61.43) 278.75,61.43 v15(278.07,60.75) v16(277.33,60.01) v16(276.52,59.2) v15(275.78,58.46) v16(274.69,58.46) v16(273.67,58.46) v16(272.89,58.46) 272.86,58.46 v16(272.12,57.73) v16(271.39,56.99) v16(270.73,56.33) 270.05,55.65 v5(270.04,55.65) v5(269.12,55.65) v5(268.2,55.65) 268.12,55.57 v4(267.28,55.57) 266.37,55.57 v4(266.36,55.58) 266,55.94 v15(266,56.23) 266,56.41 265.95,56.46 265.95,57.5 266.33,57.88 v15(266.87,57.88) v15(267.65,58.67) v15(268.52,59.53) v15(269.25,60.27) v16(269.84,60.85) 269.86,60.88 v16(271.44,60.88) v16(272.53,60.88) v16(273.9,60.88) v16(275.12,60.88) v16(275.91,61.66) v15(276.67,62.43) ; 30.6,61.56 v16(30.6,60.11) 30.6,59.2 v5(30.24,58.84) 30.16,58.76 v5(29.24,58.76) 29.23,58.75 v5(28.32,58.75) 28.24,58.67 27.45,58.67 27.4,58.72 v5(27.4,58.73) 26.49,58.73 v5(26.48,58.74) 26.05,58.74 25.9,58.89 25.9,60.72 v16(25.78,60.83) v14(25.78,62.17) 25.78,62.18 25.56,62.4 arc(24.76,63.14) 23.9,63.82 arc(23.32,64.21) 22.72,64.57 arc(22.55,64.67) v8(22.38,64.76) arc(21.54,65.17) 20.66,65.53 arc(20.56,65.56) v8(20.47,65.6) arc(19.3,65.94) 18.12,66.18 arc(18.03,66.19) v8(17.94,66.21) arc(17.75,66.23) 17.55,66.25 arc(16.81,66.32) 16.07,66.34 v16(16.04,66.34) v16(14.72,66.34) v15(13.73,66.34) 13.43,66.34 v15(12.79,66.97) v16(12.23,67.53) v16(11.75,68.01) 10.02,68.01 9.36,68.67 9.36,69.39 v5(9.84,69.87) 9.88,69.91 11.36,69.91 v15(11.37,69.92) 11.38,69.91 11.51,69.91 11.9,70.3 11.9,70.73 v16(12.23,71.06) 12.33,71.16 v15(12.79,71.16) v5(13.7,71.16) 13.68,71.14 v14(13.68,70.55) 13.68,70.17 14.26,69.59 v15(14.36,69.59) 15.13,68.83 v16(15.23,68.83) v16(15.99,68.83) 16.79,68.83 arc(17.59,68.81) v8(18.38,68.75) arc(19.6,68.57) v8(20.81,68.31) arc(21.96,67.96) 23.07,67.52 arc(23.31,67.42) v8(23.54,67.31) arc(24.65,66.73) 25.7,66.07 arc(25.89,65.94) v8(26.08,65.81) arc(27.05,65.04) v16(27.95,64.2) v15(29.02,63.14) v15(29.71,62.45) v16(30.42,61.74) 30.6,61.56 ; v15(171.26,35.63) v15(172.28,34.61) 172.71,34.18 v15(173.7,34.18) v15(174.49,33.39) v15(175.65,32.22) 176.57,31.31 v16(176.59,31.31) v16(177.92,31.31) v15(179.29,31.31) v16(180.73,31.31) v15(182.08,31.31) v15(183.58,31.31) 183.61,31.31 v16(184.27,31.97) 184.98,32.68 v16(185.05,32.68) 185.14,32.68 185.95,33.5 v5(186.04,33.5) 186.04,33.88 185.69,34.23 v3(185.51,34.23) 185.51,34.33 185.16,34.69 v16(184.29,34.69) v15(182.89,34.69) v15(181.7,34.69) 181.7,34.64 v16(181.09,34.03) v16(180.33,33.27) 180.3,33.24 v16(179.19,33.24) v16(178.19,33.24) v16(177.36,33.24) v15(176.34,34.26) v15(175.27,35.32) 174.36,36.24 v16(174.21,36.24) 173.57,36.24 v16(173.17,36.64) v16(172.48,37.33) 171.9,37.91 v16(171.69,37.91) 171.16,37.91 v16(170.68,38.4) 170.52,38.55 v16(169.58,38.55) 168.87,38.55 v15(168.42,39.01) 168.03,39.39 v16(167.3,39.39) v15(166.28,39.39) 165.22,39.39 v4(165.16,39.34) 164.89,39.06 v3(164.83,39.06) 164.79,39.01 164.23,39.01 164.05,38.83 v15(164.05,38.6) 164.05,38.37 165.11,37.3 v15(165.65,37.3) 166.43,37.3 v3(166.64,37.51) 166.84,37.3 167.27,37.3 v16(167.53,37.05) 167.92,36.66 168.75,36.66 v16(169.03,36.39) 169.58,35.83 v16(170.45,35.83) 171.06,35.83 v15(171.26,35.63) ; 150.99,62.73 151.32,63.06 153.02,63.06 v16(153.63,62.45) 153.63,61.66 153.2,61.23 151.42,61.23 150.99,61.66 150.99,62.73
  GND4 w0.203: JUSBC2.6 290.76,59 ; JUSBC2.6 289.55,60.35 ; JUSBC2.6 288.34,59.68 ; JUSBC2.6 290.76,60.35 ; JUSBC2.6 288.34,60.35 ; JUSBC2.6 289.55,59 ; JUSBC2.6 288.34,59 ; JUSBC2.6 290.76,59.68 ; 10.7,83.75 H1.1 ; H1.1 12.5,83.75 ; H1.1 11.6,84.06 ; H1.1 10.39,82.85 ; H1.1 11.6,81.64 ; H1.1 12.5,81.95 ; H1.1 10.7,81.95 ; H1.1 12.81,82.85 ; 47.07,24.45 JBATT1.13 ; JBATT1.13 47.76,23.76 ; JBATT1.13 46.8,22.81 ; JBATT1.13 47.5,22.12 ; JBATT1.13 48.45,23.07 ; JBATT1.13 46.59,23.98 ; JBATT1.13 46.11,23.5 ; JBATT1.13 47.97,22.59 ; 3.35,81.89 JUSBC1.6 ; JUSBC1.6 4.56,83.23 ; JUSBC1.6 3.35,83.23 ; JUSBC1.6 2.14,81.89 ; JUSBC1.6 4.56,82.56 ; JUSBC1.6 4.56,81.89 ; JUSBC1.6 2.14,82.56 ; JUSBC1.6 2.14,83.23 ; 284.09,60.02 JUSBC2.5 ; JUSBC2.5 285.11,60.02 ; JUSBC2.5 284.6,60.02 ; 111.82,36.32 HCPU2.1 ; HCPU2.1 112.37,34.81 ; HCPU2.1 112.37,37.83 ; HCPU2.1 115.38,37.83 ; HCPU2.1 113.87,38.38 ; HCPU2.1 115.38,34.81 ; HCPU2.1 115.93,36.32 ; HCPU2.1 113.87,34.26 ; JBATT1.11 37.07,11.69 ; JBATT1.11 36.16,13.55 ; JBATT1.11 37.54,12.16 ; JBATT1.11 36.64,14.02 ; JBATT1.11 37.33,13.33 ; JBATT1.11 35.68,13.07 ; JBATT1.11 36.37,12.38 ; JBATT1.11 38.02,12.64 ; 39.09,11.57 JBATT1.12 ; JBATT1.12 40.48,10.18 ; JBATT1.12 39.52,9.23 ; JBATT1.12 39.78,10.87 ; JBATT1.12 38.62,11.09 ; JBATT1.12 38.14,10.61 ; JBATT1.12 40,9.71 ; JBATT1.12 38.83,9.92 ; HCPU1.1 114.31,65.58 ; HCPU1.1 116.37,63.52 ; HCPU1.1 114.31,61.47 ; HCPU1.1 112.8,62.02 ; HCPU1.1 112.25,63.52 ; HCPU1.1 112.8,65.03 ; HCPU1.1 115.81,65.03 ; HCPU1.1 115.81,62.02 ; 177.08,62.02 HCPU4.1 ; HCPU4.1 178.59,61.47 ; HCPU4.1 180.09,65.03 ; HCPU4.1 177.08,65.03 ; HCPU4.1 176.53,63.52 ; HCPU4.1 178.59,65.58 ; HCPU4.1 180.65,63.52 ; HCPU4.1 180.09,62.02 ; 252.9,32.34 H9.1 ; H9.1 256.3,32.34 ; H9.1 253.34,31.08 ; H9.1 253.34,33.59 ; H9.1 255.85,31.08 ; H9.1 254.6,34.04 ; H9.1 254.6,30.63 ; H9.1 255.85,33.59 ; 287.06,52.43 H10.1 ; H10.1 287.06,56.85 ; H10.1 285.45,53.03 ; H10.1 289.27,54.64 ; H10.1 288.68,56.25 ; H10.1 284.85,54.64 ; H10.1 288.68,53.03 ; H10.1 285.45,56.25 ; H4.1 41.72,29.1 ; H4.1 41.72,26.59 ; H4.1 40.46,29.54 ; H4.1 42.16,27.84 ; H4.1 39.21,26.59 ; H4.1 40.46,26.14 ; H4.1 39.21,29.1 ; H4.1 38.76,27.84 ; 49.26,20.35 JBATT1.14 ; JBATT1.14 49.52,22 ; JBATT1.14 49.95,19.66 ; JBATT1.14 50.21,21.3 ; JBATT1.14 50.91,20.61 ; JBATT1.14 48.57,21.04 ; JBATT1.14 49.05,21.52 ; JBATT1.14 50.43,20.14 ; JUSBC2.2 284.6,71.03 ; JUSBC2.2 285.11,71.03 ; JUSBC2.2 284.09,71.03 ; H8.1 274.61,4.41 ; H8.1 273,0.59 ; H8.1 271.38,4.41 ; H8.1 275.21,2.8 ; H8.1 274.61,1.19 ; H8.1 273,5.01 ; H8.1 271.38,1.19 ; H8.1 270.79,2.8 ; 4.85,65.49 H2.1 ; H2.1 2.64,67.7 ; H2.1 3.23,66.09 ; H2.1 3.23,69.31 ; H2.1 6.46,69.31 ; H2.1 4.85,69.91 ; H2.1 7.06,67.7 ; H2.1 6.46,66.09 ; 288.34,70.7 JUSBC2.1 ; JUSBC2.1 290.76,71.38 ; JUSBC2.1 289.55,70.7 ; JUSBC2.1 290.76,72.05 ; JUSBC2.1 289.55,72.05 ; JUSBC2.1 290.76,70.7 ; JUSBC2.1 288.34,72.05 ; JUSBC2.1 288.34,71.38 ; 18.28,4.41 H5.1 ; H5.1 17.69,2.8 ; H5.1 21.51,1.19 ; H5.1 22.11,2.8 ; H5.1 18.28,1.19 ; H5.1 19.9,5.01 ; H5.1 19.9,0.59 ; H5.1 21.51,4.41 ; 2.14,71.53 JUSBC1.1 ; JUSBC1.1 3.35,70.19 ; JUSBC1.1 4.56,71.53 ; JUSBC1.1 3.35,71.53 ; JUSBC1.1 4.56,70.86 ; JUSBC1.1 4.56,70.19 ; JUSBC1.1 2.14,70.19 ; JUSBC1.1 2.14,70.86 ; 202.33,56.84 H7.1 ; H7.1 201.74,55.22 ; H7.1 206.16,55.22 ; H7.1 205.56,53.61 ; H7.1 202.33,53.61 ; H7.1 205.56,56.84 ; H7.1 203.95,57.43 ; H7.1 203.95,53.01 ; 103.23,17.15 HSSD1.1 ; HSSD1.1 106.8,18.66 ; HSSD1.1 107.35,17.15 ; HSSD1.1 105.29,19.21 ; HSSD1.1 106.8,15.64 ; HSSD1.1 105.29,15.09 ; HSSD1.1 103.79,18.66 ; HSSD1.1 103.79,15.64 ; JUSBC1.3 10.1,72.37 ; JUSBC1.3 8.95,71.2 ; JUSBC1.3 7.79,72.37 ; JUSBC1.3 7.79,71.2 ; JUSBC1.3 7.79,71.78 ; JUSBC1.3 10.1,71.2 ; JUSBC1.3 10.1,71.78 ; JUSBC1.3 8.95,72.37 ; JP1.22 5.89,64.35 ; JP1.22 6.89,63.65 ; JP1.22 4.89,64.35 ; JP1.22 4.89,63.65 ; JP1.22 6.89,64.35 ; JUSBC2.3 285.1,70.45 ; JUSBC2.3 285.1,71.03 ; JUSBC2.3 282.79,70.45 ; JUSBC2.3 283.95,71.03 ; JUSBC2.3 283.95,69.87 ; JUSBC2.3 285.1,69.87 ; JUSBC2.3 282.79,71.03 ; JUSBC2.3 282.79,69.87 ; 5.89,47.15 JP1.19 ; JP1.19 6.89,47.85 ; JP1.19 6.89,47.15 ; JP1.19 4.89,47.85 ; JP1.19 4.89,47.15 ; JUSBC2.4 285.1,61.18 ; JUSBC2.4 283.95,60.02 ; JUSBC2.4 283.95,61.18 ; JUSBC2.4 282.79,60.02 ; JUSBC2.4 282.79,60.6 ; JUSBC2.4 282.79,61.18 ; JUSBC2.4 285.1,60.6 ; JUSBC2.4 285.1,60.02 ; H6.1 91.16,55.22 ; H6.1 88.95,57.43 ; H6.1 90.56,53.61 ; H6.1 88.95,53.01 ; H6.1 90.56,56.84 ; H6.1 87.33,56.84 ; H6.1 86.74,55.22 ; H6.1 87.33,53.61 ; 177.52,34.81 HCPU3.1 ; HCPU3.1 181.08,36.32 ; HCPU3.1 179.02,34.26 ; HCPU3.1 180.53,37.83 ; HCPU3.1 179.02,38.38 ; HCPU3.1 176.97,36.32 ; HCPU3.1 180.53,34.81 ; HCPU3.1 177.52,37.83 ; JP1.21 17.1,60.75 ; JP1.21 17.1,62.65 ; JP1.21 16.4,62.65 ; JP1.21 17.1,61.7 ; JP1.21 16.4,60.75 ; 8.3,71.2 JUSBC1.2 ; JUSBC1.2 8.81,71.2 ; JUSBC1.2 7.79,71.2 ; JUSBC1.4 10.1,81.05 ; JUSBC1.4 10.1,81.64 ; JUSBC1.4 7.79,82.22 ; JUSBC1.4 8.95,81.05 ; JUSBC1.4 10.1,82.22 ; JUSBC1.4 8.95,82.22 ; JUSBC1.4 7.79,81.05 ; JUSBC1.4 7.79,81.64 ; JUSBC1.5 8.81,82.22 ; JUSBC1.5 8.3,82.22 ; JUSBC1.5 7.79,82.22 ; JP1.20 17.1,50.15 ; JP1.20 17.1,52.05 ; JP1.20 16.4,52.05 ; JP1.20 16.4,50.15 ; JP1.20 17.1,51.1
  BOTTOM w0.089: v12(171.2,51.41) 171.08,51.53 170.2,51.53 v12(169.84,51.89) 169.84,51.94 170.17,52.27 171.08,52.27 171.18,52.36 171.22,52.36 171.24,52.34
  BOTTOM w0.127: PQ100.4 105.37,8.37 v6(105.65,8.65) ; 92.34,21.89 92.98,21.89 v6(93.05,21.96) ; v6(208.01,14.9) 208.16,15.05 v12(208.16,16.36) ; v6(91.56,64.97) 91.83,65.24 v12(91.83,66.06)
  BOTTOM w0.152: v12(269.12,50.54) URT2.D1 v5(269.12,49.56) ; v4(266.36,55.58) URT2.K12 v12(266.36,54.68) ; v12(27.4,57.77) URT1.H12 v5(27.4,58.73) ; v12(29.24,53.63) URT1.D1 v5(29.24,52.66) ; v12(28.32,57.77) URT1.F12 v5(28.32,58.75) ; v5(27.4,52.66) URT1.H1 v12(27.4,53.63) ; v5(266.26,49.4) 266.36,49.49 URT2.K1 v12(266.36,50.54) ; v5(270.04,55.65) URT2.B12 ; v4(267.28,55.57) URT2.H12 v12(267.28,54.68) ; v5(26.46,52.63) 26.48,52.65 URT1.K1 v12(26.48,53.63) ; v12(267.28,50.54) URT2.H1 v5(267.28,49.56) ; URT2.L12 265.9,55.34 265.61,55.63 v5(265.43,55.63) 265.43,55.59 265.44,55.58 v12(265.44,55.14) ; v12(28.32,53.63) URT1.F1 v14(28.32,52.66) ; v5(268.2,55.65) URT2.F12 v12(268.2,54.68) ; v12(30.62,57.77) 30.77,57.77 v5(31.03,58.04) ; v5(268.2,49.56) URT2.F1 v12(268.2,50.54) ; v12(270.85,54.81) 270.72,54.68 v12(270.5,54.68) ; v12(25.56,58.23) 25.54,58.26 25.54,58.6 25.52,58.62 v12(25.52,58.65) 25.71,58.65 26.02,58.34 URT1.L12 ; v5(269.12,55.65) URT2.D12 v12(269.12,54.68) ; v5(26.48,58.74) URT1.K12 v12(26.48,57.77) ; v5(30.24,58.84) 30.16,58.76 URT1.B12 ; v12(29.24,57.77) URT1.D12 v5(29.24,58.76)
  BOTTOM w0.203: v5(270.04,49.58) URT2.B1 v12(270.04,50.54) ; UC1.CY49 160.77,35.4 v12(160.77,35.32) ; PU1201.13 95.74,45.96 95.77,45.99 95.77,46.42 v12(95.26,46.93) ; UC1.CL49 v12(156.91,35.28) ; v5(30.16,52.68) URT1.B1 v12(30.16,53.63) ; PU1200.13 95.74,36.8 v4(95.26,37.28) ; PC715.2 95.79,12.15 PU700.4
  BOTTOM w0.254: UC1.A42 122.44,39.11 v4(122.67,39.34) ; v5(140.85,53.48) 140.83,53.5 v12(140.83,54.11) 141.07,54.11 v5(141.32,53.86) ; CT56.2 24.45,51.76 v12(24.14,52.06) ; v12(25.21,56.61) 25.16,56.65 v14(24.53,56.65) 24.48,56.7 v12(23.97,56.7) v12(22.92,56.7) v12(22.32,56.7) 22.28,56.7 22.1,56.89 v12(21.88,56.89) 21.82,56.89 21.57,57.14 v14(21.57,57.75) ; v14(263.82,54.28) 263.81,54.29 262.48,54.29 v14(262.07,53.88) 261.81,53.88 CT44.2 ; v12(181.05,53.37) 180.98,53.44 QM1.4 ; CC144.2 153.03,33.15 152.71,32.82 CC721.2 152.66,32.53 v12(152.21,32.53) ; v14(280.51,61.92) v5(280.51,61.43) ; v14(280.51,61.92) v5(281.04,61.92) ; v14(280.51,61.92) v5(279.97,61.92) ; v5(280.48,66.21) 280.48,66.21 D415.2 ; RH8.2 v12(164.61,59.86) ; v5(279.36,68.78) 279.34,68.75 v14(279.34,68.09) ; v5(151.31,53.68) 151.3,53.69 150.5,53.69 150.08,54.11 v12(149.98,54.11) ; v14(153.64,41.56) 153.98,41.9 v5(154.11,41.9) ; UC27.5 150.87,31.6 v12(151.45,32.17) ; v5(260.61,63.41) 260.09,63.41 CA80.1 ; QV21.3 111.25,69.13 110.89,69.13 v12(110.78,69.23) ; RH475.2 174.77,57.09 v12(175.12,57.45) 174.72,57.85 RH5.2 ; UC1.DH5 v12(164.66,56.79) ; v12(171.2,51.41) 171.86,51.41 v12(172.08,51.2) v12(172.58,50.69) 172.9,50.38 v12(173.5,50.38) 173.81,50.38 173.94,50.24 v12(173.94,49.47) v12(173.94,48.64) v12(173.94,47.62) v12(173.94,46.45) v12(174.33,46.06) v12(174.8,45.59) v12(175.65,45.59) 176.04,45.59 ; v5(8.83,79.8) 8.78,79.8 8.31,79.33 JUSBC1.B1 ; v12(153.23,30.47) 153.36,30.61 QE18.4 ; v12(149.98,54.11) 149.71,54.11 v5(149.51,53.91) ; v12(149.98,54.11) 149.98,53.52 v5(149.95,53.49) ; CT44.2 261.49,53.71 261.27,53.94 YT2.2 260.67,53.26 260.69,53.24 ; CT44.2 v12(261.29,53.35) 261.17,53.24 260.69,53.24 ; QE18.1 154.66,28.98 v12(154.95,28.69) ; v12(24.87,57.52) v14(24.51,57.88) ; v14(24.51,57.88) CT42.2 ; v14(24.51,57.88) v14(24.51,58.64) v14(24.51,59.27) v14(24.51,59.91) ; UC1.C21 123.38,49.15 v5(123.04,49.49) 123.04,49.36 UC1.B21 122.42,49.36 v5(122.42,49.5) ; v12(264.71,54.73) 264.71,54.9 v12(264.27,55.33) 263.88,55.72 263.85,55.72 263.84,55.72 v14(263.62,55.72) v12(262.91,55.72) 261.8,55.72 CT45.2 261.17,56.04 260.81,56.04 v12(260.8,56.02) 260.78,56.04 v14(260.12,56.04) 259.55,56.04 ; v14(24.51,59.91) 24.5,59.9 YT1.4 23.73,60.63 v14(23.75,60.65) ; v14(24.51,59.91) v14(24.51,60.54) 24.4,60.65 v14(23.75,60.65) ; v12(164.97,59.81) UC1.DH1 UC1.DH3 ; v5(101.94,10.86) 102.45,10.86 102.96,10.36 PQ100.1 ; v5(279.9,66.49) 279.54,66.49 v14(279.34,66.69) ; RT102.1 270.6,56.21 v5(270.04,55.65) ; v12(29.35,59.87) RT101.1 RT6.2 ; 258.85,55.34 v12(258.85,55.82) 259.07,56.04 259.55,56.04 ; 258.85,55.34 258.85,55.34 YT2.4 259.57,56.01 259.55,56.04 ; 258.85,55.34 v14(258.85,54.89) 258.85,54.41 258.74,54.29 v12(258.74,53.97) 258.74,53.61 v14(258.76,53.59) 258.76,53.47 259,53.24 v12(259.42,53.24) v12(260.24,53.24) 260.69,53.24 ; v12(124.57,37.56) 124.65,37.48 v14(124.65,37.1) ; RH630.2 174.38,53.38 v12(174.49,53.48) ; v5(284.14,68.57) 284.31,68.4 JUSBC2.B12 ; v14(125.98,47.22) 125.98,47.32 125.68,47.62 v5(125.68,47.67) 125.33,47.32 v14(125.33,47.22) 125.04,47.51 v5(125.04,47.67) ; v12(167.04,65.68) 167.25,65.68 167.38,65.54 JUFC1.67 ; v14(12.28,70.55) 12.28,70.15 v5(12.43,69.99) ; v5(132.12,54.62) 131.71,55.04 v12(131.68,55.04) v12(130.76,55.04) ; v12(155.72,41.56) 155.83,41.56 v5(156.16,41.9) 156.5,41.56 v12(156.64,41.56) ; v12(155.72,41.56) 155.61,41.45 155.14,41.45 v5(155.12,41.43) ; v12(155.72,41.56) 155.3,41.98 v5(155.14,41.98) ; CC145.2 v12(156.09,33.21) ; JSPK1.4 v12(19.24,35.48) ; JUFC1.63 166.2,63.7 166.48,63.7 v12(166.69,63.49) ; UC1.DK49 166.12,35.46 v12(166.12,34.92) 166.12,33.98 166.44,33.67 v12(166.44,33.62) v12(166.44,32.88) 166.44,31.98 166.3,31.83 165.61,31.83 165.31,31.53 v12(165.31,31.3) 165.12,31.3 164.78,30.95 v12(164.78,30.7) v12(164.78,29.71) v12(164.78,28.64) 164.78,28.53 165.06,28.24 v12(165.98,28.24) v12(166.82,28.24) v12(168.54,28.24) 168.86,28.56 v12(168.86,28.59) v12(168.86,29.41) v12(168.86,30.57) 168.86,30.8 v12(168.36,31.3) 168.24,31.42 168.24,32.15 167.9,32.49 v12(167.9,33.04) v12(167.9,34.24) v12(167.22,34.92) ; v12(168.4,37.55) UC1.DP45 ; 176.04,45.59 v12(176.04,46.25) v12(176.04,47.26) v12(176.04,48.02) 175.82,48.24 v12(175.82,48.76) v12(175.82,49.62) v12(175.82,50.34) 175.82,50.63 v12(175.28,51.18) 175.28,51.28 v12(174.77,51.78) 174.46,51.78 174.38,51.71 v12(174.11,51.71) v12(173.17,51.71) v12(172.53,52.34) v12(171.95,52.34) v12(171.29,52.34) 171.24,52.34 ; 176.04,45.59 v12(176.49,45.59) 177.24,45.59 177.46,45.81 v12(177.46,45.82) v12(177.46,46.58) v12(177.46,47.16) v12(177.46,47.95) ; v12(166.2,57.39) UC1.DK3 ; v12(129.85,53.74) 130.03,53.92 130.59,53.92 v12(130.76,53.74) ; UC1.A39 v12(123.09,40.42) ; JUFC1.68 155.69,65.31 v12(155.68,65.32) ; v12(160.3,42.21) 159.98,41.9 v5(159.8,41.9) 159.46,41.56 v12(159.38,41.56) 159.06,41.88 v5(158.96,41.88) 158.79,41.88 v12(158.47,41.56) ; UC1.DV44 v12(170.16,37.64) ; v12(164.62,54.39) 164.78,54.23 v12(164.78,53.46) v12(164.78,52.63) UC1.DF13 v12(163.48,52.63) ; v14(21.57,57.75) v14(21.57,58.64) ; v14(21.57,57.75) 22,57.75 CT43.2 22.12,58.03 22.33,58.23 YT1.2 22.07,58.8 21.91,58.64 v14(21.57,58.64) ; v12(152.72,55.69) 152.99,55.69 v12(153.64,55.04) ; RH10.2 v12(165.88,62.02) ; v12(169.46,36.92) 169.53,36.85 UC1.DU47 ; v12(154.55,55.04) v12(155.47,55.04) v12(156.38,55.04) v12(157.3,55.04) v12(158.21,55.04) v12(159.13,55.04) v12(160.04,55.04) v12(160.96,55.04) v12(161.87,55.04) ; v14(21.57,58.64) v14(21.57,59.27) v14(21.57,59.91) 21.57,60.42 v14(21.81,60.65) v12(22.57,60.65) v12(23.2,60.65) v14(23.75,60.65) ; v12(137.17,56.34) v12(138.08,56.34) 138.35,56.34 v12(139,55.69) ; PU900.19 v12(193.03,70.35) ; v5(279.97,63.31) v14(280.51,63.31) v5(281.04,63.31) ; UC1.DL44 v12(166.64,37.76) ; UC1.H21 125.98,49.17 v5(125.62,49.53) 125.62,49.45 125.33,49.16 UC1.G21 ; JUFC1.47 v12(165.37,63.39) ; v12(171.21,37.13) 170.9,37.13 UC1.DW46 ; UC1.BF45 v12(144.71,37.22) ; v14(10.05,69.33) 10.05,69.66 v5(9.84,69.87) ; PR906.2 190.26,72.44 v5(190.26,73.12) ; CC395.2 v12(147.16,32.02) ; v12(139,55.69) v12(139,55.04) v12(139,54.11) ; v12(139,55.69) v12(139.91,55.69) v12(140.83,55.69) v12(141.74,55.69) v12(142.66,55.69) v12(143.57,55.69) v12(144.49,55.69) v12(145.4,55.69) v12(146.32,55.69) v12(147.23,55.69) v12(148.15,55.69) 148.28,55.82 148.93,55.82 v12(149.06,55.69) ; RC14.2 v12(124.12,31.72) ; v4(165.16,39.34) 165.43,39.07 UC1.DJ42 ; v12(217.13,19.11) 217.9,19.11 217.93,19.14 PC335.2 218.5,19.09 218.68,19.09 v4(219.55,19.96) ; JUFC1.49 v12(164.32,63.39) ; v5(121.73,44.92) 121.73,44.82 v14(122.08,44.47) 122.08,44.59 v5(122.42,44.93) 122.42,44.79 v14(122.73,44.47) 122.73,44.58 v5(123.08,44.93) 123.08,44.77 v14(123.38,44.47) 123.38,44.57 v5(123.74,44.93) 123.74,44.76 v14(124.03,44.47) 124.03,44.56 v5(124.4,44.93) 124.4,44.75 v14(124.68,44.47) 125.05,44.84 v5(125.05,44.93) ; v12(149.98,55.69) v12(150.89,55.69) v12(151.81,55.69) ; v14(125.98,44.47) 125.98,44.62 v5(125.67,44.93) 125.67,44.86 125.33,44.52 v14(125.33,44.47) ; v5(14.16,70.55) v14(13.68,70.55) 13.68,71.14 v5(13.7,71.16) ; PU900.4 v14(196.61,66.77) ; v5(142.61,53.48) 142.61,53.51 142.66,53.56 v12(142.66,54.11) ; JUFC1.51 v12(163.27,63.39) ; v5(104.26,7.59) PQ100.4 ; v14(123.38,47.22) 123.38,47.33 v5(123.7,47.65) ; JUSBC2.B1 284.56,62.9 v5(284.24,62.58) ; v12(162.79,56.34) 162.79,56.76 UC1.DC5 UC1.DC3 ; UC1.CN5 v12(157.55,58.04) ; v5(147.69,53.9) 147.48,54.11 v12(147.23,54.11) 147.23,53.52 v5(147.25,53.5) ; 173,54.51 173.11,54.4 v12(173.57,54.4) v12(174.46,54.4) 175.09,54.4 v12(175.2,54.29) 175.2,54.02 v12(175.38,53.84) 175.55,53.66 v12(175.99,53.66) v12(176.77,53.66) v12(177.38,53.66) 177.84,53.66 v12(178.12,53.94) v5(178.12,54.42) v12(178.12,55.44) v12(178.12,55.9) 178.12,56.35 177.92,56.56 v12(177.79,56.56) v12(177,56.56) v12(176.24,56.56) v12(175.32,56.56) 175.22,56.56 175.19,56.53 v12(175.19,56.09) 174.73,56.09 174.65,56.01 v12(174.59,55.95) v12(173.62,55.95) v12(173.01,55.95) 172.88,55.82 v12(172.12,55.82) v12(171.29,55.82) v12(170.49,55.82) v12(169.84,55.82) v12(169.19,55.82) 168.86,55.49 v12(168.86,55.17) v12(168.86,54.51) v12(169.84,54.51) v12(170.49,54.51) v12(171.29,54.51) v12(172.18,54.51) v12(172.58,54.51) 173,54.51
  BOTTOM w0.279: JUSBC1.A12 9.22,79.59 9.01,79.8 v5(8.83,79.8) ; JUSBC1.A1 9.46,74.08 9.01,73.63 v5(8.83,73.63)
  BOTTOM w0.305: v12(149.06,55.69) v5(149.51,56.01) v12(149.98,55.69) ; 133.06,54 v12(132.59,53.74) ; 133.06,54 133.48,53.73 v12(133.51,53.74) ; 133.06,54 133.5,54.39 v12(133.51,54.39) v5(132.99,54.66) ; v12(151.81,55.69) v5(152.25,56.01) v12(152.72,55.69) ; v12(126.05,54.6) 126.38,54.27 v5(126.38,54.14) 126.7,53.82 v12(126.7,53.69) ; v12(124.36,41.73) 124.46,41.83 v14(125.1,41.83) v14(125.75,41.83) v14(126.4,41.83) v14(127.05,41.83) v14(127.7,41.83) ; DA1.2 276.85,66.24 v12(277.25,66.64) ; v12(124.75,53.69) v5(125.08,54.14) ; JUFC1.54 162.54,66.9 v12(162.55,66.9) ; RT3.1 261.84,52.91 262.31,52.91 v5(262.37,52.85) ; v12(154.55,55.04) v5(154.1,55.5) v12(153.64,55.04) ; v12(128.65,53.69) 128.65,53.82 v5(128.33,54.14) 128,54.47 v12(128,54.6) ; v12(142.66,57.64) v5(143.12,57.45) ; v5(143.12,57.45) v12(143.57,57.64) 143.74,57.57 v5(144.03,57.45) v12(144.49,57.64) ; v5(143.12,57.45) v12(143.57,56.99) ; CPD1.2 39.26,61.03 v5(39.54,60.75)
  BOTTOM w0.356: v5(2.38,46.8) 1.9,47.28 JP1.12 ; RT4.1 RT3.1 ; CPD2.2 v5(21.5,38.38)
  BOTTOM w0.381: v12(274.59,60.52) DA3.2 DA4.2 ; RT194.2 v4(34.56,46.69) ; PR901.1 197.07,64.71 v5(197.32,64.71) ; v5(196.81,64.2) 196.69,64.2 PC911.2 ; v5(21.68,40.81) 21.68,41.14 C4216.2 ; UC31.2 v5(19.97,40.43) ; RT193.2 v4(34.56,48.44)
  BOTTOM w0.406: v5(190.26,73.12) 189.97,73.41 QC5.1
  BOTTOM w0.508: UPD3.4 v4(34.92,51.25) ; v5(178.12,54.42) YH1.4 ; PC1213.2 PC1214.2 93.56,37.2 v5(93.56,36.64) ; v5(6.67,44.65) 7,44.98 RR1.1 ; v5(94.76,15.28) PC713.2 PC714.2 ; PC1215.2 98.13,36.51 v5(97.93,36.72) ; v5(94.78,12.34) PC715.2 ; UTS2.9 279.26,47.35 v5(282.12,47.35) ; PC701.2 v5(102.1,21.15) ; C750.2 203.59,21.25 v12(203.79,21.06) ; v12(6.21,45.31) v4(5.32,45.31) ; v5(93.77,46.22) 93.77,46.25 93.64,46.37 PC1201.2 PC1200.2 ; PC237.2 v5(94.12,13.66) ; CA82.1 v5(264.76,69.92) ; PC244.2 27.89,9.71 v5(27.89,9.19) ; v14(275.12,69.59) 275.27,69.59 DA13.2 ; UPD3.9 v5(39.71,55.96) ; v5(186.09,26.13) 187.47,27.5 JNGFF1.77 ; PC1202.2 98.13,46.14 v5(98.03,46.25) ; v12(197.7,24) C1131.2 ; v12(176.24,56.56) YH1.2 ; CA79.1 v5(265.65,69.92) ; CPD7.2 v5(21.35,37.62)
  vias: v2(11.62,71.82) v2(12.38,71.85) v2(28.49,2.68) v2(31.96,3.28) v2(113.24,16.22) v2(118.73,52.6) v2(119.14,52.6) v2(119.55,52.6) v2(119.95,52.6) v2(131.54,50.44) v2(132.17,50.44) v2(132.81,50.44) v2(136.36,52.98) v2(139.23,63.92) v2(139.64,51.63) v2(140.17,58.67) v2(154.9,57.4) v2(155.13,51.63) v2(155.84,55.97) v2(155.87,51.61) v2(156.55,51.61) v2(156.99,56.02) v2(157.32,62.17) v2(157.95,62.17) v2(158.21,51.61) v2(158.69,57.19) v2(158.89,51.66) v2(159.68,56.76) v2(159.7,51.66) v2(160.29,57.42) v2(160.26,56.76) v2(161.13,50.11) v2(161.13,48.58) v2(162.4,58.89) v2(162.6,56.05) v2(164.02,55.57) v2(164.12,52.47) v2(164.17,54.04) v2(188.41,47.74) v2(189.35,47.36) v2(189.52,45.66) v2(189.9,46.47) v2(190.16,44.95) v2(190.56,52.57) v2(255.54,20.41) v2(261.93,13.59) v3(98.16,50.74) v3(99.51,50.72) v3(103.33,18.28) v3(103.33,16.02) v3(105.29,19.41) v3(105.29,14.89) v3(107.25,18.28) v3(107.25,16.02) v3(111.71,18.07) v3(111.94,37.48) v3(111.94,35.22) v3(111.94,16.56) v3(112.03,23.69) v3(112.02,21.74) v3(112.03,19.82) v3(112.03,19.14) v3(112.02,15.89) v3(112.02,14.84) v3(112.03,12.46) v3(112.05,21.07) v3(112.35,64.65) v3(112.35,62.39) v3(112.31,17.35) v3(112.83,19.8) v3(112.84,16.56) v3(112.84,11.46) v3(112.89,24.33) v3(112.87,21.76) v3(112.87,21.07) v3(112.95,18.43) v3(112.86,15.24) v3(112.86,14.45) v3(112.89,13.76) v3(113.18,17.96) v3(113.45,13.76) v3(113.6,21.76) v3(113.63,19.78) v3(113.65,15.22) v3(113.65,19.14) v3(113.65,10.76) v3(113.75,24.44) v3(113.9,38.61) v3(113.9,34.09) v3(113.9,23.53) v3(113.98,18.2) v3(114.31,65.79) v3(114.31,61.26) v3(114.43,16.56) v3(114.44,13.96) v3(114.44,13.28) v3(114.49,21.79) v3(114.49,21.13) v3(114.49,20.46) v3(114.47,19.78) v3(114.45,19.13) v3(114.46,15.28) v3(114.46,11.4) v3(114.74,18.36) v3(115.22,19.79) v3(115.25,17.7) v3(115.33,14.92) v3(115.65,16.04) v3(115.86,37.48) v3(115.86,35.22) v3(116.07,18.31) v3(116.27,64.65) v3(116.27,62.39) v3(116.72,16.38) v3(116.83,19.81) v3(116.85,22.29) v3(116.88,15.11) v3(116.93,13.86) v3(117.45,18.48) v3(117.64,24.43) v3(117.62,23.74) v3(117.64,19.8) v3(117.64,15.89) v3(117.59,14.55) v3(117.63,13.95) v3(117.64,13.28) v3(117.64,12.62) v3(117.63,11.37) v3(117.72,17.49) v3(118.43,20.45) v3(118.45,21.76) v3(118.49,21.18) v3(118.48,14.01) v3(118.49,11.92) v3(118.45,11.35) v3(118.73,52.6) v3(119.14,52.6) v3(119.15,14.71) v3(119.24,24.91) v3(119.22,21.79) v3(119.24,17.39) v3(119.25,16.55) v3(119.24,15.89) v3(119.23,15.23) v3(119.24,13.35) v3(119.27,20.51) v3(119.27,11.96) v3(119.39,20.03) v3(119.55,52.6) v3(119.95,52.6) v3(120.03,22.42) v3(120.03,13.84) v3(120.05,21.13) v3(120.05,16.98) v3(120.2,15.58) v3(120.41,11.63) v3(120.72,21.05) v3(120.82,15.13) v3(120.84,13.51) v3(121.4,42.23) v3(121.91,38.04) v3(121.98,41.5) v3(122.8,42.79) v3(123.51,37.74) v3(124.09,39.34) v3(124.25,38.02) v3(124.32,41.55) v3(124.36,40.42) v3(124.42,35.83) v3(124.5,42.33) v3(124.68,36.57) v3(124.83,40.07) v3(124.85,16.02) v3(124.85,14.92) v3(124.78,13.51) v3(124.88,20.54) v3(124.87,19.52) v3(125.34,41.39) v3(125.37,17.84) v3(125.62,23.87) v3(125.64,23.08) v3(125.62,18.35) v3(125.64,15.23) v3(125.74,41.17) v3(125.74,40.07) v3(125.67,13.96) v3(126.03,37.31) v3(126.18,41.39) v3(126.18,17.26) v3(126.33,12.01) v3(126.43,20.44) v3(126.42,19.84) v3(126.41,19.27) v3(126.46,22.37) v3(126.46,21.73) v3(126.46,15.92) v3(126.46,15.23) v3(126.63,41.19) v3(126.66,40.07) v3(126.66,39.49) v3(126.66,39.01) v3(126.82,14.2) v3(127.24,14.57) v3(127.24,13.94) v3(127.27,15.33) v3(127.27,12.69) v3(127.36,18.03) v3(127.65,39.36) v3(128.03,40.33) v3(128,23.03) v3(128,21.85) v3(128.01,19.89) v3(128.04,19.27) v3(128.03,15.84) v3(128,13.28) v3(128.11,37.84) v3(128.11,18.59) v3(128.29,17.66) v3(128.46,40.63) v3(128.49,40) v3(128.49,39.36) v3(128.49,38.78) v3(128.82,37.81) v3(128.84,13.79) v3(128.82,12.34) v3(128.89,14.92) v3(128.97,40.28) v3(129.07,65.58) v3(129.38,40.61) v3(129.4,39.36) v3(129.4,38.73) v3(129.45,38.17) v3(129.66,36.62) v3(129.73,17.7) v3(129.83,41.39) v3(129.96,18.7) v3(130.24,39.9) v3(130.32,37.71) v3(130.39,38.22) v3(130.39,20.77) v3(130.39,14.9) v3(130.47,13.43) v3(130.47,12.64) v3(130.71,15.77) v3(130.93,18.38) v3(131.23,40.66) v3(131.2,21.79) v3(131.2,19.75) v3(131.23,15.79) v3(131.23,14.01) v3(131.23,13.3) v3(131.2,11.37) v3(131.31,38.27) v3(131.25,20.56) v3(131.54,50.44) v3(131.62,22.09) v3(131.79,18.41) v3(131.77,17.6) v3(132.02,13.33) v3(132.02,12.69) v3(132.14,40.63) v3(132.14,40) v3(132.14,39.36) v3(132.14,38.73) v3(132.07,21.73) v3(132.17,50.44) v3(132.22,37.18) v3(132.53,17.98) v3(132.6,37.66) v3(132.81,50.44) v3(132.85,15.78) v3(132.81,12.72) v3(132.93,20.54) v3(132.86,13.63) v3(133.06,40.07) v3(133.21,34.97) v3(133.54,41.39) v3(133.59,24.89) v3(133.64,23.06) v3(133.63,22.43) v3(133.64,21.73) v3(133.64,21.05) v3(133.57,14.62) v3(133.62,12.03) v3(133.93,18.2) v3(134,41.9) v3(133.97,40.07) v3(134.13,37.69) v3(134.43,41.5) v3(134.35,19.8) v3(134.5,13.63) v3(134.89,40.07) v3(134.89,39.51) v3(134.89,38.78) v3(135.37,41.67) v3(135.8,40.07) v3(136.34,41.62) v3(136.36,52.98) v3(136.72,40.07) v3(136.69,37.66) v3(137.17,41.45) v3(137.63,40.07) v3(137.63,39.51) v3(137.63,38.78) v3(138.06,41.55) v3(138.55,40.05) v3(139.05,41.55) v3(139.23,63.92) v3(139.46,40.07) v3(139.64,51.63) v3(139.92,41.45) v3(140.17,58.67) v3(140.37,40.07) v3(140.37,39.51) v3(140.37,38.78) v3(140.83,41.45) v3(141.31,40.07) v3(141.77,41.47) v3(142.2,40.07) v3(142.15,37.15) v3(142.61,56.18) v3(142.69,41.45) v3(143.12,40.05) v3(143.12,39.51) v3(143.12,38.78) v3(143.24,14.93) v3(143.25,19.47) v3(143.26,16.22) v3(143.27,13.81) v3(143.5,37.13) v3(143.47,34.54) v3(143.65,41.47) v3(143.58,18.33) v3(143.88,58.59) v3(144.03,56.69) v3(144.03,40.18) v3(144.03,38.96) v3(144.01,22.01) v3(144.01,14.22) v3(144.08,24.3) v3(144.06,19.14) v3(144.33,17.28) v3(144.54,17.95) v3(144.62,13.45) v3(144.82,37.53) v3(144.84,23.06) v3(144.84,20.44) v3(144.83,19.14) v3(144.83,16.55) v3(144.84,15.89) v3(144.85,15.25) v3(144.84,11.93) v3(144.84,11.42) v3(144.86,19.8) v3(145.05,40.05) v3(145.02,39.34) v3(145.23,59.3) v3(145.48,18.14) v3(145.64,20.47) v3(145.64,19.8) v3(145.62,19.19) v3(145.64,15.25) v3(145.64,13.94) v3(145.66,23.06) v3(145.66,22.4) v3(145.74,12.81) v3(145.89,40.58) v3(145.91,39.97) v3(145.89,39.36) v3(145.86,38.09) v3(146.01,57.27) v3(146.37,24.43) v3(146.44,23.06) v3(146.41,22.41) v3(146.44,21.13) v3(146.44,16.63) v3(146.44,11.93) v3(146.44,11.45) v3(146.52,59.81) v3(146.46,20.46) v3(146.48,15.96) v3(146.47,14.59) v3(146.48,13.9) v3(146.69,17.38) v3(146.8,57.85) v3(146.8,40.63) v3(147.17,58.43) v3(147.18,41.47) v3(147.28,19.86) v3(147.31,15) v3(147.71,58.08) v3(147.69,40.56) v3(147.69,39.87) v3(147.69,38.63) v3(147.66,38.17) v3(147.84,34.74) v3(147.8,16.14) v3(147.99,18.25) v3(148.1,37.58) v3(148.6,40) v3(148.6,39.44) v3(148.63,38.78) v3(148.65,40.56) v3(148.74,16.25) v3(148.76,19.7) v3(148.78,14.96) v3(148.83,13.33) v3(149.37,22.47) v3(149.52,40.66) v3(149.62,21.05) v3(149.63,19.8) v3(149.62,15.84) v3(149.59,13.91) v3(149.65,12.67) v3(149.67,18.58) v3(150.03,41.5) v3(150.28,37.43) v3(150.44,23.7) v3(150.44,11.5) v3(150.46,40.07) v3(150.47,15.23) v3(150.5,14.01) v3(150.61,17.72) v3(150.92,41.52) v3(151.22,23.74) v3(151.25,22.42) v3(151.21,21.13) v3(151.24,20.44) v3(151.24,19.8) v3(151.24,19.16) v3(151.23,16.52) v3(151.24,15.91) v3(151.25,15.26) v3(151.24,13.94) v3(151.25,12.64) v3(151.2,11.98) v3(151.35,40.78) v3(151.32,38.8) v3(151.27,18.59) v3(151.37,39.44) v3(151.75,41.57) v3(152.05,21.74) v3(152.04,14.61) v3(152.08,13.99) v3(152.06,13.3) v3(152.06,12.67) v3(152.06,11.98) v3(152.29,40.07) v3(152.72,41.62) v3(153.02,37.56) v3(153.18,40.07) v3(154.12,40.53) v3(154.14,39.77) v3(154.14,39.01) v3(154.9,57.4) v3(154.9,39.44) v3(155.13,51.63) v3(155.84,55.97) v3(155.87,51.61) v3(156.55,51.61) v3(156.86,16.22) v3(156.86,14.92) v3(156.99,56.02) v3(157.32,62.17) v3(157.64,23.03) v3(157.64,21.11) v3(157.62,19.78) v3(157.62,15.81) v3(157.62,13.96) v3(157.62,13.3) v3(157.62,12.67) v3(157.61,11.99) v3(157.68,22.45) v3(157.95,62.17) v3(157.95,17.37) v3(158.07,14.15) v3(158.21,51.61) v3(158.21,18.38) v3(158.43,23.03) v3(158.43,22.42) v3(158.42,20.61) v3(158.43,19.88) v3(158.41,19.02) v3(158.41,15.81) v3(158.43,12.69) v3(158.46,12.01) v3(158.69,57.19) v3(158.89,51.66) v3(158.87,25.09) v3(159.22,16.58) v3(159.23,15.86) v3(159.23,13.93) v3(159.25,12.61) v3(159.17,11.96) v3(159.32,21.76) v3(159.42,34.1) v3(159.68,56.76) v3(159.7,51.66) v3(160.01,24.25) v3(160.03,23.13) v3(160.03,22.45) v3(160.01,21.66) v3(159.98,18.43) v3(160.04,15.41) v3(160.03,14.75) v3(160.08,11.42) v3(160.29,57.42) v3(160.26,56.76) v3(160.32,17.74) v3(160.89,16.25) v3(160.92,13.54) v3(160.98,20.81) v3(161.13,50.11) v3(161.13,48.58) v3(161.08,19.2) v3(161.29,17.88) v3(161.38,36.64) v3(161.96,18.43) v3(162.44,22.2) v3(162.36,16.25) v3(162.6,56.05) v3(162.57,19.93) v3(162.83,18.43) v3(163.19,24.73) v3(163.23,22.5) v3(163.23,21.76) v3(163.23,20.46) v3(163.23,15.91) v3(163.16,12.67) v3(163.23,11.4) v3(163.26,19.8) v3(163.26,13.92) v3(164.02,55.57) v3(164.05,19.91) v3(163.98,17.13) v3(164.02,16.53) v3(164.02,15.33) v3(163.96,13.99) v3(164.05,12.67) v3(164.12,52.47) v3(164.07,24.96) v3(164.1,21.76) v3(164.17,54.04) v3(164.71,18.23) v3(164.81,23.74) v3(164.81,23) v3(164.81,22.42) v3(164.81,21.72) v3(164.81,21.15) v3(164.83,20.39) v3(164.83,19.8) v3(164.83,15.36) v3(164.83,13.79) v3(164.83,12.67) v3(164.87,14.65) v3(165.19,56.79) v3(165.29,17.26) v3(165.51,19.14) v3(165.63,23.71) v3(165.65,23.03) v3(165.65,21.76) v3(165.65,21.13) v3(165.65,20.44) v3(165.65,19.93) v3(165.59,15.33) v3(165.63,12.66) v3(165.9,56.61) v3(165.88,18.28) v3(166.26,56.99) v3(166.43,21.84) v3(166.44,20.77) v3(166.44,19.47) v3(166.38,14.92) v3(166.45,16.23) v3(166.82,55.47) v3(167.7,38.93) v3(168.14,57.07) v3(176.63,64.65) v3(176.63,62.39) v3(177.06,37.48) v3(177.06,35.22) v3(178.59,65.79) v3(178.59,61.26) v3(179.02,38.61) v3(179.02,34.09) v3(180.55,64.65) v3(180.55,62.39) v3(180.98,37.48) v3(180.98,35.22) v3(190.56,52.57) v3(207.2,33.19) v3(207.18,32.22) v3(207.35,33.98) v3(207.48,32.5) v3(207.76,32.81) v3(208.01,32.48) v3(208.09,31.21) v3(208.4,31.49) v3(239.66,19.37) v3(240.4,13.91) v3(242.08,13.96) v3(246.34,5.43) v3(247.28,5.58) v3(247.49,6.04) v3(248.2,6.88) v3(249.31,24.91) v3(249.26,5.45) v3(256.35,67.2) v3(257.14,21.33) v3(257.52,68.39) v3(259.97,38.45) v3(260.06,38.98) v3(260.69,39.18) v3(260.67,38.45) v3(261.84,38.42) v3(262.01,39.15) v3(263.11,38.42) v3(263.16,39.06) v3(264.1,39.15) v3(264.1,38.45) v3(266.38,57.24) v3(267.3,57.24) v3(268.21,57.24) v3(269.13,57.24) v3(270.65,68.52) v3(270.65,67.07) v4(17.24,39.21) v4(18,38.88) v4(24.01,31.28) v4(27.5,59.48) v4(28.09,57) v4(28.26,59.48) v4(29.33,59.5) v4(30.09,59.48) v4(32.19,37.89) v4(32.2,37.48) v4(32.2,37.1) v4(32.5,3.24) v4(33.63,38.76) v4(34.52,44.9) v4(34.56,49.02) v4(148.91,34.64) v4(164.43,55.36) v4(207.2,33.19) v4(207.18,32.22) v4(207.35,33.98) v4(207.48,32.5) v4(207.76,32.81) v4(208.01,32.48) v4(208.09,31.21) v4(208.4,31.49) v4(258.26,27.98) v4(264.3,41.11) v4(265.11,41.11) v4(266.38,57.24) v4(267.07,40.35) v4(267.3,57.24) v4(267.37,56.38) v4(267.78,39.59) v4(268.14,56.38) v4(268.21,57.24) v4(269.13,57.24) v4(269.2,56.41) v4(269.97,56.38) v4(283.22,62.65) v5(0.43,46.41) v5(0.43,44.68) v5(0.5,69.84) v5(0.76,71.41) v5(0.87,64.91) v5(1.34,81.81) v5(1.39,43.5) v5(1.46,83.27) v5(2.53,84.17) v5(2.76,68.91) v5(2.76,66.49) v5(3.11,42.94) v5(3.42,41.01) v5(3.42,38.88) v5(3.75,37.18) v5(4.25,84.22) v5(4.26,63.33) v5(4.36,48.17) v5(4.71,71.61) v5(4.85,70.11) v5(4.85,65.29) v5(5.55,37.13) v5(5.98,84.22) v5(5.99,81.86) v5(6.94,68.91) v5(6.94,66.49) v5(7.3,71.21) v5(7.53,37.13) v5(7.71,84.22) v5(7.71,63.33) v5(7.76,79.85) v5(7.81,48.17) v5(8.52,70.48) v5(9.43,84.22) v5(9.44,63.33) v5(9.54,48.17) v5(9.95,35.22) v5(9.95,33.62) v5(9.95,31.67) v5(11,43.01) v5(11,40.78) v5(11.17,63.33) v5(11.27,48.17) v5(11.28,31.13) v5(12.12,41.89) v5(12.9,63.33) v5(12.97,81.09) v5(12.97,79.25) v5(12.99,48.17) v5(13.01,31.13) v5(13.23,43.01) v5(13.23,40.78) v5(13.73,77.34) v5(14.43,75.83) v5(14.36,63.42) v5(14.62,47.82) v5(14.73,31.13) v5(14.77,74.2) v5(14.78,72.47) v5(15.05,70.78) v5(15.53,69.41) v5(16.07,63.06) v5(16.11,60.55) v5(16.11,52.37) v5(16.11,49.7) v5(16.51,70.52) v5(17.26,69.41) v5(17.44,29.73) v5(17.44,28) v5(17.44,26.28) v5(17.44,25.07) v5(17.44,23.55) v5(17.44,21.59) v5(17.44,19.86) v5(17.44,18.13) v5(17.44,16.4) v5(17.44,14.67) v5(17.44,12.94) v5(17.44,11.22) v5(17.44,9.49) v5(17.44,7.76) v5(17.44,6.03) v5(17.44,4.31) v5(17.48,2.8) v5(17.46,1.14) v5(18.24,70.52) v5(18.69,4.89) v5(18.69,0.48) v5(19.97,70.52) v5(21.1,4.89) v5(21.1,0.48) v5(21.7,70.52) v5(22.31,2.8) v5(23.13,0.48) v5(23.42,70.52) v5(23.37,46.89) v5(24.86,0.48) v5(25.15,70.52) v5(25.06,53.76) v5(25.48,37.17) v5(25.86,49.81) v5(26.15,48.51) v5(26.39,60.93) v5(26.58,0.48) v5(26.74,38.64) v5(26.74,37.17) v5(26.74,35.7) v5(26.88,70.52) v5(27.18,48.49) v5(27.24,11.12) v5(27.24,10.53) v5(27.35,60.93) v5(27.37,49.83) v5(27.75,10.79) v5(28.01,38.64) v5(28.01,37.17) v5(28.01,35.7) v5(28.33,60.9) v5(28.31,0.48) v5(28.4,49.81) v5(28.6,70.52) v5(28.68,48.24) v5(29.13,2.72) v5(29.3,60.88) v5(29.27,38.64) v5(29.27,37.17) v5(29.27,35.7) v5(29.67,48.24) v5(29.81,49.85) v5(30.04,0.48) v5(30.33,70.52) v5(30.28,66.52) v5(30.53,37.17) v5(30.91,67.14) v5(30.91,65.89) v5(31,49.85) v5(31.53,66.52) v5(31.76,0.48) v5(32.06,70.52) v5(32.48,8.98) v5(32.48,6.74) v5(33.49,0.48) v5(33.59,7.86) v5(33.79,70.52) v5(34.71,8.98) v5(34.71,6.74) v5(35.19,17.47) v5(35.22,0.48) v5(35.51,70.52) v5(35.55,17.95) v5(35.65,17.09) v5(35.98,17.54) v5(37.24,70.52) v5(37.25,0.48) v5(37.43,15.05) v5(37.83,14.57) v5(38.32,14.17) v5(38.52,69.96) v5(38.52,68.23) v5(38.52,66.51) v5(38.52,64.78) v5(38.53,44.05) v5(38.54,42.3) v5(38.56,27.84) v5(38.73,45.97) v5(38.67,40.58) v5(38.93,38.8) v5(38.99,62.91) v5(39.05,47.63) v5(39.32,37.08) v5(39.44,49.27) v5(39.51,29.49) v5(39.93,35.15) v5(40.05,51.17) v5(40.4,0.48) v5(40.72,61.18) v5(40.72,33.21) v5(40.89,53.11) v5(41.41,29.49) v5(41.41,26.19) v5(41.72,31.28) v5(41.8,54.8) v5(42.05,2.86) v5(42.05,1.01) v5(42.44,59.46) v5(42.37,27.84) v5(42.74,4.23) v5(42.99,56.58) v5(43.01,29.29) v5(43.61,57.92) v5(44.31,4.44) v5(44.92,26.95) v5(46.09,4.44) v5(46.93,25.03) v5(47.54,4.43) v5(48.93,23.5) v5(49.27,4.43) v5(50.87,22.3) v5(50.92,3.26) v5(50.94,1.53) v5(52.09,3.2) v5(52.07,1.48) v5(52.71,21.38) v5(52.87,4.28) v5(54.48,20.68) v5(54.49,4.43) v5(56.11,20.17) v5(56.22,4.43) v5(57.85,19.76) v5(57.94,4.43) v5(59.58,19.49) v5(59.67,4.43) v5(61.35,19.34) v5(61.4,4.43) v5(63.09,19.32) v5(63.12,4.43) v5(64.85,4.43) v5(64.96,19.45) v5(66.58,4.43) v5(66.69,19.69) v5(68.31,4.43) v5(68.42,20.07) v5(70.03,4.43) v5(70.24,20.62) v5(71.76,4.43) v5(72.09,21.34) v5(73.49,4.43) v5(73.91,22.24) v5(75.21,4.43) v5(75.61,23.26) v5(76.94,4.43) v5(77.6,24.72) v5(78.67,4.43) v5(79.37,26.32) v5(80.4,4.43) v5(81.01,28.14) v5(82.12,4.43) v5(82.38,30) v5(83.32,31.54) v5(83.85,4.39) v5(84.28,33.45) v5(84.93,3.2) v5(84.95,1.49) v5(85.01,35.27) v5(84.99,32.14) v5(85.18,32.71) v5(85.43,33.34) v5(85.58,37.12) v5(85.56,31.82) v5(85.69,33.91) v5(85.69,32.45) v5(85.82,19.09) v5(85.82,18.46) v5(85.82,17.87) v5(86,38.99) v5(86.09,3.21) v5(86.08,1.49) v5(86.23,40.57) v5(86.38,73.4) v5(86.38,71.67) v5(86.38,69.94) v5(86.38,68.22) v5(86.38,66.49) v5(86.38,64.76) v5(86.38,63.03) v5(86.38,61.31) v5(86.38,59.58) v5(86.38,57.85) v5(86.38,56.13) v5(86.38,54.4) v5(86.38,52.67) v5(86.38,50.94) v5(86.38,49.22) v5(86.38,47.49) v5(86.38,45.76) v5(86.38,44.04) v5(86.36,42.31) v5(86.54,55.22) v5(86.63,74.82) v5(87.43,4.43) v5(87.57,75.91) v5(87.74,57.31) v5(87.74,53.13) v5(88.66,76.29) v5(89.15,4.43) v5(90.16,57.31) v5(90.16,53.13) v5(90.42,76.32) v5(90.77,22.29) v5(90.77,21.66) v5(91.3,4.44) v5(91.36,55.22) v5(91.53,23.44) v5(92.14,76.32) v5(92.17,23.44) v5(92.17,21.02) v5(92.17,20.39) v5(92.47,4.08) v5(93.18,24.07) v5(93.18,23.44) v5(93.43,19.2) v5(93.45,17.94) v5(93.42,16.71) v5(93.82,18.61) v5(93.82,17.34) v5(93.82,16.2) v5(93.87,76.32) v5(94.13,0.48) v5(94.2,75.28) v5(95.79,40.61) v5(95.87,39.41) v5(95.86,0.48) v5(96.05,30.97) v5(96.08,29.98) v5(96.23,74.85) v5(96.21,40.04) v5(96.33,10.2) v5(96.42,30.47) v5(96.43,9.64) v5(96.5,40.61) v5(96.53,10.74) v5(96.58,39.41) v5(96.76,30.97) v5(96.79,29.98) v5(96.91,76.32) v5(96.92,40.04) v5(97.13,30.47) v5(97.23,61.98) v5(97.21,40.62) v5(97.17,10.74) v5(97.29,39.42) v5(97.34,31.57) v5(97.37,41.22) v5(97.47,30.98) v5(97.5,30) v5(97.64,40.05) v5(97.59,0.48) v5(97.84,30.49) v5(98.3,60.91) v5(98.64,76.32) v5(99.31,0.48) v5(99.37,61.98) v5(99.37,59.84) v5(99.38,22.32) v5(100.37,76.32) v5(101.04,0.48) v5(102.1,76.32) v5(102.77,0.48) v5(103.83,76.31) v5(104.17,38.7) v5(104.46,74.54) v5(104.49,0.48) v5(104.74,38.7) v5(105.12,29.6) v5(105.12,29.02) v5(106.2,73.73) v5(107.93,73.73) v5(109.7,0.48) v5(109.84,72.61) v5(111.43,0.48) v5(111.56,72.61) v5(113.16,0.48) v5(113.29,72.61) v5(114.88,0.48) v5(115.02,72.61) v5(116.02,72.53) v5(116.02,70.8) v5(116.52,69.07) v5(116.61,0.48) v5(118.34,0.48) v5(118.48,68.73) v5(120.06,0.48) v5(120.2,68.73) v5(121.79,0.48) v5(121.93,68.73) v5(122.98,3.36) v5(123.52,0.48) v5(123.66,68.73) v5(125.25,0.48) v5(125.38,68.73) v5(126.97,0.48) v5(127.11,68.73) v5(128.7,0.48) v5(128.84,68.73) v5(130.43,0.48) v5(130.57,68.73) v5(131.33,60.48) v5(132.15,0.48) v5(132.29,68.73) v5(133.88,0.48) v5(134.02,68.73) v5(135.61,0.48) v5(135.75,68.73) v5(137.33,0.49) v5(137.47,68.73) v5(139.05,0.49) v5(139.2,68.73) v5(140.78,0.49) v5(140.93,68.73) v5(142.66,68.73) v5(142.82,0.48) v5(144.02,1.43) v5(144.17,2.88) v5(144.38,68.73) v5(145.1,4.07) v5(146.11,68.73) v5(146.72,4.46) v5(147.84,68.73) v5(148.26,3.66) v5(148.88,1.87) v5(149.5,0.48) v5(149.56,68.73) v5(151.23,0.48) v5(151.29,68.73) v5(153.02,68.73) v5(152.96,0.48) v5(154.75,68.73) v5(154.69,0.48) v5(156.41,0.48) v5(156.47,68.73) v5(157.85,65.63) v5(158.14,0.48) v5(158.2,68.73) v5(159.93,68.73) v5(159.87,0.48) v5(161.6,0.48) v5(161.66,68.73) v5(163.32,0.48) v5(163.38,68.73) v5(165.05,0.48) v5(165.11,68.73) v5(166.84,68.73) v5(166.78,0.48) v5(168.5,0.48) v5(168.56,68.73) v5(170.23,0.48) v5(170.29,68.73) v5(172.02,68.73) v5(171.96,0.48) v5(173.75,68.73) v5(173.69,0.48) v5(175.41,0.48) v5(175.67,68.74) v5(176.88,72.02) v5(176.88,70.29) v5(177.14,0.48) v5(177.57,5.54) v5(178.91,72.62) v5(178.87,0.48) v5(180.64,72.62) v5(180.59,0.48) v5(182.32,0.48) v5(182.36,72.62) v5(183.99,46.04) v5(184.05,0.48) v5(184.12,73.73) v5(185.84,73.73) v5(185.78,0.48) v5(186.04,29.66) v5(187.49,73.77) v5(187.5,0.48) v5(187.57,41.74) v5(188.57,74.98) v5(188.69,69.79) v5(188.99,33.5) v5(188.99,29.66) v5(189.19,76.32) v5(189.19,70.17) v5(189.23,0.48) v5(190.92,76.32) v5(190.96,0.48) v5(192.64,76.32) v5(192.68,0.48) v5(193.02,73.04) v5(193.13,72.44) v5(193.13,50.61) v5(193.26,49.73) v5(193.65,73.61) v5(193.65,72.93) v5(193.74,72.11) v5(193.71,70.63) v5(193.89,50.36) v5(193.89,49.73) v5(194.02,74.07) v5(194.11,71.52) v5(194.15,70.22) v5(194.26,73.46) v5(194.25,72.57) v5(194.37,76.32) v5(194.44,74.49) v5(194.41,0.48) v5(194.63,72.04) v5(194.77,73.92) v5(194.81,73.06) v5(195.13,72.51) v5(195.34,73.52) v5(195.67,72.96) v5(196.1,76.32) v5(196.14,0.48) v5(197.18,66.83) v5(197.4,63.62) v5(197.72,67.31) v5(197.89,66.64) v5(197.87,0.48) v5(198.03,74.59) v5(198.16,67.9) v5(198.26,68.91) v5(198.42,67.22) v5(198.49,47.49) v5(198.63,68.26) v5(198.59,66.62) v5(198.87,67.74) v5(198.99,76.32) v5(199.1,67.12) v5(199.29,68.27) v5(199.56,68.94) v5(199.56,67.68) v5(199.59,0.55) v5(199.93,1.63) v5(200.72,76.32) v5(201.03,60.11) v5(201.25,2.44) v5(201.32,61.96) v5(201.44,75.1) v5(201.49,60.57) v5(201.54,55.22) v5(201.75,61.57) v5(201.92,61.03) v5(202.18,75.09) v5(202.45,76.32) v5(202.43,61.51) v5(202.74,57.31) v5(202.74,53.13) v5(202.91,75.08) v5(202.93,62.15) v5(202.97,2.44) v5(203.37,62.6) v5(203.71,75.06) v5(203.77,63.01) v5(203.95,76.31) v5(204.54,75.09) v5(204.7,2.44) v5(205.16,57.31) v5(205.16,53.13) v5(205.35,49.57) v5(205.35,48.94) v5(205.32,48.3) v5(205.35,47.67) v5(205.32,47.06) v5(205.32,46.42) v5(205.32,45.79) v5(205.58,75.74) v5(205.98,38.75) v5(205.98,38.17) v5(206.08,37.53) v5(206.26,74.85) v5(206.36,55.22) v5(206.43,2.44) v5(206.52,73.39) v5(206.52,71.66) v5(206.52,69.93) v5(206.52,68.2) v5(206.52,66.48) v5(206.52,64.75) v5(206.52,63.02) v5(206.52,61.3) v5(206.52,59.57) v5(206.52,57.84) v5(206.52,56.11) v5(206.52,54.39) v5(206.52,52.66) v5(206.52,50.93) v5(206.52,49.21) v5(206.52,47.48) v5(206.52,45.75) v5(206.52,44.02) v5(206.54,42.29) v5(206.67,40.57) v5(206.93,38.82) v5(207.38,36.88) v5(208.01,34.94) v5(208.16,2.43) v5(208.98,32.67) v5(208.98,1.28) v5(209.92,0.43) v5(210.23,30.45) v5(211.62,28.47) v5(211.64,0.43) v5(213.16,26.69) v5(213.37,0.43) v5(213.82,1.57) v5(214.95,25.01) v5(215.06,2.44) v5(216.76,23.62) v5(216.79,2.44) v5(218.4,22.57) v5(218.52,2.44) v5(220.12,21.66) v5(220.24,2.44) v5(221.92,20.89) v5(221.97,2.44) v5(223.7,2.44) v5(223.78,20.26) v5(225.43,2.44) v5(225.47,19.84) v5(227.18,19.54) v5(227.15,2.44) v5(228.93,19.36) v5(228.88,2.43) v5(229.68,1.22) v5(230.61,0.48) v5(230.69,19.32) v5(232.34,0.48) v5(232.44,19.4) v5(234.15,19.6) v5(234.07,0.48) v5(235.79,0.48) v5(235.87,19.94) v5(237.52,0.48) v5(237.86,20.49) v5(239.25,0.48) v5(239.83,21.23) v5(240.98,0.48) v5(241.84,22.2) v5(242.7,0.48) v5(243.68,23.31) v5(244.43,0.48) v5(245.37,24.53) v5(246.16,0.48) v5(247.3,26.26) v5(247.88,0.48) v5(248.86,27.95) v5(249.62,58.62) v5(249.61,0.48) v5(250.07,56.37) v5(250.26,29.83) v5(251.35,60.35) v5(251.33,54.4) v5(251.29,31.49) v5(251.34,0.48) v5(252.18,52.75) v5(252.24,33.36) v5(252.69,32.34) v5(252.94,50.9) v5(253.07,62.08) v5(253.06,35.4) v5(253.07,0.48) v5(253.46,49.29) v5(253.56,37.04) v5(253.65,33.99) v5(253.64,30.69) v5(253.83,47.71) v5(253.96,38.76) v5(254.15,69.47) v5(254.15,68) v5(254.15,66.27) v5(254.15,64.54) v5(254.16,63.16) v5(254.17,46.01) v5(254.23,40.58) v5(254.37,44.04) v5(254.36,42.31) v5(254.79,0.48) v5(254.88,70.6) v5(255.12,53.11) v5(255.55,33.99) v5(255.55,30.69) v5(256.5,32.34) v5(256.52,0.48) v5(256.58,70.62) v5(256.64,49.64) v5(258.25,0.48) v5(258.31,70.62) v5(258.64,63.41) v5(258.64,61.44) v5(258.64,59.47) v5(259.87,39.51) v5(260.04,70.62) v5(259.97,0.48) v5(260.61,61.44) v5(260.61,59.47) v5(261.13,40.99) v5(261.13,39.51) v5(261.13,38.04) v5(261.7,0.48) v5(261.77,70.62) v5(262.4,40.99) v5(262.4,39.51) v5(262.4,38.04) v5(262.58,63.41) v5(262.58,61.44) v5(262.58,59.47) v5(263.43,0.48) v5(263.49,70.62) v5(263.66,40.99) v5(263.66,39.51) v5(263.66,38.04) v5(264.92,39.51) v5(264.94,6.62) v5(265.22,70.62) v5(265.16,0.48) v5(265.7,46.68) v5(266.95,70.62) v5(266.89,46.73) v5(266.88,0.48) v5(268.16,46.73) v5(268.61,0.48) v5(268.68,70.62) v5(269.43,46.73) v5(270.34,0.48) v5(270.4,70.62) v5(270.6,46.7) v5(270.59,2.8) v5(270.93,7.05) v5(271.79,4.89) v5(271.79,0.71) v5(272.13,70.62) v5(273.42,13.2) v5(273.86,70.62) v5(273.95,27.58) v5(274.21,4.89) v5(274.2,0.71) v5(274.38,36.31) v5(275.41,2.8) v5(275.39,0.86) v5(275.5,30.07) v5(275.46,28.49) v5(275.46,26.77) v5(275.46,25.04) v5(275.46,23.31) v5(275.46,21.58) v5(275.46,19.86) v5(275.46,18.13) v5(275.46,16.4) v5(275.46,14.68) v5(275.46,12.95) v5(275.46,11.22) v5(275.46,4.31) v5(275.58,70.62) v5(276.77,39.84) v5(277.25,31.14) v5(277.28,70.73) v5(278.14,73.63) v5(278.14,71.9) v5(278.8,56.83) v5(279.03,74.59) v5(278.98,31.14) v5(279.42,57.45) v5(279.42,56.21) v5(280.05,56.83) v5(280.71,31.14) v5(280.76,74.59) v5(280.81,60.55) v5(281.92,45.78) v5(281.9,43.12) v5(282.43,31.14) v5(282.49,74.59) v5(282.49,61.87) v5(282.49,61.26) v5(282.46,39.67) v5(282.82,48.79) v5(282.82,47.06) v5(282.82,45.33) v5(282.82,43.6) v5(283.2,41.99) v5(283.47,40.56) v5(283.47,38.83) v5(283.47,37.11) v5(283.47,35.38) v5(283.47,33.65) v5(283.47,31.92) v5(284.22,74.57) v5(284.27,49.87) v5(284.65,54.64) v5(284.77,59.38) v5(284.82,58.67) v5(285.13,62.4) v5(285.83,72.88) v5(285.89,59.91) v5(285.86,56.73) v5(285.86,52.55) v5(285.99,49.87) v5(286.09,71.13) v5(287.63,70.63) v5(287.61,60.42) v5(287.68,72.49) v5(287.72,49.87) v5(288.27,56.73) v5(288.27,52.55) v5(289.4,72.4) v5(289.45,49.87) v5(289.48,54.64) v5(290.18,57.55) v5(290.17,54.38) v5(291.13,72.32) v5(291.09,70.63) v5(291.06,60.42) v5(291.2,53.36) v5(291.17,49.87) v5(291.33,50.64) v5(291.38,52.54) v5(292.47,71.51) v5(292.47,60.06) v5(292.46,58.56) v6(8.52,65.42) v6(15.99,64.58) v6(23.2,7.51) v6(23.41,20.69) v6(31.03,21.99) v6(31.15,26.21) v6(31.84,68.67) v6(35.24,68.47) v6(37.3,36.03) v6(40.76,59.17) v6(92.52,31.62) v6(93.82,28.54) v6(96.58,42.03) v6(96.56,32.63) v6(101.08,1.38) v6(104,52.16) v6(121.81,64.91) v6(142.1,58.64) v6(144.62,58.51) v6(148.68,57.52) v6(157.54,41.62) v6(157.77,48.81) v6(180.48,56.96) v6(193.99,74.96) v6(205.04,63.16) v6(205.55,64.41) v6(230.57,9.77) v6(255.28,66.57) v6(263.26,29.63) v6(266.92,5.48) v6(269.28,29.23) v6(270.88,11.52) v6(275.65,37.74) v6(281.42,37.53) v6(283.86,56.91) v6(285.21,71.93) v8(111.71,18.07) v8(111.94,16.56) v8(112.03,23.69) v8(112.02,21.74) v8(112.03,19.82) v8(112.03,19.14) v8(112.02,15.89) v8(112.02,14.84) v8(112.03,12.46) v8(112.05,21.07) v8(112.31,17.35) v8(112.83,19.8) v8(112.84,16.56) v8(112.84,11.46) v8(112.89,24.33) v8(112.87,21.76) v8(112.87,21.07) v8(112.95,18.43) v8(112.86,15.24) v8(112.86,14.45) v8(112.89,13.76) v8(113.18,17.96) v8(113.45,13.76) v8(113.6,21.76) v8(113.63,19.78) v8(113.65,15.22) v8(113.65,19.14) v8(113.65,10.76) v8(113.75,24.44) v8(113.9,23.53) v8(113.98,18.2) v8(114.43,16.56) v8(114.44,13.96) v8(114.44,13.28) v8(114.49,21.79) v8(114.49,21.13) v8(114.49,20.46) v8(114.47,19.78) v8(114.45,19.13) v8(114.46,15.28) v8(114.46,11.4) v8(114.74,18.36) v8(115.22,19.79) v8(115.25,17.7) v8(115.33,14.92) v8(115.65,16.04) v8(116.07,18.31) v8(116.72,16.38) v8(116.83,19.81) v8(116.85,22.29) v8(116.88,15.11) v8(116.93,13.86) v8(117.45,18.48) v8(117.64,24.43) v8(117.62,23.74) v8(117.64,19.8) v8(117.64,15.89) v8(117.59,14.55) v8(117.63,13.95) v8(117.64,13.28) v8(117.64,12.62) v8(117.63,11.37) v8(117.72,17.49) v8(118.43,20.45) v8(118.45,21.76) v8(118.49,21.18) v8(118.48,14.01) v8(118.49,11.92) v8(118.45,11.35) v8(118.73,52.6) v8(119.14,52.6) v8(119.15,14.71) v8(119.24,24.91) v8(119.22,21.79) v8(119.24,17.39) v8(119.25,16.55) v8(119.24,15.89) v8(119.23,15.23) v8(119.24,13.35) v8(119.27,20.51) v8(119.27,11.96) v8(119.39,20.03) v8(119.55,52.6) v8(119.95,52.6) v8(120.03,22.42) v8(120.03,13.84) v8(120.05,21.13) v8(120.05,16.98) v8(120.2,15.58) v8(120.41,11.63) v8(120.82,15.13) v8(120.84,13.51) v8(121.4,42.23) v8(121.91,38.04) v8(121.98,41.5) v8(122.8,42.79) v8(123.51,37.74) v8(124.09,39.34) v8(124.25,38.02) v8(124.42,35.83) v8(124.5,42.33) v8(124.68,36.57) v8(124.83,40.07) v8(124.78,13.51) v8(124.88,20.54) v8(124.87,19.52) v8(125.34,41.39) v8(125.37,17.84) v8(125.62,23.87) v8(125.64,23.08) v8(125.62,18.35) v8(125.64,15.23) v8(125.74,41.17) v8(125.74,40.07) v8(125.67,13.96) v8(126.03,37.31) v8(126.18,41.39) v8(126.18,17.26) v8(126.33,12.01) v8(126.43,20.44) v8(126.42,19.84) v8(126.41,19.27) v8(126.46,22.37) v8(126.46,21.73) v8(126.46,15.92) v8(126.46,15.23) v8(126.63,41.19) v8(126.66,40.07) v8(126.66,39.49) v8(126.66,39.01) v8(126.82,14.2) v8(127.24,14.57) v8(127.24,13.94) v8(127.27,15.33) v8(127.27,12.69) v8(127.36,18.03) v8(127.65,39.36) v8(128.03,40.33) v8(128,23.03) v8(128,21.85) v8(128.01,19.89) v8(128.04,19.27) v8(128.03,15.84) v8(128.11,37.84) v8(128.11,18.59) v8(128.29,17.66) v8(128.46,40.63) v8(128.49,40) v8(128.49,39.36) v8(128.49,38.78) v8(128.82,37.81) v8(128.97,40.28) v8(129.07,65.58) v8(129.38,40.61) v8(129.4,39.36) v8(129.4,38.73) v8(129.45,38.17) v8(129.66,36.62) v8(129.73,17.7) v8(129.83,41.39) v8(129.96,18.7) v8(130.24,39.9) v8(130.32,37.71) v8(130.39,38.22) v8(130.39,20.77) v8(130.39,14.9) v8(130.47,13.43) v8(130.47,12.64) v8(130.71,15.77) v8(130.93,18.38) v8(131.23,40.66) v8(131.2,21.79) v8(131.2,19.75) v8(131.23,15.79) v8(131.23,14.01) v8(131.23,13.3) v8(131.2,11.37) v8(131.31,38.27) v8(131.25,20.56) v8(131.54,50.44) v8(131.62,22.09) v8(131.79,18.41) v8(131.77,17.6) v8(132.02,13.33) v8(132.02,12.69) v8(132.14,40.63) v8(132.14,40) v8(132.14,39.36) v8(132.14,38.73) v8(132.07,21.73) v8(132.17,50.44) v8(132.22,37.18) v8(132.53,17.98) v8(132.6,37.66) v8(132.81,50.44) v8(132.85,15.78) v8(132.81,12.72) v8(132.93,20.54) v8(132.86,13.63) v8(133.06,40.07) v8(133.21,34.97) v8(133.54,41.39) v8(133.59,24.89) v8(133.64,23.06) v8(133.63,22.43) v8(133.64,21.73) v8(133.64,21.05) v8(133.57,14.62) v8(133.62,12.03) v8(133.93,18.2) v8(134,41.9) v8(133.97,40.07) v8(134.13,37.69) v8(134.43,41.5) v8(134.35,19.8) v8(134.5,13.63) v8(134.89,40.07) v8(134.89,39.51) v8(134.89,38.78) v8(135.37,41.67) v8(135.8,40.07) v8(136.34,41.62) v8(136.36,52.98) v8(136.72,40.07) v8(136.69,37.66) v8(137.17,41.45) v8(137.63,40.07) v8(137.63,39.51) v8(137.63,38.78) v8(138.06,41.55) v8(138.55,40.05) v8(139.05,41.55) v8(139.23,63.92) v8(139.46,40.07) v8(139.64,51.63) v8(139.92,41.45) v8(140.37,40.07) v8(140.37,39.51) v8(140.37,38.78) v8(140.83,41.45) v8(141.31,40.07) v8(141.77,41.47) v8(142.2,40.07) v8(142.15,37.15) v8(142.61,56.18) v8(142.69,41.45) v8(143.12,40.05) v8(143.12,39.51) v8(143.12,38.78) v8(143.24,14.93) v8(143.25,19.47) v8(143.26,16.22) v8(143.27,13.81) v8(143.5,37.13) v8(143.47,34.54) v8(143.65,41.47) v8(143.58,18.33) v8(143.88,58.59) v8(144.03,56.69) v8(144.03,40.18) v8(144.03,38.96) v8(144.01,14.22) v8(144.08,24.3) v8(144.06,19.14) v8(144.33,17.28) v8(144.54,17.95) v8(144.62,13.45) v8(144.82,37.53) v8(144.84,23.06) v8(144.84,20.44) v8(144.83,19.14) v8(144.83,16.55) v8(144.84,15.89) v8(144.85,15.25) v8(144.84,11.93) v8(144.84,11.42) v8(144.86,19.8) v8(145.05,40.05) v8(145.02,39.34) v8(145.23,59.3) v8(145.48,18.14) v8(145.64,20.47) v8(145.64,19.8) v8(145.62,19.19) v8(145.64,15.25) v8(145.64,13.94) v8(145.66,23.06) v8(145.66,22.4) v8(145.74,12.81) v8(145.89,40.58) v8(145.91,39.97) v8(145.89,39.36) v8(145.86,38.09) v8(146.01,57.27) v8(146.37,24.43) v8(146.44,23.06) v8(146.44,16.63) v8(146.44,11.93) v8(146.44,11.45) v8(146.52,59.81) v8(146.46,20.46) v8(146.48,15.96) v8(146.47,14.59) v8(146.48,13.9) v8(146.69,17.38) v8(146.8,57.85) v8(146.8,40.63) v8(147.17,58.43) v8(147.18,41.47) v8(147.28,19.86) v8(147.31,15) v8(147.71,58.08) v8(147.69,40.56) v8(147.69,39.87) v8(147.69,38.63) v8(147.66,38.17) v8(147.84,34.74) v8(147.8,16.14) v8(147.99,18.25) v8(148.1,37.58) v8(148.6,40) v8(148.6,39.44) v8(148.63,38.78) v8(148.65,40.56) v8(148.74,16.25) v8(148.76,19.7) v8(148.78,14.96) v8(148.83,13.33) v8(149.37,22.47) v8(149.52,40.66) v8(149.62,21.05) v8(149.63,19.8) v8(149.62,15.84) v8(149.59,13.91) v8(149.65,12.67) v8(149.67,18.58) v8(150.03,41.5) v8(150.28,37.43) v8(150.44,23.7) v8(150.44,11.5) v8(150.46,40.07) v8(150.47,15.23) v8(150.5,14.01) v8(150.61,17.72) v8(150.92,41.52) v8(151.22,23.74) v8(151.25,22.42) v8(151.21,21.13) v8(151.24,20.44) v8(151.24,19.8) v8(151.24,19.16) v8(151.23,16.52) v8(151.24,15.91) v8(151.25,15.26) v8(151.24,13.94) v8(151.25,12.64) v8(151.2,11.98) v8(151.32,38.8) v8(151.27,18.59) v8(151.37,39.44) v8(151.75,41.57) v8(152.05,21.74) v8(152.04,14.61) v8(152.08,13.99) v8(152.06,13.3) v8(152.06,12.67) v8(152.06,11.98) v8(152.29,40.07) v8(152.72,41.62) v8(153.18,40.07) v8(154.12,40.53) v8(154.14,39.77) v8(154.14,39.01) v8(154.9,57.4) v8(154.9,39.44) v8(155.13,51.63) v8(155.84,55.97) v8(155.87,51.61) v8(156.55,51.61) v8(156.99,56.02) v8(157.32,62.17) v8(157.64,23.03) v8(157.62,19.78) v8(157.62,15.81) v8(157.62,13.96) v8(157.62,13.3) v8(157.62,12.67) v8(157.61,11.99) v8(157.68,22.45) v8(157.95,62.17) v8(157.95,17.37) v8(158.07,14.15) v8(158.21,51.61) v8(158.21,18.38) v8(158.43,23.03) v8(158.43,22.42) v8(158.42,20.61) v8(158.43,19.88) v8(158.41,19.02) v8(158.41,15.81) v8(158.43,12.69) v8(158.46,12.01) v8(158.69,57.19) v8(158.89,51.66) v8(158.87,25.09) v8(159.22,16.58) v8(159.23,15.86) v8(159.23,13.93) v8(159.25,12.61) v8(159.17,11.96) v8(159.32,21.76) v8(159.68,56.76) v8(159.7,51.66) v8(160.01,24.25) v8(160.03,23.13) v8(160.03,22.45) v8(160.01,21.66) v8(159.98,18.43) v8(160.04,15.41) v8(160.03,14.75) v8(160.08,11.42) v8(160.29,57.42) v8(160.26,56.76) v8(160.32,17.74) v8(160.89,16.25) v8(160.92,13.54) v8(160.98,20.81) v8(161.13,50.11) v8(161.13,48.58) v8(161.08,19.2) v8(161.29,17.88) v8(161.96,18.43) v8(162.36,16.25) v8(162.6,56.05) v8(162.57,19.93) v8(162.83,18.43) v8(163.19,24.73) v8(163.23,22.5) v8(163.23,21.76) v8(163.23,20.46) v8(163.23,15.91) v8(163.16,12.67) v8(163.23,11.4) v8(163.26,19.8) v8(163.26,13.92) v8(164.02,55.57) v8(164.05,19.91) v8(163.98,17.13) v8(164.02,16.53) v8(164.02,15.33) v8(163.96,13.99) v8(164.05,12.67) v8(164.12,52.47) v8(164.07,24.96) v8(164.1,21.76) v8(164.17,54.04) v8(164.71,18.23) v8(164.81,23.74) v8(164.81,23) v8(164.81,22.42) v8(164.81,21.72) v8(164.81,21.15) v8(164.83,20.39) v8(164.83,19.8) v8(164.83,15.36) v8(164.83,13.79) v8(164.83,12.67) v8(164.87,14.65) v8(165.29,17.26) v8(165.51,19.14) v8(165.63,23.71) v8(165.65,23.03) v8(165.65,21.76) v8(165.65,21.13) v8(165.65,20.44) v8(165.65,19.93) v8(165.59,15.33) v8(165.63,12.66) v8(165.88,18.28) v8(166.43,21.84) v9(111.71,18.07) v9(111.94,16.56) v9(112.03,23.69) v9(112.02,21.74) v9(112.03,19.82) v9(112.03,19.14) v9(112.02,15.89) v9(112.02,14.84) v9(112.03,12.46) v9(112.05,21.07) v9(112.31,17.35) v9(112.83,19.8) v9(112.84,16.56) v9(112.84,11.46) v9(112.89,24.33) v9(112.87,21.76) v9(112.87,21.07) v9(112.95,18.43) v9(112.86,15.24) v9(112.86,14.45) v9(112.89,13.76) v9(113.18,17.96) v9(113.45,13.76) v9(113.6,21.76) v9(113.63,19.78) v9(113.65,15.22) v9(113.65,19.14) v9(113.65,10.76) v9(113.75,24.44) v9(113.9,23.53) v9(113.98,18.2) v9(114.43,16.56) v9(114.44,13.96) v9(114.44,13.28) v9(114.49,21.79) v9(114.49,21.13) v9(114.49,20.46) v9(114.47,19.78) v9(114.45,19.13) v9(114.46,15.28) v9(114.46,11.4) v9(114.74,18.36) v9(115.22,19.79) v9(115.25,17.7) v9(115.33,14.92) v9(115.65,16.04) v9(116.07,18.31) v9(116.72,16.38) v9(116.83,19.81) v9(116.85,22.29) v9(116.88,15.11) v9(116.93,13.86) v9(117.45,18.48) v9(117.64,24.43) v9(117.62,23.74) v9(117.64,19.8) v9(117.64,15.89) v9(117.59,14.55) v9(117.63,13.95) v9(117.64,13.28) v9(117.64,12.62) v9(117.63,11.37) v9(117.72,17.49) v9(118.43,20.45) v9(118.45,21.76) v9(118.49,21.18) v9(118.48,14.01) v9(118.49,11.92) v9(119.15,14.71) v9(119.24,24.91) v9(119.22,21.79) v9(119.24,17.39) v9(119.25,16.55) v9(119.24,15.89) v9(119.23,15.23) v9(119.24,13.35) v9(119.27,20.51) v9(119.27,11.96) v9(119.39,20.03) v9(120.03,22.42) v9(120.03,13.84) v9(120.05,21.13) v9(120.05,16.98) v9(120.2,15.58) v9(120.82,15.13) v9(120.84,13.51) v9(121.4,42.23) v9(121.91,38.04) v9(121.98,41.5) v9(122.8,42.79) v9(123.51,37.74) v9(124.09,39.34) v9(124.25,38.02) v9(124.42,35.83) v9(124.5,42.33) v9(124.68,36.57) v9(124.83,40.07) v9(124.78,13.51) v9(124.88,20.54) v9(124.87,19.52) v9(125.34,41.39) v9(125.37,17.84) v9(125.62,23.87) v9(125.64,23.08) v9(125.62,18.35) v9(125.64,15.23) v9(125.74,41.17) v9(125.74,40.07) v9(125.67,13.96) v9(126.03,37.31) v9(126.18,41.39) v9(126.18,17.26) v9(126.33,12.01) v9(126.43,20.44) v9(126.42,19.84) v9(126.41,19.27) v9(126.46,22.37) v9(126.46,21.73) v9(126.46,15.92) v9(126.46,15.23) v9(126.66,40.07) v9(126.66,39.49) v9(126.66,39.01) v9(126.82,14.2) v9(127.24,14.57) v9(127.24,13.94) v9(127.27,15.33) v9(127.27,12.69) v9(127.36,18.03) v9(127.65,39.36) v9(128.03,40.33) v9(128,23.03) v9(128,21.85) v9(128.01,19.89) v9(128.04,19.27) v9(128.03,15.84) v9(128.11,37.84) v9(128.11,18.59) v9(128.29,17.66) v9(128.46,40.63) v9(128.49,40) v9(128.49,39.36) v9(128.49,38.78) v9(128.82,37.81) v9(128.97,40.28) v9(129.07,65.58) v9(129.38,40.61) v9(129.4,39.36) v9(129.4,38.73) v9(129.45,38.17) v9(129.66,36.62) v9(129.73,17.7) v9(129.83,41.39) v9(129.96,18.7) v9(130.24,39.9) v9(130.32,37.71) v9(130.39,38.22) v9(130.39,20.77) v9(130.39,14.9) v9(130.47,13.43) v9(130.47,12.64) v9(130.71,15.77) v9(130.93,18.38) v9(131.23,40.66) v9(131.2,21.79) v9(131.2,19.75) v9(131.23,15.79) v9(131.23,14.01) v9(131.23,13.3) v9(131.2,11.37) v9(131.31,38.27) v9(131.25,20.56) v9(131.62,22.09) v9(131.79,18.41) v9(131.77,17.6) v9(132.02,13.33) v9(132.02,12.69) v9(132.14,40.63) v9(132.14,40) v9(132.14,39.36) v9(132.14,38.73) v9(132.07,21.73) v9(132.22,37.18) v9(132.53,17.98) v9(132.6,37.66) v9(132.85,15.78) v9(132.81,12.72) v9(132.93,20.54) v9(132.86,13.63) v9(133.06,40.07) v9(133.21,34.97) v9(133.54,41.39) v9(133.59,24.89) v9(133.64,23.06) v9(133.63,22.43) v9(133.64,21.73) v9(133.64,21.05) v9(133.57,14.62) v9(133.62,12.03) v9(133.93,18.2) v9(134,41.9) v9(133.97,40.07) v9(134.13,37.69) v9(134.43,41.5) v9(134.35,19.8) v9(134.5,13.63) v9(134.89,40.07) v9(134.89,39.51) v9(134.89,38.78) v9(135.37,41.67) v9(135.8,40.07) v9(136.34,41.62) v9(136.72,40.07) v9(136.69,37.66) v9(137.17,41.45) v9(137.63,40.07) v9(137.63,39.51) v9(137.63,38.78) v9(138.06,41.55) v9(138.55,40.05) v9(139.05,41.55) v9(139.46,40.07) v9(139.92,41.45) v9(140.37,40.07) v9(140.37,39.51) v9(140.37,38.78) v9(140.83,41.45) v9(141.31,40.07) v9(141.77,41.47) v9(142.2,40.07) v9(142.15,37.15) v9(142.61,56.18) v9(142.69,41.45) v9(143.12,40.05) v9(143.12,39.51) v9(143.12,38.78) v9(143.24,14.93) v9(143.25,19.47) v9(143.26,16.22) v9(143.27,13.81) v9(143.5,37.13) v9(143.47,34.54) v9(143.65,41.47) v9(143.58,18.33) v9(143.88,58.59) v9(144.03,56.69) v9(144.03,40.18) v9(144.03,38.96) v9(144.01,14.22) v9(144.08,24.3) v9(144.06,19.14) v9(144.33,17.28) v9(144.54,17.95) v9(144.62,13.45) v9(144.82,37.53) v9(144.84,23.06) v9(144.84,20.44) v9(144.83,19.14) v9(144.83,16.55) v9(144.84,15.89) v9(144.85,15.25) v9(144.84,11.93) v9(144.84,11.42) v9(144.86,19.8) v9(145.05,40.05) v9(145.02,39.34) v9(145.23,59.3) v9(145.48,18.14) v9(145.64,20.47) v9(145.64,19.8) v9(145.62,19.19) v9(145.64,15.25) v9(145.64,13.94) v9(145.66,23.06) v9(145.66,22.4) v9(145.74,12.81) v9(145.91,39.97) v9(145.89,39.36) v9(145.86,38.09) v9(146.01,57.27) v9(146.37,24.43) v9(146.44,23.06) v9(146.44,16.63) v9(146.44,11.93) v9(146.44,11.45) v9(146.52,59.81) v9(146.46,20.46) v9(146.48,15.96) v9(146.47,14.59) v9(146.48,13.9) v9(146.69,17.38) v9(146.8,57.85) v9(147.17,58.43) v9(147.18,41.47) v9(147.28,19.86) v9(147.31,15) v9(147.71,58.08) v9(147.69,39.87) v9(147.69,38.63) v9(147.66,38.17) v9(147.84,34.74) v9(147.8,16.14) v9(147.99,18.25) v9(148.1,37.58) v9(148.6,40) v9(148.6,39.44) v9(148.63,38.78) v9(148.65,40.56) v9(148.74,16.25) v9(148.76,19.7) v9(148.78,14.96) v9(148.83,13.33) v9(149.37,22.47) v9(149.52,40.66) v9(149.62,21.05) v9(149.63,19.8) v9(149.62,15.84) v9(149.59,13.91) v9(149.65,12.67) v9(149.67,18.58) v9(150.03,41.5) v9(150.28,37.43) v9(150.44,23.7) v9(150.44,11.5) v9(150.46,40.07) v9(150.47,15.23) v9(150.5,14.01) v9(150.61,17.72) v9(150.92,41.52) v9(151.22,23.74) v9(151.25,22.42) v9(151.21,21.13) v9(151.24,20.44) v9(151.24,19.8) v9(151.24,19.16) v9(151.23,16.52) v9(151.24,15.91) v9(151.25,15.26) v9(151.24,13.94) v9(151.25,12.64) v9(151.2,11.98) v9(151.32,38.8) v9(151.27,18.59) v9(151.37,39.44) v9(151.75,41.57) v9(152.05,21.74) v9(152.04,14.61) v9(152.08,13.99) v9(152.06,13.3) v9(152.06,12.67) v9(152.06,11.98) v9(152.29,40.07) v9(152.72,41.62) v9(153.18,40.07) v9(154.12,40.53) v9(154.14,39.77) v9(154.14,39.01) v9(154.9,39.44) v9(157.64,23.03) v9(157.62,19.78) v9(157.62,15.81) v9(157.62,13.96) v9(157.62,13.3) v9(157.62,12.67) v9(157.61,11.99) v9(157.68,22.45) v9(157.95,17.37) v9(158.07,14.15) v9(158.21,18.38) v9(158.43,23.03) v9(158.43,22.42) v9(158.42,20.61) v9(158.43,19.88) v9(158.41,19.02) v9(158.41,15.81) v9(158.43,12.69) v9(158.46,12.01) v9(158.87,25.09) v9(159.22,16.58) v9(159.23,15.86) v9(159.23,13.93) v9(159.25,12.61) v9(159.17,11.96) v9(159.32,21.76) v9(160.01,24.25) v9(160.03,23.13) v9(160.03,22.45) v9(160.01,21.66) v9(159.98,18.43) v9(160.04,15.41) v9(160.03,14.75) v9(160.08,11.42) v9(160.32,17.74) v9(160.89,16.25) v9(160.92,13.54) v9(160.98,20.81) v9(161.08,19.2) v9(161.29,17.88) v9(161.96,18.43) v9(162.36,16.25) v9(162.57,19.93) v9(162.83,18.43) v9(163.19,24.73) v9(163.23,22.5) v9(163.23,21.76) v9(163.23,20.46) v9(163.23,15.91) v9(163.16,12.67) v9(163.23,11.4) v9(163.26,19.8) v9(163.26,13.92) v9(164.05,19.91) v9(163.98,17.13) v9(164.02,16.53) v9(164.02,15.33) v9(163.96,13.99) v9(164.05,12.67) v9(164.07,24.96) v9(164.1,21.76) v9(164.71,18.23) v9(164.81,23.74) v9(164.81,23) v9(164.81,22.42) v9(164.81,21.72) v9(164.81,21.15) v9(164.83,20.39) v9(164.83,19.8) v9(164.83,15.36) v9(164.83,13.79) v9(164.83,12.67) v9(164.87,14.65) v9(165.29,17.26) v9(165.51,19.14) v9(165.63,23.71) v9(165.65,23.03) v9(165.65,21.76) v9(165.65,21.13) v9(165.65,20.44) v9(165.65,19.93) v9(165.59,15.33) v9(165.63,12.66) v9(165.88,18.28) v9(166.43,21.84) v10(11.01,76.99) v10(11.01,75.44) v10(30.11,67.97) v10(103.03,17.15) v10(104.16,19.11) v10(104.16,15.19) v10(106.42,19.11) v10(106.42,15.19) v10(107.55,17.15) v10(111.64,36.32) v10(111.64,23.37) v10(111.64,22.07) v10(111.64,20.77) v10(111.64,19.47) v10(111.64,16.22) v10(111.64,13.62) v10(111.64,12.32) v10(112.05,63.52) v10(112.44,22.72) v10(112.44,18.82) v10(112.44,16.87) v10(112.77,38.28) v10(112.77,34.37) v10(113.18,65.48) v10(113.18,61.57) v10(113.24,24.67) v10(113.24,23.37) v10(113.24,20.77) v10(113.24,19.47) v10(113.24,14.92) v10(113.24,12.32) v10(113.24,11.02) v10(114.04,22.72) v10(114.04,18.82) v10(114.04,16.87) v10(114.04,12.97) v10(114.84,20.77) v10(114.84,14.92) v10(114.84,13.62) v10(114.84,12.32) v10(114.84,11.02) v10(115.03,38.28) v10(115.03,34.37) v10(115.44,65.48) v10(115.44,61.57) v10(116.16,36.32) v10(116.57,63.52) v10(116.68,44.9) v10(116.68,44.52) v10(116.93,44.71) v10(117.18,44.9) v10(117.18,44.52) v10(117.24,23.37) v10(117.24,22.07) v10(117.24,14.92) v10(117.24,13.62) v10(117.24,12.32) v10(117.24,11.02) v10(117.95,44.9) v10(117.95,44.52) v10(118.04,22.72) v10(118.04,12.97) v10(118.2,44.71) v10(118.45,44.9) v10(118.45,44.52) v10(118.84,23.37) v10(118.84,14.92) v10(118.84,12.32) v10(119.22,44.9) v10(119.22,44.52) v10(119.47,44.71) v10(119.64,12.97) v10(119.72,44.9) v10(119.72,44.52) v10(120.44,20.77) v10(120.44,14.92) v10(120.44,13.62) v10(120.44,12.32) v10(121.86,8.25) v10(122.52,14.45) v10(122.52,12.99) v10(122.5,8.25) v10(123.11,13.62) v10(125.23,23.37) v10(125.23,22.07) v10(125.23,20.77) v10(125.23,19.47) v10(125.23,16.22) v10(125.23,14.92) v10(125.23,13.62) v10(125.23,12.32) v10(126.03,18.82) v10(126.03,16.87) v10(126.03,12.97) v10(126.19,8.67) v10(126.83,24.67) v10(126.83,19.47) v10(126.83,16.22) v10(126.83,14.92) v10(126.83,12.32) v10(126.83,11.02) v10(127.63,22.72) v10(127.63,18.82) v10(127.63,16.87) v10(127.63,12.97) v10(128.06,8.67) v10(128.43,23.37) v10(128.43,22.07) v10(128.43,14.92) v10(128.43,13.62) v10(128.43,12.32) v10(128.43,11.02) v10(130.47,8.67) v10(130.83,23.37) v10(130.83,22.07) v10(130.83,20.77) v10(130.83,14.92) v10(130.83,13.62) v10(130.83,12.32) v10(130.83,11.02) v10(131.63,22.72) v10(131.63,16.87) v10(131.63,12.97) v10(132.43,23.37) v10(132.43,20.77) v10(132.43,14.92) v10(132.43,12.32) v10(132.51,8.67) v10(133.23,22.72) v10(133.23,18.82) v10(134.03,23.37) v10(134.03,22.07) v10(134.03,20.77) v10(134.03,16.22) v10(134.03,14.92) v10(134.03,12.32) v10(136.82,16.42) v10(136.82,14.39) v10(140.52,17.94) v10(140.6,9.21) v10(140.69,18.77) v10(140.75,17.18) v10(140.81,20.86) v10(140.88,23.02) v10(140.88,22.39) v10(140.94,14.83) v10(143.64,22.07) v10(143.64,20.77) v10(143.64,19.47) v10(143.64,16.22) v10(143.64,14.92) v10(143.64,13.62) v10(144.44,18.82) v10(144.44,16.87) v10(145.24,23.37) v10(145.24,20.77) v10(145.24,19.47) v10(145.24,16.22) v10(145.24,14.92) v10(145.24,12.32) v10(145.46,8.98) v10(146.04,22.72) v10(146.04,18.82) v10(146.04,16.87) v10(146.85,23.37) v10(146.85,22.07) v10(146.85,20.77) v10(146.85,14.92) v10(146.85,11.02) v10(148.51,8.93) v10(149.25,14.92) v10(149.25,13.62) v10(149.25,12.32) v10(149.25,11.02) v10(150.05,22.72) v10(150.05,18.82) v10(150.05,16.87) v10(150.05,12.97) v10(150.85,24.67) v10(150.85,23.37) v10(150.85,20.77) v10(150.85,19.47) v10(150.85,16.22) v10(150.85,14.92) v10(150.85,12.32) v10(150.85,11.02) v10(150.82,8.9) v10(151.65,18.82) v10(151.65,16.87) v10(151.65,12.97) v10(152.45,16.22) v10(152.45,14.92) v10(152.45,13.62) v10(152.45,12.32) v10(154.53,10.83) v10(154.53,10.2) v10(154.82,11.64) v10(157.23,23.37) v10(157.23,22.07) v10(157.23,20.77) v10(157.23,19.47) v10(157.23,16.22) v10(157.23,14.92) v10(158.03,22.72) v10(158.03,18.82) v10(158.03,16.87) v10(158.71,8.86) v10(158.83,24.67) v10(158.83,20.77) v10(158.83,19.47) v10(158.83,16.22) v10(158.83,14.92) v10(158.83,12.32) v10(159.35,19.78) v10(159.48,8.91) v10(159.63,22.72) v10(159.63,18.82) v10(159.63,16.87) v10(159.63,12.97) v10(160.01,20.31) v10(160.16,8.96) v10(160.43,23.37) v10(160.43,22.07) v10(160.43,20.77) v10(160.43,14.92) v10(160.43,13.62) v10(160.43,11.02) v10(160.87,19.55) v10(161.96,8.96) v10(162.83,23.37) v10(162.83,22.07) v10(162.83,20.77) v10(162.83,14.92) v10(162.83,13.62) v10(162.83,12.32) v10(162.83,11.02) v10(163.63,16.87) v10(163.63,12.97) v10(164.43,24.67) v10(164.43,20.77) v10(164.43,19.47) v10(164.43,16.22) v10(164.43,14.92) v10(164.43,12.32) v10(164.43,11.02) v10(165.23,22.72) v10(165.23,18.82) v10(165.23,16.87) v10(166.03,23.37) v10(166.03,22.07) v10(166.03,20.77) v10(166.03,19.47) v10(166.03,16.22) v10(166.03,14.92) v10(166.03,12.32) v10(176.33,63.52) v10(176.76,36.35) v10(177.46,65.48) v10(177.46,61.57) v10(177.89,38.31) v10(177.89,34.39) v10(179.72,65.48) v10(179.72,61.57) v10(180.15,38.31) v10(180.15,34.39) v10(180.85,63.52) v10(181.28,36.35) v10(262.4,44.75) v10(268.15,39.2) v11(9.49,77.37) v11(9.49,74.96) v11(9.58,67.76) v11(9.58,67.12) v11(9.66,68.52) v11(10.08,77.38) v11(10.12,74.96) v11(11.01,78.12) v11(11.33,68.52) v11(11.39,70.55) v11(11.43,67.76) v11(11.43,67.12) v11(19.42,24.22) v11(19.37,23.18) v11(20.03,34.48) v11(20.03,32.23) v11(20.67,27.68) v11(22.82,52.61) v11(23.06,54.48) v11(23.42,31.28) v11(24.75,55.58) v11(24.84,2.7) v11(24.84,2.45) v11(24.86,30.75) v11(25.09,2.7) v11(25.09,2.45) v11(25.35,2.7) v11(25.35,2.45) v11(25.56,52.99) v11(26.06,2.67) v11(26.06,2.42) v11(26.23,56.96) v11(26.25,55.78) v11(26.31,2.67) v11(26.31,2.42) v11(26.57,2.67) v11(26.57,2.42) v11(26.8,56.96) v11(26.8,53.71) v11(27.28,2.7) v11(27.28,2.45) v11(27.43,56.33) v11(27.53,2.7) v11(27.53,2.45) v11(27.79,2.7) v11(27.79,2.45) v11(27.98,56.92) v11(27.98,54.38) v11(28.07,56.33) v11(28.06,24.2) v11(28.06,23.18) v11(28.18,14.29) v11(28.44,22.29) v11(28.44,22.04) v11(28.44,21.79) v11(28.82,26.87) v11(28.82,26.61) v11(28.82,26.36) v11(28.84,25.6) v11(28.84,25.34) v11(28.84,25.09) v11(28.77,22.29) v11(28.77,22.04) v11(28.77,21.79) v11(29.12,56.57) v11(29.15,26.87) v11(29.15,26.61) v11(29.15,26.36) v11(29.1,21.02) v11(29.1,20.77) v11(29.1,20.52) v11(29.1,19.75) v11(29.1,19.5) v11(29.1,19.25) v11(29.17,25.6) v11(29.17,25.34) v11(29.17,25.09) v11(29.38,55.65) v11(29.38,55.02) v11(29.38,54.38) v11(29.43,21.02) v11(29.43,20.77) v11(29.43,20.52) v11(29.43,19.75) v11(29.43,19.5) v11(29.43,19.25) v11(29.64,62.82) v11(30.91,62.82) v11(31.03,12.34) v11(32.99,2.81) v11(33.66,58.98) v11(34.4,36.26) v11(34.36,9.83) v11(34.5,64.64) v11(34.59,4.65) v11(36.62,59.86) v11(36.62,55.59) v11(36.96,9.06) v11(38.17,6.1) v11(40.68,4.95) v11(89.88,61.96) v11(90.07,68.65) v11(90.91,43.16) v11(90.95,33.28) v11(91.37,43.01) v11(91.41,33.12) v11(92.21,43.2) v11(92.18,33.26) v11(92.64,33.11) v11(92.67,43.04) v11(93.69,63.23) v11(93.88,71.52) v11(94.32,63.23) v11(94.38,71.52) v11(94.96,68.65) v11(94.96,63.23) v11(95.33,25.19) v11(95.59,63.23) v11(97.88,63.28) v11(98.64,63.28) v11(99.79,74.4) v11(100.04,63.23) v11(100.67,63.23) v11(101.31,68.65) v11(101.31,63.23) v11(101.94,63.23) v11(102.24,2.05) v11(102.58,63.23) v11(103.21,63.23) v11(103.85,63.23) v11(104.07,2.01) v11(104.48,63.23) v11(104.88,71.52) v11(104.88,65.78) v11(105.12,63.23) v11(105.38,71.52) v11(106.2,68.65) v11(108.45,14.64) v11(108.64,19.28) v11(108.81,22.26) v11(108.81,21.5) v11(108.81,18.45) v11(108.81,17.82) v11(108.81,17.18) v11(108.81,16.61) v11(108.81,15.4) v11(108.87,25.05) v11(108.87,24.42) v11(108.89,23.86) v11(108.85,22.93) v11(108.87,13.75) v11(109.24,1.83) v11(111.06,28.48) v11(111.64,14.92) v11(111.82,28.26) v11(111.93,4.39) v11(112.07,2.34) v11(112.44,12.97) v11(112.48,8.67) v11(112.61,27.6) v11(114.21,8.7) v11(114.25,2.56) v11(114.21,1.71) v11(114.84,23.37) v11(114.84,22.07) v11(115.48,8.7) v11(117.24,20.77) v11(118.05,51.78) v11(118.05,51.4) v11(118.04,18.82) v11(118.04,16.87) v11(118.3,51.59) v11(118.56,51.78) v11(118.56,51.4) v11(118.84,24.67) v11(118.84,20.77) v11(118.84,19.47) v11(118.84,16.22) v11(118.84,11.02) v11(119.2,27.38) v11(119.29,51.76) v11(119.29,51.38) v11(119.55,51.57) v11(119.64,22.72) v11(119.64,18.82) v11(119.64,16.87) v11(119.8,51.76) v11(119.8,51.38) v11(120.02,27.14) v11(120.44,23.37) v11(120.44,22.07) v11(120.44,19.47) v11(120.44,16.22) v11(120.98,27.21) v11(121.07,8.32) v11(121.85,54) v11(121.93,57.09) v11(122.44,26.24) v11(122.52,21.56) v11(122.52,10.32) v11(122.52,9.69) v11(122.62,53.99) v11(122.68,5) v11(122.82,24.5) v11(122.82,17.74) v11(122.82,16.75) v11(122.82,11.14) v11(123.11,22.77) v11(123.11,22.13) v11(123.11,20.36) v11(123.11,19.78) v11(123.2,27.05) v11(123.2,26.24) v11(123.15,8.25) v11(123.28,5.69) v11(123.56,1.69) v11(123.83,27.05) v11(124.08,2.61) v11(124.45,66.46) v11(124.47,27.05) v11(125.1,27.05) v11(125.79,27.62) v11(126.03,22.72) v11(126.46,27.63) v11(126.58,65.58) v11(126.56,63.49) v11(126.83,23.37) v11(126.83,20.77) v11(127.09,27.63) v11(127.22,61.49) v11(128.17,62.53) v11(128.22,55.9) v11(128.79,58.61) v11(128.77,58.04) v11(129,53.61) v11(129.49,58.06) v11(129.45,57.35) v11(129.49,55.9) v11(129.75,44.49) v11(130.67,53.15) v11(130.9,55.9) v11(131.38,44.49) v11(131.53,51.05) v11(131.63,18.82) v11(131.66,55.95) v11(131.76,53.15) v11(132.17,51.05) v11(132.43,24.67) v11(132.43,19.47) v11(132.43,16.22) v11(132.43,11.02) v11(132.79,67.28) v11(132.8,51.05) v11(133,44.49) v11(133.23,16.87) v11(133.23,12.97) v11(133.47,63.81) v11(133.5,55.76) v11(133.69,67.28) v11(133.71,54.02) v11(133.69,26.97) v11(134.03,19.47) v11(134.03,13.62) v11(134.1,63.8) v11(134.22,44.49) v11(134.46,26.92) v11(134.58,67.28) v11(135.69,27.49) v11(135.85,44.49) v11(136.23,67.28) v11(136.58,27.66) v11(136.82,23.28) v11(136.82,22.64) v11(136.82,21.5) v11(136.82,19.59) v11(136.82,18.1) v11(136.82,15.05) v11(137.03,52.9) v11(137.12,67.28) v11(137.24,20.61) v11(137.24,17.31) v11(137.42,27.05) v11(137.47,44.49) v11(138.01,67.28) v11(138.06,27.05) v11(138.55,51.4) v11(138.62,27.06) v11(139.2,27.05) v11(139.43,58.6) v11(139.83,27.05) v11(140.27,13.88) v11(140.55,64.97) v11(140.58,63.96) v11(140.62,13.05) v11(140.6,12.39) v11(140.76,62.74) v11(140.81,21.5) v11(140.81,20.23) v11(141.05,62.74) v11(141.16,58.59) v11(141.31,62.73) v11(141.57,58.92) v11(141.63,55.49) v11(141.72,58.44) v11(142.95,27.21) v11(143.22,62.86) v11(143.6,60.65) v11(143.64,23.37) v11(143.64,12.32) v11(143.82,27.49) v11(143.85,64.94) v11(143.9,56.08) v11(143.98,55.57) v11(144.44,22.72) v11(144.44,12.97) v11(144.46,27.49) v11(145.24,24.67) v11(145.24,11.02) v11(145.38,63.31) v11(146.04,12.97) v11(146.14,63.24) v11(146.78,65.65) v11(146.85,13.62) v11(146.85,12.32) v11(147.92,56.1) v11(149.25,23.37) v11(149.25,22.07) v11(149.25,20.77) v11(149.32,56.96) v11(150.2,56.96) v11(150.2,56.1) v11(151,28.18) v11(151.22,57.65) v11(151.47,55.44) v11(151.65,22.72) v11(151.7,27.88) v11(152.08,8.98) v11(152.45,23.37) v11(152.45,22.07) v11(152.45,20.77) v11(152.45,19.47) v11(152.46,27.91) v11(152.74,55.43) v11(153.25,56.58) v11(153.32,33.76) v11(153.32,33.11) v11(153.55,60.63) v11(153.55,60.35) v11(153.51,55.01) v11(153.51,27.91) v11(153.56,60.89) v11(153.67,57.89) v11(154.14,57.22) v11(154.27,27.45) v11(154.45,51.71) v11(154.4,45.61) v11(154.53,19.09) v11(154.53,14.89) v11(154.65,16.22) v11(154.82,20.15) v11(154.9,56.46) v11(154.9,27.45) v11(155.02,6.07) v11(155.13,52.11) v11(155.11,21.88) v11(155.11,17.85) v11(155.11,14.13) v11(155.11,13.37) v11(155.72,44.43) v11(155.78,55.35) v11(155.96,53.57) v11(155.97,53) v11(156.04,40.23) v11(156.04,37.62) v11(156.07,50.64) v11(156.3,67.35) v11(156.3,58.35) v11(156.33,50.63) v11(156.27,27.75) v11(156.61,50.63) v11(156.71,55.35) v11(157.04,67.29) v11(157.06,57.22) v11(157.19,58.35) v11(157.16,28.04) v11(157.23,13.62) v11(157.23,12.32) v11(157.31,38.2) v11(157.38,61.68) v11(157.39,51.59) v11(157.52,54.9) v11(157.57,57.02) v11(157.82,33.83) v11(157.93,65.09) v11(157.92,27.62) v11(158.03,12.97) v11(158.08,57.22) v11(158.18,52.05) v11(158.33,55.95) v11(158.46,62.17) v11(158.58,40.23) v11(158.58,28.43) v11(158.55,27.62) v11(158.71,55.95) v11(158.83,23.37) v11(158.83,11.02) v11(159.03,61.45) v11(159.09,58.35) v11(159.22,57.22) v11(159.2,51.05) v11(159.22,45.61) v11(159.21,35.66) v11(159.19,33.81) v11(159.49,65.09) v11(159.57,55.31) v11(159.75,32.54) v11(160.28,51.6) v11(160.36,55.95) v11(160.36,32.54) v11(160.43,12.32) v11(160.49,43.81) v11(160.55,37.88) v11(160.61,41.76) v11(160.75,55.95) v11(161.2,42.92) v11(161.24,40.99) v11(161.35,51.05) v11(161.38,57.22) v11(161.57,38.58) v11(161.76,55.57) v11(161.85,50.11) v11(161.85,49.34) v11(161.84,48.6) v11(162.14,56.96) v11(162.14,6.09) v11(162.52,41.7) v11(162.51,40.99) v11(162.72,39.16) v11(163.44,53.43) v11(163.41,53.03) v11(163.41,52.11) v11(163.63,22.72) v11(163.63,18.82) v11(163.77,3.09) v11(163.89,37.23) v11(163.88,3.8) v11(164,54.55) v11(164.07,8.8) v11(164.45,37.36) v11(164.43,23.37) v11(164.76,28.46) v11(165.23,12.97) v11(165.35,28.47) v11(165.54,8.96) v11(165.82,47.09) v11(165.9,4.97) v11(165.9,4.54) v11(165.96,28.44) v11(166.03,13.62) v11(166.21,66.15) v11(166.24,40.97) v11(166.3,4.97) v11(166.3,4.53) v11(166.36,52.13) v11(166.69,4.97) v11(166.69,4.53) v11(167.05,5.81) v11(167.17,8.78) v11(167.53,48.3) v11(167.98,15.26) v11(167.97,4.75) v11(168.24,23.87) v11(168.24,23.26) v11(168.24,20.82) v11(168.24,19.3) v11(168.24,17.9) v11(168.24,13) v11(168.34,3.35) v11(168.62,51.63) v11(168.99,49.59) v11(168.99,47.74) v11(169.28,37.53) v11(169.38,56.71) v11(169.37,33.55) v11(169.64,41.43) v11(169.69,18.89) v11(170.05,46.54) v11(170.05,20.1) v11(170.45,48.43) v11(170.6,22.93) v11(170.96,16.88) v11(171.29,6.57) v11(171.35,19.52) v11(171.46,17.62) v11(171.47,16.12) v11(171.99,48.94) v11(172.08,21.25) v11(172.21,54.81) v11(172.3,13.33) v11(172.37,45.4) v11(172.56,48.94) v11(172.76,20.49) v11(172.93,44.68) v11(172.93,42.25) v11(173.13,4.83) v11(173.19,13.33) v11(173.6,45.35) v11(173.56,42.25) v11(173.58,3.9) v11(173.91,53.38) v11(173.95,17.35) v11(173.92,15.94) v11(174.03,12.48) v11(174.2,45.35) v11(174.59,28.04) v11(174.58,17.35) v11(174.76,52.68) v11(175.91,44.51) v11(175.93,3.91) v11(176.07,46.04) v11(176.07,45.38) v11(176.78,42.48) v11(177.2,7.23) v11(177.56,26.08) v11(177.59,5.02) v11(178.67,4.79) v11(178.97,27.16) v11(179.13,20.99) v11(179.13,16.99) v11(179.24,24.73) v11(179.91,47.95) v11(179.91,9.87) v11(179.91,8.09) v11(179.92,3.95) v11(180,47.19) v11(180.25,58.11) v11(180.61,47.19) v11(180.73,22.59) v11(180.73,19.39) v11(180.68,10.16) v11(180.68,8.88) v11(180.89,46) v11(181.32,47.87) v11(181.26,10.16) v11(181.32,8.88) v11(181.83,27.67) v11(181.84,26.28) v11(181.92,28.87) v11(181.95,10.16) v11(182.31,6.72) v11(182.4,26.29) v11(182.54,50.61) v11(182.53,10.16) v11(182.97,42.96) v11(183.1,57.7) v11(183.17,49.95) v11(183.61,55.52) v11(183.61,4.62) v11(183.73,41.69) v11(184.16,4.62) v11(184.47,8.98) v11(184.65,10.19) v11(185.15,28.06) v11(185.21,10.19) v11(185.62,4.84) v11(185.71,28.06) v11(185.81,54.88) v11(186.33,22.59) v11(186.53,26.74) v11(186.55,8.91) v11(186.62,7.66) v11(187.12,4.84) v11(188.08,25.77) v11(188.27,5.58) v11(189.08,22.64) v11(189.23,19.25) v11(189.46,23.41) v11(189.69,7.91) v11(189.73,7.15) v11(189.84,15.97) v11(190.05,8.88) v11(194.27,27.85) v11(194.27,26.85) v11(195.9,50.18) v11(195.9,43.68) v11(197.32,31.95) v11(197.32,19.25) v11(199.78,45.79) v11(211.21,3.83) v11(211.21,3.37) v11(211.4,3.6) v11(211.6,3.8) v11(211.57,3.4) v11(223.56,11.56) v11(224.19,11.56) v11(227.33,10.1) v11(229.76,8.91) v11(232.42,10.05) v11(232.86,7.76) v11(234.58,9.39) v11(234.99,5.86) v11(235.52,2.25) v11(236.97,5.15) v11(237.28,7.64) v11(238.65,9.36) v11(239.33,4.56) v11(240.65,7.33) v11(241.72,8.88) v11(242.48,4.44) v11(243.78,9.67) v11(243.78,7.36) v11(244.74,5.4) v11(244.97,3.37) v11(247.08,5.94) v11(247.56,4.11) v11(248.15,10.3) v11(249.34,10.41) v11(250.89,8.76) v11(251.8,10.51) v11(251.91,8.35) v11(253.46,8.81) v11(253.79,5.81) v11(255.33,5.45) v11(255.41,9.42) v11(255.54,61.41) v11(255.54,60.14) v11(255.54,59.25) v11(255.89,48.54) v11(256,52.47) v11(255.97,7.89) v11(256.38,46.27) v11(256.67,44.26) v11(256.77,41.15) v11(256.77,36.02) v11(256.87,14.65) v11(256.88,5.61) v11(257,11.47) v11(257.39,56.46) v11(257.62,54.04) v11(258.08,57.09) v11(258.08,56.46) v11(258.13,54.75) v11(258.05,29) v11(258.08,28.49) v11(258.2,40.25) v11(258.2,39.9) v11(258.2,39.51) v11(258.18,26.71) v11(258.28,50.16) v11(258.32,41.75) v11(258.48,26.71) v11(258.64,28.47) v11(258.64,27.58) v11(258.7,41.75) v11(258.73,29.55) v11(258.84,31.35) v11(258.84,31.06) v11(258.86,24.91) v11(258.89,14.57) v11(258.88,11.35) v11(258.88,10.71) v11(259.04,47.69) v11(258.97,32.28) v11(259.17,7.76) v11(259.53,43.68) v11(260.14,11.98) v11(260.19,13.95) v11(260.69,57.29) v11(260.77,13.95) v11(261.25,32.14) v11(261.51,44.32) v11(261.74,28.78) v11(261.95,30.78) v11(261.96,57.17) v11(262.12,6.77) v11(262.27,32.14) v11(262.6,55.36) v11(262.7,6.77) v11(262.8,13.53) v11(262.83,11.14) v11(263.23,55.36) v11(263.22,32.97) v11(263.22,32.59) v11(263.22,31.77) v11(263.22,31.39) v11(263.87,55.36) v11(263.98,12.34) v11(264.22,29.81) v11(264.3,29.35) v11(264.48,8.46) v11(264.55,28.85) v11(264.71,2.61) v11(264.83,58.29) v11(264.94,29.08) v11(265.04,27.98) v11(265.22,57.62) v11(265.2,17.52) v11(265.16,13.48) v11(265.16,11.14) v11(265.43,42.77) v11(265.37,41.98) v11(265.41,29.48) v11(265.65,32.8) v11(265.65,28.34) v11(265.77,57.65) v11(265.94,53.91) v11(265.94,49.9) v11(265.93,28.75) v11(266,28.34) v11(266.08,58.92) v11(266.39,33.62) v11(266.41,28.77) v11(266.41,28.26) v11(266.54,28.52) v11(266.61,52.48) v11(266.57,50.66) v11(266.7,53.91) v11(266.71,37.74) v11(266.66,28.77) v11(267.07,60.39) v11(267.11,15.92) v11(267.21,50.66) v11(267.27,53.28) v11(267.4,35.27) v11(267.37,17.67) v11(267.7,59.23) v11(267.91,56.43) v11(267.88,53.88) v11(267.91,53.28) v11(267.88,51.97) v11(267.91,9.82) v11(268.12,51.21) v11(268.09,40.72) v11(268.14,32.99) v11(268.42,39.96) v11(268.57,54.46) v11(268.62,43.88) v11(268.95,27.22) v11(269.09,52.41) v11(269.09,51.84) v11(269.7,19.55) v11(269.91,31.93) v11(270.17,39.31) v11(270.68,31.93) v11(270.73,27.22) v11(270.83,38.68) v11(271.44,43.43) v11(271.45,43.01) v11(271.44,42.56) v11(271.65,30.09) v11(271.62,27.22) v11(272.15,39.36) v11(272.15,38.19) v11(272.17,38.93) v11(272.17,38.55) v11(272.81,38.22) v11(272.86,39.36) v11(273.17,34.74) v11(273.65,38.93) v11(273.65,38.55) v11(273.65,35.88) v11(273.61,31.05) v11(273.61,30.65) v11(274.38,20.72) v11(275.1,41.57) v11(278.39,42.97) v11(278.86,66.24) v11(278.86,63.7) v11(279,48.58) v11(281.35,65.67) v11(281.35,64.19) v11(281.35,39.59) v11(282.61,66.24) v11(282.61,64.89) v11(283.2,66.24) v11(283.17,64.89) v12(0.5,63.82) v12(2.6,63.8) v12(4.47,41.83) v12(9.48,45.19) v12(10.81,45.58) v12(12.08,37.99) v12(12.54,68.86) v12(12.54,67.42) v12(12.92,65.22) v12(12.92,64.71) v12(12.99,66.62) v12(12.99,66.11) v12(13.02,64.97) v12(13.1,66.36) v12(13.25,66.62) v12(13.25,66.11) v12(13.17,65.22) v12(13.17,64.71) v12(13.54,37.26) v12(13.55,45.58) v12(13.84,46.34) v12(14.39,37.46) v12(16.35,43.16) v12(16.35,39.86) v12(16.54,57.39) v12(16.53,36.3) v12(16.8,31.51) v12(17.14,36.3) v12(17.14,31.3) v12(17.62,61.82) v12(17.62,45.19) v12(17.62,44.56) v12(17.62,43.8) v12(17.62,42.53) v12(17.62,41.89) v12(17.62,41.26) v12(17.6,31.3) v12(17.75,36.3) v12(18.28,56.66) v12(18.28,53.84) v12(18.51,27.44) v12(19.14,43.5) v12(20.24,30.01) v12(20.73,48.38) v12(20.89,65.85) v12(21.05,67.76) v12(21.05,63.95) v12(22.12,49.91) v12(22.25,36.85) v12(22.44,67.76) v12(22.44,63.95) v12(22.54,65.85) v12(22.52,49) v12(22.46,27.44) v12(22.76,55.76) v12(23,32.93) v12(23.2,25.07) v12(23.53,65.83) v12(23.65,53.99) v12(23.69,35.39) v12(23.84,67.76) v12(23.84,63.95) v12(23.99,26.5) v12(24.22,53.99) v12(24.44,49.11) v12(24.47,47.64) v12(24.75,30.46) v12(24.75,27.32) v12(24.73,11.37) v12(24.88,26.5) v12(24.97,40.42) v12(25.03,39.67) v12(25.06,11.78) v12(25.11,2.1) v12(25.24,17.85) v12(25.18,11.12) v12(25.39,63.95) v12(25.56,54.09) v12(25.56,53.63) v12(25.62,11.78) v12(25.92,12.24) v12(25.94,11.35) v12(25.97,26.76) v12(25.97,13.51) v12(26.1,11.78) v12(26.2,63.95) v12(26.23,12.87) v12(26.18,2.23) v12(26.4,11.14) v12(26.46,13.51) v12(26.48,12.24) v12(26.61,11.78) v12(26.75,47.88) v12(26.73,12.87) v12(26.79,57) v12(26.81,18.97) v12(26.81,13.91) v12(26.99,13.51) v12(26.96,12.24) v12(27.06,28.92) v12(27.12,11.78) v12(27.18,30.58) v12(27.18,30.2) v12(27.22,12.84) v12(27.29,13.91) v12(27.44,56.35) v12(27.44,55.05) v12(27.43,47.94) v12(27.37,28.92) v12(27.47,13.51) v12(27.47,12.24) v12(27.72,19.74) v12(27.73,12.87) v12(27.82,27.67) v12(27.78,21.56) v12(27.78,13.91) v12(27.98,13.51) v12(27.98,12.24) v12(28.09,56.35) v12(28.09,55.05) v12(28.09,54.4) v12(28.13,29.79) v12(28.31,13.91) v12(28.64,27.42) v12(28.64,27.12) v12(28.56,13.56) v12(28.57,8.41) v12(28.67,26.44) v12(28.74,20.59) v12(28.72,19.83) v12(28.72,19.14) v12(28.82,13.91) v12(28.9,41.97) v12(28.94,13.05) v12(29.02,17.59) v12(29.02,17.29) v12(29.15,29.79) v12(29.15,20.57) v12(29.13,19.81) v12(29.12,19.12) v12(29.4,5.99) v12(29.45,6.8) v12(29.58,20.57) v12(29.56,19.81) v12(29.55,19.12) v12(29.78,13.15) v12(29.89,16.34) v12(30.04,12.62) v12(30.16,57.77) v12(30.23,3.47) v12(30.35,9.29) v12(30.47,12.62) v12(30.52,11.6) v12(30.6,13.15) v12(30.87,41.34) v12(31.08,39.44) v12(31.13,12.49) v12(31.23,11.47) v12(31.32,13.09) v12(31.46,39.44) v12(31.54,24.47) v12(31.54,23.84) v12(31.54,23.2) v12(31.54,22.57) v12(31.54,12.1) v12(31.77,26.12) v12(31.77,25.23) v12(32.67,27.17) v12(32.86,17.54) v12(33.19,57.8) v12(33.19,56.53) v12(33.19,55.26) v12(33.21,3.69) v12(33.31,4.64) v12(33.63,33.68) v12(33.73,41.92) v12(33.94,17.55) v12(34.56,46.1) v12(34.56,45.52) v12(34.61,29.96) v12(34.58,2) v12(35.14,15.44) v12(35.52,15.05) v12(35.71,19.97) v12(35.8,16.38) v12(35.9,14.67) v12(36.06,16.12) v12(36.16,14.8) v12(36.31,15.87) v12(36.55,24) v12(36.46,14.52) v12(36.54,4.62) v12(36.72,17.24) v12(36.67,14.93) v12(36.79,14.17) v12(36.92,14.67) v12(36.97,16.98) v12(37.22,16.73) v12(37.17,14.42) v12(37.17,13.78) v12(37.43,15.69) v12(37.43,14.17) v12(37.61,18.13) v12(37.56,13.4) v12(37.68,16.2) v12(37.68,15.44) v12(37.68,13.91) v12(37.68,6.14) v12(37.86,17.86) v12(37.94,15.94) v12(37.94,15.18) v12(37.94,13.66) v12(37.94,13.02) v12(37.94,2.91) v12(38.11,17.62) v12(38.19,16.45) v12(38.19,15.69) v12(38.19,14.93) v12(38.19,13.4) v12(38.22,12.77) v12(38.44,16.96) v12(38.44,16.2) v12(38.44,15.44) v12(38.44,14.67) v12(38.44,13.15) v12(38.44,12.51) v12(38.7,16.71) v12(38.7,15.94) v12(38.7,15.18) v12(38.7,14.42) v12(38.7,13.66) v12(38.7,12.9) v12(38.95,16.45) v12(38.95,15.69) v12(38.95,14.93) v12(38.95,14.17) v12(38.95,13.4) v12(38.95,12.64) v12(39.21,16.2) v12(39.21,15.44) v12(39.21,14.67) v12(39.21,13.91) v12(39.21,13.15) v12(39.21,12.39) v12(39.46,14.42) v12(39.46,13.66) v12(39.46,12.9) v12(52.16,20.42) v12(52.65,19.96) v12(53.4,19.72) v12(58.14,12.57) v12(59.53,12.64) v12(59.78,12.39) v12(60.48,11.82) v12(61.46,11.57) v12(61.67,11.36) v12(61.89,11.14) v12(62.12,12.64) v12(62.27,17.85) v12(62.28,17.09) v12(64.65,10.65) v12(68.95,6.77) v12(70.25,10.65) v12(71.36,15.18) v12(71.55,14.17) v12(71.68,15.18) v12(72.12,12.01) v12(72.12,11.63) v12(72.44,12.01) v12(72.44,11.63) v12(72.63,16.4) v12(72.63,16.02) v12(72.95,16.4) v12(72.95,16.02) v12(74.16,16.48) v12(74.16,16.1) v12(74.35,11.22) v12(74.35,10.84) v12(74.35,10.46) v12(74.47,16.48) v12(74.47,16.1) v12(74.66,11.22) v12(74.66,10.84) v12(74.66,10.46) v12(74.98,11.22) v12(74.98,10.84) v12(74.98,10.46) v12(75.05,9.27) v12(75.05,8.88) v12(75.36,9.27) v12(75.36,8.88) v12(76.47,18.74) v12(76.79,18.74) v12(78.96,12.95) v12(78.96,11.96) v12(79.59,9.49) v12(79.8,12.59) v12(80.28,12.59) v12(81.5,22.75) v12(81.83,23.08) v12(81.8,22.47) v12(82.13,22.8) v12(82.18,23.44) v12(82.21,22.04) v12(82.51,23.77) v12(82.49,23.16) v12(82.54,22.37) v12(82.84,24.1) v12(82.82,23.49) v12(82.89,22.73) v12(83.15,24.4) v12(83.15,23.82) v12(83.22,23.06) v12(83.45,24.12) v12(83.55,23.39) v12(83.78,25.09) v12(83.86,23.69) v12(84.11,25.42) v12(84.09,24.81) v12(84.42,25.14) v12(84.47,25.77) v12(84.49,24.38) v12(84.8,26.1) v12(84.77,25.49) v12(84.82,24.71) v12(84.8,18.48) v12(84.88,17.24) v12(84.9,15.97) v12(84.96,19.13) v12(84.96,17.86) v12(84.96,16.59) v12(85.13,26.43) v12(85.1,25.82) v12(85.18,25.06) v12(85.18,18.48) v12(85.31,17.24) v12(85.33,15.97) v12(85.43,26.74) v12(85.43,26.15) v12(85.51,25.39) v12(85.56,16.83) v12(85.74,26.46) v12(85.69,17.24) v12(85.71,15.97) v12(85.84,25.72) v12(86.15,34.13) v12(86.15,33.72) v12(86.15,26.03) v12(86.16,33.28) v12(86.16,32.8) v12(86.16,32.39) v12(86.16,31.95) v12(86.68,34.13) v12(86.68,33.72) v12(86.68,33.28) v12(86.68,32.8) v12(86.68,32.39) v12(86.69,31.95) v12(87.23,34.13) v12(87.23,33.72) v12(87.24,33.28) v12(87.24,32.8) v12(87.24,32.39) v12(87.24,31.95) v12(87.63,47.59) v12(87.63,47.18) v12(87.64,46.75) v12(87.64,46.26) v12(87.64,45.85) v12(87.65,45.42) v12(87.98,47.59) v12(87.98,47.18) v12(87.99,46.75) v12(87.99,46.26) v12(87.99,45.85) v12(87.99,45.42) v12(87.97,41.09) v12(87.97,40.84) v12(87.97,40.58) v12(87.97,40.33) v12(87.97,40.07) v12(87.97,39.31) v12(87.97,39.06) v12(87.97,38.8) v12(87.97,38.55) v12(87.97,38.3) v12(88.23,41.09) v12(88.23,40.84) v12(88.23,40.58) v12(88.23,40.33) v12(88.23,40.07) v12(88.23,39.31) v12(88.23,39.06) v12(88.23,38.8) v12(88.23,38.55) v12(88.23,38.3) v12(88.3,47.59) v12(88.3,47.18) v12(88.31,46.75) v12(88.31,46.26) v12(88.31,45.85) v12(88.32,45.42) v12(88.43,61.94) v12(88.85,67.16) v12(88.99,41.09) v12(88.99,40.84) v12(88.99,40.58) v12(88.99,40.33) v12(88.99,40.07) v12(88.99,39.31) v12(88.99,39.06) v12(88.99,38.8) v12(88.99,38.55) v12(88.99,38.3) v12(89.19,75.11) v12(89.63,41.09) v12(89.63,40.84) v12(89.63,40.58) v12(89.63,40.33) v12(89.63,40.07) v12(89.63,39.31) v12(89.63,39.06) v12(89.63,38.8) v12(89.63,38.55) v12(89.63,38.3) v12(89.8,75.13) v12(90.26,41.09) v12(90.26,40.84) v12(90.26,40.58) v12(90.26,40.33) v12(90.26,40.07) v12(90.26,39.31) v12(90.26,39.06) v12(90.26,38.8) v12(90.26,38.55) v12(90.26,38.3) v12(90.45,68.46) v12(90.49,74.59) v12(92,66.67) v12(92.27,43.17) v12(92.54,17.32) v12(92.57,32.88) v12(92.59,19.73) v12(92.58,19.2) v12(92.57,18.59) v12(92.58,17.93) v12(92.58,16.66) v12(92.67,61.33) v12(92.68,42.94) v12(92.68,16.16) v12(93,32.65) v12(93.04,18.6) v12(93.05,17.31) v12(93.07,19.72) v12(93.13,16.14) v12(93.44,59.33) v12(93.49,64.2) v12(93.49,63.31) v12(93.49,62.23) v12(93.49,61.35) v12(93.49,60.5) v12(94.12,2.94) v12(94.12,2.68) v12(94.12,2.43) v12(94.19,53.89) v12(94.19,53.36) v12(94.19,52.81) v12(94.35,68.46) v12(94.5,2.94) v12(94.5,2.68) v12(94.5,2.43) v12(94.59,53.89) v12(94.59,53.36) v12(94.59,52.81) v12(94.98,65.7) v12(95.08,53.89) v12(95.08,53.36) v12(95.08,52.81) v12(95.21,28.01) v12(95.53,56.29) v12(95.52,53.89) v12(95.52,53.37) v12(95.52,52.82) v12(95.93,53.89) v12(95.93,53.37) v12(95.93,52.82) v12(96,28.82) v12(96,28.47) v12(96.31,28.64) v12(96.48,53.92) v12(96.48,53.28) v12(96.48,52.77) v12(96.61,28.82) v12(96.61,28.47) v12(96.81,69.44) v12(96.86,10.23) v12(96.86,9.85) v12(96.86,9.47) v12(96.86,9.09) v12(96.86,8.7) v12(96.97,53.88) v12(96.97,53.35) v12(96.97,52.8) v12(97.25,10.23) v12(97.25,9.85) v12(97.25,9.47) v12(97.25,9.09) v12(97.25,8.7) v12(97.25,8.32) v12(97.27,28.82) v12(97.27,28.47) v12(97.41,53.89) v12(97.41,53.36) v12(97.41,52.81) v12(97.58,28.64) v12(97.63,10.61) v12(97.63,10.1) v12(97.63,9.85) v12(97.63,9.59) v12(97.63,8.83) v12(97.63,8.58) v12(97.63,8.32) v12(97.82,53.89) v12(97.82,53.36) v12(97.82,52.81) v12(97.88,28.82) v12(97.88,28.47) v12(98.01,12.92) v12(98.01,12.45) v12(98.02,12.05) v12(98.01,11.61) v12(98.01,11.15) v12(98.01,10.61) v12(98.01,10.1) v12(98.01,9.85) v12(98.01,9.59) v12(98.01,8.83) v12(98.01,8.58) v12(98.01,8.32) v12(98.3,53.89) v12(98.3,53.36) v12(98.3,52.81) v12(98.74,53.89) v12(98.74,53.37) v12(98.74,52.82) v12(99.02,71.81) v12(99.15,53.89) v12(99.15,53.37) v12(99.15,52.82) v12(99.19,72.38) v12(99.61,71.79) v12(99.68,64.99) v12(99.86,22.47) v12(99.86,22.12) v12(100.2,53.88) v12(100.2,53.35) v12(100.2,52.8) v12(100.17,22.29) v12(100.5,71.76) v12(100.47,22.47) v12(100.47,22.12) v12(100.64,53.89) v12(100.64,53.36) v12(100.64,52.81) v12(100.98,74.16) v12(101.05,53.89) v12(101.05,53.36) v12(101.05,52.81) v12(101.13,22.47) v12(101.13,22.12) v12(101.28,66.91) v12(101.31,13.43) v12(101.44,22.29) v12(101.53,53.89) v12(101.53,53.36) v12(101.53,52.81) v12(101.51,9.85) v12(101.51,9.59) v12(101.51,8.83) v12(101.51,8.58) v12(101.74,22.47) v12(101.74,22.12) v12(101.97,53.89) v12(101.97,53.37) v12(101.97,52.82) v12(102.22,11.63) v12(102.38,53.89) v12(102.38,53.37) v12(102.38,52.82) v12(103.16,63.06) v12(103.16,62.17) v12(103.16,61.28) v12(103.16,60.39) v12(103.36,49.65) v12(103.36,49.24) v12(103.37,48.8) v12(103.37,48.32) v12(103.37,47.91) v12(103.38,47.47) v12(103.79,67.56) v12(103.88,71.37) v12(103.89,49.65) v12(103.89,49.24) v12(103.9,48.8) v12(103.9,48.32) v12(103.9,47.91) v12(103.9,47.47) v12(103.98,65.3) v12(104.44,49.65) v12(104.44,49.24) v12(104.45,48.8) v12(104.45,48.32) v12(104.45,47.91) v12(104.46,47.47) v12(105.12,63.55) v12(105.07,60.28) v12(105.51,54.64) v12(105.51,54.12) v12(105.51,53.56) v12(105.95,54.65) v12(105.95,54.12) v12(105.95,53.57) v12(106.11,66.61) v12(106.31,61.36) v12(106.35,54.65) v12(106.35,54.12) v12(106.35,53.57) v12(106.84,54.65) v12(106.84,54.12) v12(106.84,53.57) v12(107.28,54.66) v12(107.28,54.13) v12(107.28,53.58) v12(107.72,68.88) v12(107.69,54.66) v12(107.69,54.13) v12(107.69,53.58) v12(108.09,58.95) v12(108.19,72.51) v12(108.65,57.29) v12(108.75,70.07) v12(108.75,63.7) v12(108.78,54.62) v12(108.78,54.09) v12(108.78,53.54) v12(109.22,54.62) v12(109.22,54.1) v12(109.22,53.55) v12(109.36,29.98) v12(109.36,29.42) v12(109.36,28.9) v12(109.63,54.62) v12(109.63,54.1) v12(109.63,53.55) v12(109.69,59.98) v12(109.79,67.94) v12(109.79,67.28) v12(109.77,29.98) v12(109.77,29.42) v12(109.77,28.9) v12(110.12,54.62) v12(110.12,54.1) v12(110.12,53.55) v12(110.21,29.98) v12(110.21,29.43) v12(110.21,28.9) v12(110.48,2.81) v12(110.48,2.56) v12(110.48,2.3) v12(110.55,54.63) v12(110.55,54.1) v12(110.55,53.55) v12(110.69,29.98) v12(110.69,29.43) v12(110.69,28.91) v12(110.86,2.81) v12(110.86,2.56) v12(110.86,2.3) v12(110.96,54.63) v12(110.96,54.1) v12(110.96,53.55) v12(111.1,29.98) v12(111.1,29.43) v12(111.1,28.9) v12(111.39,71.57) v12(111.39,70.93) v12(111.53,70.27) v12(111.54,29.99) v12(111.54,29.44) v12(111.54,28.91) v12(112.32,59.31) v12(112.35,56.71) v12(112.35,56.18) v12(112.35,55.63) v12(112.79,56.71) v12(112.79,56.19) v12(112.79,55.63) v12(113.2,56.71) v12(113.2,56.19) v12(113.2,55.63) v12(113.37,69.69) v12(113.68,56.71) v12(113.68,56.19) v12(113.68,55.63) v12(114.12,56.72) v12(114.12,56.19) v12(114.12,55.64) v12(114.53,56.72) v12(114.53,56.19) v12(114.53,55.64) v12(114.87,70.6) v12(115.53,67.81) v12(115.66,56.73) v12(115.66,56.2) v12(115.66,55.65) v12(116.1,56.73) v12(116.1,56.21) v12(116.1,55.65) v12(116.51,56.73) v12(116.51,56.21) v12(116.51,55.65) v12(116.65,44.89) v12(116.65,44.53) v12(116.93,44.71) v12(116.99,56.73) v12(116.99,56.21) v12(116.99,55.65) v12(117.23,44.89) v12(117.23,44.53) v12(117.43,56.74) v12(117.43,56.21) v12(117.43,55.66) v12(117.84,56.74) v12(117.84,56.21) v12(117.84,55.66) v12(117.92,44.89) v12(117.92,44.53) v12(118.02,51.76) v12(118.02,51.41) v12(118.2,44.71) v12(118.3,51.59) v12(118.38,58.91) v12(118.5,44.89) v12(118.5,44.53) v12(118.6,51.76) v12(118.6,51.41) v12(118.96,60.73) v12(119.19,44.89) v12(119.19,44.53) v12(119.25,51.75) v12(119.25,51.39) v12(119.53,51.57) v12(119.47,44.71) v12(119.84,51.75) v12(119.84,51.39) v12(119.77,44.89) v12(119.77,44.53) v12(120.35,66.4) v12(122.08,57.92) v12(122.08,50.88) v12(122.08,37.7) v12(122.08,37.05) v12(122.08,35.74) v12(122.41,54.01) v12(122.41,51.53) v12(122.44,42.97) v12(122.41,41.73) v12(122.54,35.28) v12(122.63,58.46) v12(122.73,57.82) v12(122.73,50.88) v12(122.71,35.91) v12(123.06,56.48) v12(123.06,54.01) v12(123.06,52.77) v12(123.06,51.53) v12(123.09,42.97) v12(123.19,35.28) v12(123.38,52.21) v12(123.38,50.88) v12(123.71,52.77) v12(123.84,35.28) v12(124.05,56.48) v12(124.05,54.01) v12(124.03,50.88) v12(123.96,37.8) v12(124.36,40.42) v12(124.36,39.11) v12(124.56,36.34) v12(124.75,55.52) v12(125.1,58.04) v12(125.1,57.06) v12(125.13,35.28) v12(125.3,32.66) v12(125.51,65.31) v12(125.81,37.56) v12(125.81,35.61) v12(125.94,32.66) v12(126.05,56.43) v12(126.05,52.77) v12(126.05,51.86) v12(125.98,50.88) v12(126.38,61.64) v12(126.45,51.33) v12(126.7,66.92) v12(126.7,63.7) v12(126.7,55.52) v12(126.91,51.79) v12(126.95,61.64) v12(127.11,38.96) v12(127.11,36.29) v12(127.17,66.28) v12(127.52,66.9) v12(127.52,63.73) v12(127.58,58.04) v12(127.58,57.06) v12(127.72,32.54) v12(128.4,66.29) v12(128.42,37.56) v12(128.42,35.61) v12(128.57,66.9) v12(128.57,63.73) v12(128.65,55.52) v12(129.45,66.29) v12(129.45,64.33) v12(129.38,57.71) v12(129.62,66.9) v12(129.62,63.73) v12(129.7,37.56) v12(129.7,36.29) v12(129.85,38.31) v12(130.05,58.04) v12(130.05,57.06) v12(130.33,32.83) v12(130.5,66.29) v12(130.5,64.33) v12(130.67,66.9) v12(130.67,63.73) v12(130.95,37.56) v12(130.95,35.61) v12(131.55,66.29) v12(131.55,64.34) v12(131.72,66.9) v12(131.72,63.73) v12(131.68,38.31) v12(132.2,37.56) v12(132.2,36.29) v12(132.53,58.04) v12(132.53,57.06) v12(132.6,66.29) v12(132.6,64.34) v12(132.59,56.34) v12(132.77,66.9) v12(132.77,63.72) v12(132.85,32.83) v12(133.45,35.61) v12(133.82,66.9) v12(133.82,63.73) v12(134.42,56.34) v12(134.7,36.29) v12(134.87,66.9) v12(134.87,63.72) v12(135,58.69) v12(135,58.04) v12(135,57.06) v12(135.34,55.04) v12(135.34,54.11) v12(135.53,61.61) v12(135.53,61.35) v12(135.53,61.1) v12(135.69,66.92) v12(135.69,63.7) v12(135.74,58.37) v12(135.8,41.37) v12(135.96,37.56) v12(135.96,35.61) v12(136.25,57.64) v12(136.3,32.83) v12(136.39,58.37) v12(136.88,65.06) v12(137.04,58.37) v12(137.21,36.29) v12(137.73,61.65) v12(137.69,58.37) v12(138.04,32.83) v12(138.34,58.37) v12(138.39,61.65) v12(138.46,37.56) v12(138.46,35.61) v12(138.99,59.02) v12(138.99,58.37) v12(139,57.64) v12(139.71,37.56) v12(139.71,36.29) v12(139.94,63.31) v12(139.91,57.64) v12(139.91,56.99) v12(139.91,56.34) v12(140.32,32.83) v12(140.37,41.37) v12(140.83,57.64) v12(140.98,62.55) v12(140.96,35.61) v12(141.74,57.64) v12(142.24,59.02) v12(142.24,58.37) v12(142.21,37.56) v12(142.21,36.29) v12(142.5,32.83) v12(142.87,66.64) v12(143.46,37.56) v12(143.46,35.61) v12(143.57,56.34) v12(143.58,38.96) v12(143.72,32.45) v12(144.19,59.02) v12(144.19,58.37) v12(144.71,36.29) v12(145.2,32.83) v12(145.4,57.64) v12(145.96,35.61) v12(146.14,59.02) v12(146.14,58.37) v12(146.26,62.46) v12(146.32,57.64) v12(146.32,39.61) v12(146.32,38.31) v12(146.26,32.66) v12(146.45,65.7) v12(146.89,32.66) v12(147.15,62.61) v12(147.23,57.64) v12(147.23,56.99) v12(147.23,56.34) v12(147.21,36.29) v12(148.09,59.02) v12(148.09,58.37) v12(148.15,57.64) v12(148.29,62.24) v12(148.47,35.61) v12(149.06,57.64) v12(149.18,62.24) v12(149.72,37.56) v12(149.72,36.29) v12(150.04,59.02) v12(150.04,58.37) v12(149.98,57.64) v12(150.16,62.42) v12(150.16,61.78) v12(150.44,41.37) v12(150.89,57.64) v12(150.89,56.99) v12(150.89,56.34) v12(150.97,37.56) v12(150.97,35.61) v12(151.81,57.64) v12(151.81,38.31) v12(151.88,64.68) v12(152.01,62.42) v12(152.01,61.78) v12(152.01,61.15) v12(152.22,36.29) v12(152.27,41.37) v12(152.6,58.04) v12(152.67,62.32) v12(152.7,61.66) v12(152.7,61.07) v12(152.93,64.74) v12(153.47,37.56) v12(153.47,35.61) v12(154.56,38.31) v12(154.72,37.56) v12(154.72,36.29) v12(155.07,58.04) v12(155.07,57.06) v12(155.97,37.56) v12(155.97,35.61) v12(157.2,66.93) v12(157.2,63.69) v12(157.22,37.56) v12(157.22,36.29) v12(157.55,41.56) v12(157.65,31.84) v12(157.67,66.29) v12(158.02,66.9) v12(158.02,63.72) v12(158.2,66.29) v12(158.47,43.78) v12(158.47,37.56) v12(158.47,35.61) v12(159.07,66.9) v12(159.07,63.72) v12(159.25,66.29) v12(159.38,38.96) v12(159.72,37.56) v12(159.72,36.29) v12(159.72,35.64) v12(159.87,32.54) v12(160.02,58.04) v12(160.02,57.06) v12(160.12,66.9) v12(160.12,63.72) v12(160.3,42.86) v12(160.51,32.54) v12(160.98,37.56) v12(161.17,66.9) v12(161.17,63.72) v12(161.21,39.61) v12(161.42,54.58) v12(162.13,40.91) v12(162.22,63.72) v12(162.23,37.56) v12(162.23,36.29) v12(162.23,35.64) v12(162.4,66.29) v12(162.85,35.28) v12(162.93,2.81) v12(162.93,2.56) v12(162.93,2.3) v12(163.04,41.56) v12(163.04,38.96) v12(163.01,30.46) v12(163.27,66.9) v12(163.31,32.61) v12(163.31,2.81) v12(163.31,2.56) v12(163.31,2.3) v12(163.45,66.29) v12(163.45,64.34) v12(163.48,51.8) v12(163.48,50.97) v12(163.48,50.14) v12(163.48,45.16) v12(163.48,37.56) v12(163.7,56.34) v12(163.7,54.39) v12(163.89,32.61) v12(163.96,42.21) v12(163.96,40.26) v12(164.13,45.99) v12(164.32,66.9) v12(164.5,66.29) v12(164.62,56.34) v12(164.74,36.29) v12(164.78,51.8) v12(164.78,48.48) v12(165.32,37.24) v12(165.37,66.9) v12(165.43,49.08) v12(165.43,41.76) v12(165.72,66.29) v12(166.08,56.4) v12(166.08,55.48) v12(166.19,66.93) v12(166.63,36.59) v12(166.73,54.57) v12(166.73,52.74) v12(167.19,36.26) v12(167.38,51.82) v12(167.38,49.99) v12(167.38,47.25) v12(167.38,41.76) v12(167.38,39.01) v12(168.4,35.28) v12(168.89,57.74) v12(168.86,56.46) v12(168.86,51.89) v12(168.86,49.27) v12(168.86,46.65) v12(168.86,44.03) v12(168.86,41.41) v12(168.86,38.79) v12(169.05,59.02) v12(169.05,35.28) v12(169.38,28.86) v12(169.54,58.39) v12(169.54,35.91) v12(169.56,32.23) v12(169.56,30.38) v12(169.7,59.02) v12(169.7,35.28) v12(169.84,46.65) v12(169.84,44.03) v12(169.84,41.41) v12(170.19,58.39) v12(170.16,55.17) v12(170.19,35.91) v12(170.2,30.38) v12(170.27,32.23) v12(170.35,59.02) v12(170.35,35.28) v12(170.49,46.65) v12(170.81,58.56) v12(170.81,38.12) v12(170.81,35.74) v12(170.85,32.23) v12(170.77,30.38) v12(170.83,29.41) v12(171.34,30.38) v12(171.42,32.23) v12(171.91,30.38) v12(171.99,32.23) v12(172.55,66.4) v12(172.48,30.38) v12(172.56,32.23) v12(172.68,28.99) v12(172.81,41.98) v12(172.89,44.6) v12(173.13,32.23) v12(173.37,41.98) v12(173.47,46.83) v12(173.46,44.6) v12(173.7,30.98) v12(173.75,43.56) v12(174.03,53.97) v12(174.33,30.98) v12(174.66,38.4) v12(174.8,43.62) v12(175.6,52.19) v12(175.95,51.25) v12(176.06,43.39) v12(176.07,41.62) v12(176.68,46.54) v12(176.68,46.04) v12(176.8,46.29) v12(176.93,46.54) v12(176.93,46.04) v12(178.02,29.89) v12(178.52,44.85) v12(178.78,52.14) v12(178.82,41.71) v12(178.78,30.5) v12(179.74,47.44) v12(179.74,43.88) v12(180.18,51.12) v12(180.3,42.72) v12(180.3,40.71) v12(180.68,58.56) v12(180.7,50.14) v12(180.66,29.91) v12(180.82,46.58) v12(180.91,58.34) v12(180.99,43.22) v12(181.12,58.08) v12(181.32,57.85) v12(181.4,56.2) v12(181.62,55.45) v12(182.03,57.98) v12(182.03,56.1) v12(182.06,55.44) v12(182.22,54.86) v12(182.21,29.71) v12(182.26,57.78) v12(182.43,56.29) v12(182.42,32.89) v12(182.46,45.97) v12(182.63,55.31) v12(182.57,54.51) v12(182.75,55.98) v12(182.88,69.76) v12(182.88,54.21) v12(183.04,55.69) v12(182.97,54.97) v12(183.1,45.97) v12(183.17,53.92) v12(183.32,68.86) v12(183.29,54.67) v12(183.38,55.35) v12(183.45,42.82) v12(183.64,68.56) v12(183.58,54.38) v12(183.71,69.25) v12(183.69,55.05) v12(183.93,68.27) v12(183.86,53.24) v12(184.01,69.62) v12(184.03,68.95) v12(183.96,67.44) v12(183.98,54.76) v12(184.06,47.63) v12(184.24,53.67) v12(184.17,52.93) v12(184.32,69.29) v12(184.32,68.66) v12(184.27,67.92) v12(184.28,67.14) v12(184.55,53.37) v12(184.46,52.65) v12(184.58,67.62) v12(184.64,54.13) v12(184.66,68.98) v12(184.66,68.31) v12(184.84,53.08) v12(184.8,52.3) v12(184.9,67.28) v12(185.03,68.71) v12(184.97,68.01) v12(184.96,53.82) v12(185.01,43.49) v12(185.12,52) v12(185.25,53.53) v12(185.18,52.74) v12(185.32,68.36) v12(185.26,67.72) v12(185.41,51.71) v12(185.45,36.87) v12(185.5,52.43) v12(185.54,46.47) v12(185.63,68.07) v12(185.59,53.19) v12(185.79,52.14) v12(185.9,52.89) v12(186.14,50.93) v12(186.19,52.6) v12(186.21,37.33) v12(186.27,46.12) v12(186.32,44.29) v12(186.32,39.19) v12(186.52,51.41) v12(186.46,50.62) v12(186.75,50.33) v12(186.84,51.11) v12(186.78,37.33) v12(186.9,51.87) v12(187.13,50.82) v12(187.09,49.99) v12(187.22,51.56) v12(187.4,49.69) v12(187.51,51.27) v12(187.47,50.47) v12(187.52,6.77) v12(187.69,49.4) v12(187.85,50.93) v12(187.78,50.17) v12(188.05,6.8) v12(188.07,49.88) v12(188.16,50.63) v12(188.45,50.34) v12(188.53,6.8) v12(188.83,26.4) v12(188.83,25.9) v12(188.83,25.4) v12(188.83,21.9) v12(188.83,20.4) v12(188.83,18.9) v12(188.83,17.4) v12(188.83,15.9) v12(188.83,14.4) v12(188.83,12.9) v12(188.83,11.4) v12(188.83,9.9) v12(188.83,8.4) v12(188.83,7.9) v12(188.89,71.97) v12(189.08,49) v12(189.12,46.04) v12(190.11,39.99) v12(190.39,2.96) v12(190.39,2.71) v12(190.39,2.46) v12(190.77,2.96) v12(190.77,2.71) v12(190.77,2.46) v12(191.31,29.67) v12(191.68,29.67) v12(191.91,38.55) v12(192.27,45.78) v12(192.34,43.2) v12(192.62,41.11) v12(192.67,48.1) v12(192.67,47.41) v12(192.67,46.78) v12(193.1,71.36) v12(193.13,46.78) v12(193.12,25.53) v12(193.36,48.1) v12(193.46,20.85) v12(193.62,68.81) v12(193.66,31.03) v12(193.74,6.11) v12(193.87,71.11) v12(193.9,69.09) v12(194.02,69.74) v12(194.13,37.55) v12(194.12,20.85) v12(194.2,70.68) v12(194.18,69.37) v12(194.27,29.06) v12(194.43,23.64) v12(194.46,69.65) v12(194.6,70.05) v12(194.76,70.91) v12(194.91,71.37) v12(195.02,67.39) v12(195.24,38.73) v12(195.23,38.3) v12(195.21,37.86) v12(195.3,67.67) v12(195.53,67.89) v12(195.54,29.06) v12(195.54,25.76) v12(195.62,71.72) v12(195.78,72.18) v12(195.79,68.15) v12(195.9,23.03) v12(195.91,4.2) v12(196.18,67.76) v12(196.16,36.53) v12(196.16,30.03) v12(196.31,68.14) v12(196.28,21.73) v12(196.27,10.71) v12(196.56,67.76) v12(196.56,67.38) v12(196.69,68.14) v12(196.71,22.57) v12(196.94,67.76) v12(196.94,67.38) v12(197.17,68.32) v12(197.19,5.11) v12(197.32,67.63) v12(197.28,2.62) v12(197.37,68.55) v12(197.42,68.09) v12(197.58,68.75) v12(197.65,68.29) v12(197.85,68.5) v12(198.06,39.18) v12(198.4,46.97) v12(198.4,45.75) v12(198.43,24.33) v12(198.55,46.54) v12(198.55,45.32) v12(198.64,21.58) v12(199.66,46.55) v12(199.82,47.31) v12(199.84,45.26) v12(200.31,60.9) v12(200.37,41.42) v12(200.37,40.89) v12(200.56,60.64) v12(200.59,48.71) v12(200.61,7.01) v12(200.66,61.25) v12(200.83,28.34) v12(200.91,61) v12(201.01,61.6) v12(201.21,28.14) v12(201.27,61.35) v12(201.32,19.39) v12(201.38,65.23) v12(201.41,27.91) v12(201.39,27.2) v12(201.39,26.94) v12(201.39,26.66) v12(201.63,62.34) v12(201.64,27.68) v12(201.76,74.39) v12(201.75,73.9) v12(201.76,73.46) v12(201.86,62.08) v12(201.89,21.35) v12(201.99,26.03) v12(202.11,61.88) v12(202.12,45.67) v12(202.12,27.3) v12(202.2,74.39) v12(202.19,73.9) v12(202.2,73.46) v12(202.35,27.09) v12(202.38,62.41) v12(202.5,62.79) v12(202.51,15.16) v12(202.65,74.39) v12(202.64,73.91) v12(202.65,73.47) v12(202.58,26.89) v12(203.01,16.65) v12(203.11,74.39) v12(203.11,73.91) v12(203.12,73.47) v12(203.14,26.23) v12(203.25,63.32) v12(203.21,25.62) v12(203.54,74.39) v12(203.54,73.9) v12(203.55,73.46) v12(203.47,20.52) v12(203.59,16.65) v12(203.75,23.92) v12(203.91,46.67) v12(203.91,46.17) v12(203.91,45.67) v12(203.98,74.4) v12(203.97,73.91) v12(203.98,73.47) v12(204.06,23.92) v12(204.17,48.58) v12(204.31,46.67) v12(204.32,46.17) v12(204.32,45.67) v12(204.35,48.13) v12(204.36,23.92) v12(204.71,10.06) v12(204.85,45.57) v12(204.85,46.57) v12(204.85,46.08) v12(205,38.99) v12(205,37.72) v12(205.2,39.31) v12(205.2,38.04) v12(205.27,22.32) v12(205.39,39.63) v12(205.39,38.36) v12(205.53,22.04) v12(205.6,22.39) v12(205.65,37) v12(205.7,35.63) v12(205.7,22.73) v12(205.82,36.45) v12(205.8,35.35) v12(205.89,34.99) v12(206.01,36.77) v12(205.96,22.47) v12(206.59,34.8) v12(206.69,34.46) v12(206.78,34.1) v12(207.1,33.53) v12(207.29,32.83) v12(207.74,32.26) v12(207.67,11.28) v12(207.83,31.92) v12(207.93,31.56) v12(208.24,11.28) v12(208.31,7.01) v12(208.51,30.81) v12(209.01,11.32) v12(209.42,16.43) v12(209.72,8.78) v12(210.16,7.49) v12(210.38,6.39) v12(210.4,3.33) v12(210.91,6.39) v12(211.04,3.59) v12(211.39,6.39) v12(211.6,17.04) v12(211.62,3.59) v12(211.77,18.79) v12(212.26,17.19) v12(212.26,16.86) v12(212.56,17.02) v12(212.87,17.19) v12(212.87,16.86) v12(213.4,17.19) v12(213.42,16.76) v12(213.83,16.05) v12(213.91,17.19) v12(213.86,16.65) v12(214.02,16.35) v12(214.21,16.65) v12(214.19,16.05) v12(214.39,17.19) v12(214.45,8.51) v12(214.64,16.91) v12(215.08,18.79) v12(215.08,18.34) v12(215.09,17.95) v12(215.09,17.49) v12(215.15,8.23) v12(216.35,8.23) v12(216.65,10.95) v12(216.95,8.23) v12(217.23,16.43) v12(217.23,15.49) v12(218.05,13.45) v12(218.56,16.5) v12(219.24,15.61) v12(220.55,8.23) v12(220.85,18.36) v12(220.85,11.11) v12(221.2,16.16) v12(222.05,11.11) v12(222.35,8.23) v12(222.65,11.11) v12(223.38,18.33) v12(223.39,17.91) v12(223.39,17.47) v12(224.49,18.66) v12(226.47,16.38) v12(226.61,13.91) v12(226.94,13.15) v12(226.99,18.1) v12(227.72,15.36) v12(228.77,17.33) v12(229.05,8.51) v12(229.27,13.15) v12(229.6,14.32) v12(229.78,17.54) v12(230.85,11.85) v12(235.15,7.98) v12(235.45,3.07) v12(235.45,2.81) v12(235.45,2.56) v12(235.83,3.07) v12(235.83,2.81) v12(235.83,2.56) v12(236.45,11.85) v12(237.61,16.28) v12(241.42,11.99) v12(243.04,9.49) v12(243.04,6.84) v12(243.11,13.78) v12(244.11,16.28) v12(245.48,19.09) v12(245.5,16.07) v12(245.54,14.65) v12(245.53,13.84) v12(247.31,2.3) v12(247.44,17.6) v12(247.56,8.96) v12(248.13,22.7) v12(248.17,6.76) v12(248.78,6.76) v12(249.42,19.09) v12(249.42,16.1) v12(249.39,6.76) v12(251.61,19.01) v12(251.61,17.51) v12(251.61,16.01) v12(251.61,14.51) v12(251.61,9.01) v12(251.71,20.76) v12(251.71,5.76) v12(252.46,5.66) v12(252.96,5.66) v12(253.3,55.57) v12(253.36,14.51) v12(253.36,10.51) v12(253.46,5.66) v12(253.61,20.16) v12(253.96,20.86) v12(253.96,5.66) v12(254.11,60.9) v12(254.34,56.89) v12(254.29,19.39) v12(254.29,18.12) v12(254.29,16.85) v12(254.29,16.11) v12(254.29,14.84) v12(254.29,13.57) v12(254.3,12.89) v12(254.3,11.62) v12(254.3,10.35) v12(254.3,9.56) v12(254.3,8.29) v12(254.3,7.02) v12(254.37,54.21) v12(254.46,5.66) v12(254.6,50.11) v12(254.96,5.66) v12(255.44,41.67) v12(255.46,20.86) v12(255.46,5.66) v12(255.56,19.39) v12(255.56,18.12) v12(255.56,16.85) v12(255.56,16.11) v12(255.56,14.84) v12(255.56,13.57) v12(255.57,12.89) v12(255.57,11.62) v12(255.57,10.35) v12(255.57,9.56) v12(255.57,8.3) v12(255.57,7.02) v12(255.69,39.84) v12(255.94,60.01) v12(255.87,50.16) v12(255.96,5.66) v12(256.46,5.66) v12(256.83,19.39) v12(256.83,18.12) v12(256.83,16.85) v12(256.83,16.11) v12(256.83,14.84) v12(256.83,13.57) v12(256.84,12.89) v12(256.84,11.62) v12(256.84,10.35) v12(256.84,9.56) v12(256.84,8.29) v12(256.84,7.02) v12(256.95,38.44) v12(256.96,20.86) v12(256.96,5.66) v12(257.27,58.21) v12(257.27,56.94) v12(257.27,55.67) v12(257.27,54.4) v12(257.27,53.13) v12(257.27,51.86) v12(257.27,50.59) v12(257.27,49.32) v12(257.27,48.05) v12(257.27,46.78) v12(257.27,45.51) v12(257.27,44.59) v12(257.46,5.66) v12(257.59,19.43) v12(257.59,18.16) v12(257.59,16.89) v12(257.58,16.06) v12(257.58,14.79) v12(257.58,13.52) v12(257.6,12.86) v12(257.6,11.59) v12(257.6,10.32) v12(257.6,9.58) v12(257.6,8.31) v12(257.6,7.04) v12(257.96,5.66) v12(258.54,58.21) v12(258.54,44.59) v12(258.46,20.86) v12(258.46,5.66) v12(258.85,16.06) v12(258.84,14.79) v12(258.85,13.52) v12(258.86,19.43) v12(258.86,18.16) v12(258.86,16.89) v12(258.87,12.86) v12(258.87,11.6) v12(258.87,10.32) v12(258.87,9.58) v12(258.87,8.32) v12(258.87,7.04) v12(258.96,5.66) v12(259.32,42.28) v12(259.42,62.22) v12(259.46,5.66) v12(259.81,58.21) v12(259.77,51.46) v12(259.81,44.59) v12(259.8,41.44) v12(259.8,35.94) v12(259.91,23.84) v12(259.91,23.26) v12(259.98,27.58) v12(259.98,26.99) v12(259.96,26.36) v12(259.96,25.77) v12(259.98,25.11) v12(259.98,24.53) v12(259.96,5.66) v12(260.06,62.22) v12(260.14,27.27) v12(260.11,26.05) v12(260.14,24.81) v12(260.06,23.54) v12(260.13,19.43) v12(260.13,18.16) v12(260.13,16.89) v12(260.12,16.06) v12(260.12,14.79) v12(260.12,13.52) v12(260.14,12.86) v12(260.14,11.59) v12(260.14,10.32) v12(260.14,9.58) v12(260.14,8.31) v12(260.14,7.04) v12(260.24,23.84) v12(260.24,23.26) v12(260.31,27.58) v12(260.31,26.99) v12(260.29,26.36) v12(260.29,25.77) v12(260.31,25.11) v12(260.31,24.53) v12(260.46,5.66) v12(260.69,62.22) v12(260.81,20.16) v12(260.97,46.32) v12(260.96,5.66) v12(261.08,58.21) v12(261.08,44.59) v12(261.06,10.51) v12(261.39,2.73) v12(261.46,5.66) v12(261.96,61.21) v12(261.96,59.94) v12(261.96,5.66) v12(262.35,58.21) v12(262.35,44.59) v12(262.35,22.14) v12(262.35,21.81) v12(262.43,52.22) v12(262.65,21.96) v12(262.71,20.76) v12(262.71,5.76) v12(262.81,13.51) v12(262.81,10.51) v12(262.81,9.01) v12(262.81,7.51) v12(262.81,7.01) v12(262.81,6.51) v12(262.93,22.14) v12(262.93,21.81) v12(263.49,61.41) v12(263.62,58.21) v12(263.62,44.59) v12(263.56,22.75) v12(263.56,22.42) v12(263.87,22.57) v12(263.88,19.8) v12(263.98,42.44) v12(264.15,22.75) v12(264.15,22.42) v12(264.35,16.76) v12(264.35,16.02) v12(264.5,61.41) v12(264.65,16.4) v12(264.89,58.21) v12(264.89,44.59) v12(264.91,16.76) v12(264.91,15.99) v12(264.88,12.15) v12(264.99,5.07) v12(265.39,61.41) v12(265.44,51) v12(265.44,50.54) v12(265.46,42.44) v12(265.6,18.76) v12(266.03,4.13) v12(266.16,58.21) v12(266.16,44.59) v12(266.58,4.15) v12(266.67,53.91) v12(267.07,21.61) v12(267.07,4.16) v12(267.32,53.26) v12(267.32,51.96) v12(267.33,3.05) v12(267.43,58.21) v12(267.43,44.59) v12(267.42,21.65) v12(267.42,21.27) v12(267.42,20.83) v12(267.42,20.38) v12(267.42,19.94) v12(267.46,14.37) v12(267.46,10.42) v12(267.86,21.63) v12(267.86,21.25) v12(267.86,20.82) v12(267.86,20.36) v12(267.86,19.93) v12(268.24,3.37) v12(268.31,19.37) v12(268.49,21.25) v12(268.49,20.82) v12(268.49,20.36) v12(268.47,19.96) v12(268.7,44.59) v12(268.82,33.87) v12(268.82,31.22) v12(268.87,58.21) v12(269.09,69.47) v12(269.1,16.76) v12(269.1,16.17) v12(269.08,15.54) v12(269.08,14.93) v12(269.25,16.45) v12(269.25,15.23) v12(269.43,16.76) v12(269.43,16.17) v12(269.43,15.54) v12(269.43,14.93) v12(269.48,20.22) v12(269.48,19.72) v12(269.48,19.22) v12(269.48,18.72) v12(269.76,20.24) v12(269.76,19.73) v12(269.79,19.22) v12(269.81,18.71) v12(269.89,42.87) v12(269.97,58.21) v12(270.04,54.68) v12(269.97,44.59) v12(270.67,30.4) v12(270.71,19.55) v12(270.71,19.12) v12(270.71,18.62) v12(270.71,18.18) v12(270.71,17.7) v12(271.15,47.74) v12(271.24,58.21) v12(271.24,44.59) v12(272.53,16.58) v12(272.53,15.69) v12(272.75,34.1) v12(272.76,58.21) v12(272.84,51.97) v12(272.76,49.67) v12(272.76,49.12) v12(272.76,47.44) v12(272.76,44.59) v12(273.09,55.97) v12(273.09,54.26) v12(273.09,53.68) v12(273.39,15.33) v12(274.23,15.31) v12(274.28,58.21) v12(274.28,56.94) v12(274.28,55.67) v12(274.28,54.4) v12(274.28,53.13) v12(274.28,51.86) v12(274.28,50.59) v12(274.28,49.32) v12(274.28,48.05) v12(274.28,46.78) v12(274.28,45.51) v12(274.28,44.59) v12(274.31,21.48) v12(274.31,17.21) v12(274.33,7.64) v12(274.33,7.38) v12(274.33,7.13) v12(274.71,7.64) v12(274.71,7.38) v12(274.71,7.13) v12(275.35,58.69) v12(275.35,56.89) v12(275.91,58.69) v12(275.91,56.89) v12(276.57,58.61) v12(276.57,57.09) v12(277.33,44.43) v12(277.33,43.68) v12(278.03,53.26) v12(279.3,53.26) v12(280.22,58.28) v12(280.57,53.26) v12(283.22,68.15) v13(11.62,71.82) v13(12.38,71.85) v13(31.28,67.99) v14(11.44,69.33) v14(13.09,36.29) v14(14.44,36.21) v14(19.67,61.61) v14(19.67,60.34) v14(19.67,59.07) v14(19.67,57.8) v14(19.67,56.53) v14(19.67,55.26) v14(19.67,53.99) v14(19.67,52.72) v14(19.67,51.45) v14(19.67,50.18) v14(19.67,48.91) v14(19.67,47.64) v14(19.67,46.37) v14(19.67,44.62) v14(20.89,61.61) v14(20.89,44.62) v14(21.67,54.49) v14(21.67,54.1) v14(22.16,61.61) v14(22.16,44.62) v14(23.43,61.61) v14(23.43,44.62) v14(24.7,61.61) v14(24.7,44.62) v14(25.97,44.62) v14(26.86,61.61) v14(27.24,44.62) v14(28.01,42.4) v14(28.51,61.61) v14(28.51,44.62) v14(29.78,61.61) v14(29.78,44.62) v14(31.05,61.61) v14(31.05,44.62) v14(31.45,51.03) v14(32.32,61.61) v14(32.32,44.62) v14(33.19,61.61) v14(33.19,60.34) v14(33.19,59.07) v14(33.19,53.99) v14(33.19,52.72) v14(33.19,51.45) v14(33.19,50.18) v14(33.19,48.91) v14(33.19,47.64) v14(33.19,46.37) v14(33.19,45.1) v14(93.67,40.37) v14(93.72,39.74) v14(93.77,41.65) v14(93.78,32.8) v14(93.81,32.4) v14(93.76,32.02) v14(93.81,30.73) v14(93.91,43.72) v14(93.91,43.38) v14(93.94,42.92) v14(93.95,42.52) v14(93.95,42.13) v14(93.89,40.69) v14(93.94,40.06) v14(93.87,34.06) v14(93.9,33.68) v14(93.9,33.26) v14(94.02,31.05) v14(94.02,30.41) v14(94.15,41.22) v14(94.14,40.38) v14(94.22,41.65) v14(94.19,39.74) v14(94.22,32.01) v14(94.15,31.62) v14(94.33,32.8) v14(94.28,30.73) v14(94.33,30.12) v14(94.36,40.69) v14(94.41,40.06) v14(94.42,34.06) v14(94.45,33.67) v14(94.45,33.26) v14(94.36,32.4) v14(94.46,43.71) v14(94.46,43.38) v14(94.49,42.92) v14(94.5,42.52) v14(94.5,42.12) v14(94.54,31.56) v14(94.49,31.05) v14(94.51,30.45) v14(94.64,41.64) v14(94.55,41.22) v14(94.6,40.37) v14(94.65,39.74) v14(94.67,32) v14(94.73,30.73) v14(94.75,30.13) v14(94.81,40.69) v14(94.84,32.79) v14(94.94,41.21) v14(94.86,40.06) v14(94.93,34.05) v14(94.87,32.4) v14(94.95,31.57) v14(94.95,31.05) v14(94.97,43.71) v14(94.98,43.38) v14(95,42.91) v14(95.01,42.52) v14(95.01,42.12) v14(94.96,33.67) v14(94.96,33.26) v14(94.97,30.44) v14(95.12,41.65) v14(95.08,40.39) v14(95.13,39.75) v14(95.16,32.02) v14(95.22,30.74) v14(95.24,30.14) v14(95.35,41.21) v14(95.3,40.71) v14(95.35,40.07) v14(95.34,31.57) v14(95.43,31.06) v14(95.45,30.46) v14(95.59,41.65) v14(95.63,32.02) v14(95.74,41.2) v14(95.75,31.57) v14(96.05,41.65) v14(96.08,32.02) v14(96.15,31.56) v14(96.16,41.2) v14(96.52,41.65) v14(96.55,41.2) v14(96.54,31.56) v14(96.56,32.02) v14(96.99,41.65) v14(97.03,32.02) v14(103.03,17.15) v14(104.16,19.11) v14(104.16,15.19) v14(106.42,19.11) v14(106.42,15.19) v14(107.55,17.15) v14(111.62,36.32) v14(112.05,63.52) v14(112.75,38.28) v14(112.75,34.37) v14(113.18,65.48) v14(113.18,61.57) v14(115.01,38.28) v14(115.01,34.37) v14(115.44,65.48) v14(115.44,61.57) v14(116.14,36.32) v14(116.57,63.52) v14(121.86,42.64) v14(122.39,41.32) v14(122.73,47.22) v14(123.05,42.13) v14(123.36,39.36) v14(123.36,35.92) v14(123.56,40.43) v14(123.71,42.13) v14(123.66,41.34) v14(123.74,38.73) v14(123.66,37.03) v14(123.76,36.64) v14(123.92,40.68) v14(123.86,40.15) v14(124.36,42.97) v14(124.42,40.96) v14(124.42,39.79) v14(124.45,38.5) v14(125.19,37.71) v14(125.62,37.25) v14(125.98,43.56) v14(126.2,36.87) v14(126.33,37.74) v14(126.91,43.56) v14(127.11,40.26) v14(127.11,39.61) v14(127.11,38.31) v14(127.11,37.56) v14(127.17,37.18) v14(127.34,36.67) v14(128.18,34.82) v14(128.82,36.92) v14(128.77,36.34) v14(128.94,39.61) v14(128.87,34.97) v14(129.3,36.92) v14(129.39,41.37) v14(129.38,35.55) v14(129.85,41.83) v14(129.85,39.61) v14(129.93,37.25) v14(130.31,41.37) v14(130.77,41.83) v14(131.22,41.37) v14(131.68,41.83) v14(131.68,40.91) v14(132.4,36.7) v14(132.6,40.91) v14(132.6,40.26) v14(132.6,39.61) v14(132.6,38.96) v14(132.6,38.31) v14(133.24,37.25) v14(133.51,42.76) v14(133.45,37.56) v14(133.69,37.25) v14(133.85,36.92) v14(133.97,41.37) v14(134.53,37.23) v14(134.7,37.56) v14(134.88,41.37) v14(134.89,38.09) v14(134.94,37.13) v14(134.96,36.72) v14(135.34,40.91) v14(135.34,40.26) v14(135.34,39.61) v14(135.34,38.96) v14(135.34,38.31) v14(136.34,37.61) v14(136.36,36.9) v14(136.71,41.37) v14(137.02,37.23) v14(137.21,37.56) v14(137.2,36.72) v14(137.63,41.37) v14(137.61,36.9) v14(137.83,37.64) v14(138.09,40.91) v14(138.09,40.26) v14(138.09,39.61) v14(138.09,38.96) v14(138.09,38.31) v14(138.7,37.25) v14(139.03,37.64) v14(139.33,36.92) v14(139.36,36.21) v14(140.09,36.9) v14(140.35,37.66) v14(140.83,40.91) v14(140.83,40.26) v14(140.83,39.61) v14(140.83,38.96) v14(140.83,38.31) v14(140.96,37.56) v14(141.36,36.9) v14(141.79,37.62) v14(141.82,35.6) v14(143.04,34.92) v14(143.12,41.37) v14(143.58,40.91) v14(143.58,40.26) v14(143.58,39.61) v14(143.58,38.31) v14(144.44,36.97) v14(144.49,36.59) v14(145.41,39.61) v14(145.38,37.61) v14(145.86,41.37) v14(145.96,37.56) v14(147.21,37.56) v14(148.15,38.31) v14(148.07,36.92) v14(148.47,37.56) v14(148.86,36.9) v14(149.07,40.26) v14(149.07,39.61) v14(149.07,38.96) v14(149.07,38.31) v14(149.11,37.64) v14(150.03,36.85) v14(151.32,35.55) v14(151.35,41.37) v14(151.41,38.35) v14(151.37,36.92) v14(151.81,40.91) v14(151.81,39.61) v14(151.81,38.96) v14(151.8,36.26) v14(152.22,37.56) v14(153.84,39.29) v14(153.89,38.63) v14(155.72,38.96) v14(156.64,38.96) v14(157.55,40.26) v14(159.38,40.26) v14(161.67,43.32) v14(162.13,43.78) v14(162.13,42.21) v14(163.48,49.31) v14(163.48,48.48) v14(163.48,47.65) v14(163.48,46.82) v14(163.48,45.99) v14(163.48,43.5) v14(164.13,48.48) v14(164.13,43.5) v14(165.43,49.99) v14(165.43,46.33) v14(165.43,44.5) v14(165.43,43.59) v14(165.9,45.08) v14(167.07,38.85) v14(167.38,44.5) v14(167.7,37.91) v14(169.84,49.27) v14(170.49,49.27) v14(171.72,66.97) v14(173.39,65.47) v14(173.88,63.67) v14(176.33,63.52) v14(176.79,36.3) v14(177.46,65.48) v14(177.46,61.57) v14(177.92,38.26) v14(177.92,34.34) v14(179.72,65.48) v14(179.72,61.57) v14(180.18,38.26) v14(180.18,34.34) v14(180.85,63.52) v14(181.31,36.3) v14(194.91,12.95) v14(195.26,10.76) v14(195.52,12.34) v14(196.48,8.32) v14(197.22,18.76) v14(197.17,14.27) v14(197.45,12.26) v14(198.03,14.47) v14(198.64,14.29) v14(198.79,15.79) v14(199.63,14.6) v14(199.78,15.97) v14(200.62,14.27) v14(201.36,15.49) v14(202.22,16.1) v14(262.19,49.87) v14(262.51,49.87) v14(263.32,50.59) v14(263.91,50.59) v14(266.41,61.04) v14(267.43,60.77) v14(267.97,53.91) v14(267.97,53.26) v14(267.97,51.96) v14(267.97,51.31) v14(268.31,60.77) v14(280.48,65.64) v14(280.48,64.18) v15(140.17,58.67) v15(148.91,34.64) v15(196.56,16.91) v15(196.74,15.84) v15(267.12,9.52) v15(268.34,7) v16(125.97,34.76) v16(126.38,35.58) v16(128.23,35.81) v16(130.04,35.04) v16(130.7,35.7) v16(132.43,33.85) v16(132.47,36.39) v16(133.16,35.4) v16(138.34,35.91) v16(138.34,35.25) v16(139.41,41.22) v16(140.17,58.67) v16(141.8,36.29) v16(142.2,41.24) v16(142.86,36.95) v16(143.17,35.88) v16(144.39,37.97) v16(144.36,36.29) v16(144.51,40.51) v16(144.51,39.97) v16(144.79,41.37) v16(145.15,36.92) v16(145.48,34.96) v16(146.04,35.91) v16(146.22,36.63) v16(146.65,37.15) v16(146.72,41.42) v16(148.15,39.64) v16(148.2,36.54) v16(148.35,35.91) v16(149.26,36.26) v16(149.47,35.93) v16(150.18,36.26) v16(150.56,36.87) v16(151.19,37.23) v16(196.56,16.91) v16(196.74,15.84) v16(267.12,9.52) v16(268.34,7)

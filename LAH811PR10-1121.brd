# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TAP_SMBCLK: length 17.5
  TOP w0.069: RE535.1 v2(181.88,4.46)
  IN1 w0.061: v2(181.53,20.19) 181.53,20.04 181.4,19.91 181.22,19.91 180.99,19.68 180.99,19.15 181.7,18.43 181.7,15.92 181.35,15.57 181.35,12.1 181.56,11.89 181.56,11.04 181.89,10.71 181.89,7.59 182.07,7.4 182.07,4.66 v2(181.88,4.46)
TAP_SMBCLK_R: length 45.5
  TOP w0.069: v2(182.26,3.42) 182.25,3.41 181.75,3.41 181.29,3.87 RE535.2
  IN1 w0.061: v5(211.71,1.98) 211.49,2.2 211.49,2.96 210.77,3.67 200.08,3.67 199.94,3.52 199.33,3.52 198.82,4.03 196.89,4.03 195.89,3.03 183.46,3.03 183.23,3.26 183.23,3.52 182.87,3.88 182.58,3.88 182.39,3.69 182.39,3.55 v2(182.26,3.42)
  BOTTOM w0.069: JIO1.4 216.05,10.59 215.85,10.39 215.85,10.11 215.59,9.86 214.5,9.86 214.03,9.39 v7(214.03,6.93) 214.03,3.72 212.66,2.34 211.63,2.34 211.55,2.26 211.55,2.15 v5(211.71,1.98)
TAP_SMBDAT: length 17.2
  TOP w0.069: RE534.1 v2(182.44,4.46)
  IN1 w0.061: v2(182.44,4.46) 182.26,4.64 182.26,7.48 182.08,7.66 182.08,10.79 181.75,11.12 181.75,11.97 181.54,12.18 181.54,15.49 181.89,15.84 181.89,18.51 181.17,19.22 181.17,19.6 181.3,19.72 181.46,19.72 181.53,19.64 v2(181.53,19.39)
TAP_SMBDAT_R: length 44.3
  TOP w0.069: v2(182.69,3.45) 182.69,3.55 RE534.2
  IN1 w0.061: v2(182.69,3.45) 182.57,3.56 182.57,3.61 182.66,3.69 182.79,3.69 183.04,3.44 183.04,3.18 183.38,2.84 195.97,2.84 196.97,3.84 198.74,3.84 199.25,3.34 200.02,3.34 200.16,3.48 210.7,3.48 211.3,2.88 211.3,2.15 v5(211.13,1.98)
  BOTTOM w0.069: v5(211.13,1.98) 211.35,2.2 211.35,2.34 211.55,2.54 212.58,2.54 213.84,3.8 v7(213.84,4.62) 213.84,9.47 214.42,10.05 215.51,10.05 215.65,10.19 215.65,10.39 215.45,10.59 JIO1.2
TBT_0_AUXN: length 174.7
  IN1 w0.076: v4(141.74,56.99) 141.56,56.99 arc(141.52,56.98) 141.48,56.96 141.47,56.95 arc(141.45,56.91) 141.44,56.87 141.44,56.65 arc(141.43,56.61) 141.41,56.58 141.4,56.57 arc(141.37,56.55) 141.33,56.54 141.19,56.54 arc(140.81,56.62) 140.48,56.84 139.56,57.75 arc(139.03,58.1) 138.41,58.23 137.16,58.23 arc(136.31,58.4) 135.59,58.88 132.81,61.66 arc(132.38,61.94) 131.88,62.04 128.74,62.04 arc(128.72,62.04) 128.7,62.04 126.96,61.67 arc(126.93,61.66) 126.91,61.65 126.89,61.65 arc(126.73,61.59) 126.57,61.57 122.82,61.57 arc(122.69,61.55) 122.59,61.48 119.45,58.35 arc(118.62,57.79) 117.64,57.6 108.48,57.6 arc(107.67,57.43) 106.98,56.98 103.83,53.82 arc(102.52,52.95) 100.98,52.64 95.96,52.64 95.87,52.6 91.75,48.49 arc(90.95,47.29) 90.67,45.88 90.67,45.62 arc(90.66,45.29) 90.62,44.97 90.59,44.81 90.68,44.29 90.49,43.25 90.68,42.19 90.49,41.11 90.68,40.04 90.45,38.73 90.67,37.44 90.56,36.81 90.44,36.11 90.67,34.78 90.67,34.78 90.48,33.66 90.68,32.48 90.68,30.2 arc(90.5,29.27) 89.97,28.48 76.21,14.72 arc(74.77,13.76) 73.08,13.42 70.19,13.42 arc(69.84,13.35) 69.53,13.15 arc(68.85,12.69) 68.05,12.53 65.48,12.53 64.15,12.3 62.75,12.55 61.38,12.31 60.04,12.54 58.62,12.29 57.92,12.42 57.14,12.55 55.84,12.32 54.93,12.48 54.58,12.54 53.09,12.28 51.78,12.51 49.98,12.51 arc(48.36,12.84) 46.98,13.76 38.59,22.15 arc(38.18,22.43) 37.69,22.52 37.38,22.52 arc(37.1,22.58) 36.86,22.74 36.62,22.98 arc(36.41,23.29) 36.34,23.65 36.34,24.06 36.33,24.07 arc(36.22,24.43) 36,24.74 35.95,24.79 arc(35.26,25.82) 35.02,27.04 35.02,27.89 34.76,29.32 34.95,30.41 34.75,31.54 35.01,32.99 34.75,34.45 34.96,35.64 34.74,36.93 34.74,38.09 arc(34.59,38.82) 34.18,39.44 33.19,40.43 arc(32.87,40.91) 32.75,41.48 arc(32.68,41.85) 32.47,42.16 29.07,45.57 arc(28.88,45.69) 28.67,45.73 28.59,45.73 arc(28.34,45.78) 28.12,45.93 26.01,48.04 arc(25.61,48.64) 25.47,49.35 25.47,50 arc(25.5,50.15) 25.58,50.28 v5(25.66,50.36)
  BOTTOM w0.081: v5(25.66,50.36) 25.54,50.48 arc(25.49,50.56) 25.47,50.65 25.47,50.76 arc(25.49,50.85) 25.54,50.93 RT113.1
TBT_0_AUXN_R: length 7.6
  IN3 w0.076: v4(25.56,56.39) 25.63,56.33 arc(25.68,56.26) 25.69,56.17 25.69,56.17 arc(25.62,55.8) 25.41,55.49 25.41,55.49 arc(25.27,55.39) 25.11,55.36 25.11,55.36 arc(24.85,55.31) 24.62,55.16 24.44,54.97 arc(24.28,54.73) 24.22,54.45 24.22,51.9 arc(24.29,51.53) 24.5,51.23 arc(24.66,51.12) 24.86,51.08 25.16,51.08 arc(25.44,51.19) 25.56,51.48 arc(25.57,51.53) 25.6,51.58 v4(25.66,51.63)
TBT_0_AUXP: length 174.7
  IN1 w0.076: v5(25.08,50.36) 25.16,50.28 arc(25.24,50.15) 25.27,50 25.27,49.35 arc(25.43,48.56) 25.87,47.9 27.98,45.79 arc(28.26,45.6) 28.59,45.53 28.67,45.53 arc(28.81,45.51) 28.93,45.43 32.33,42.02 arc(32.5,41.77) 32.56,41.48 arc(32.68,40.83) 33.05,40.28 34.04,39.3 arc(34.41,38.74) 34.54,38.09 34.54,36.91 34.76,35.64 34.55,34.45 34.81,32.99 34.55,31.54 34.75,30.41 34.56,29.32 34.82,27.87 34.82,27.04 arc(35.07,25.75) 35.81,24.65 35.86,24.6 arc(36.04,24.34) 36.13,24.05 arc(36.14,23.99) 36.14,23.93 36.14,23.65 arc(36.23,23.21) 36.47,22.84 36.72,22.6 arc(37.02,22.4) 37.38,22.32 37.69,22.32 arc(38.1,22.24) 38.45,22.01 46.84,13.61 arc(48.28,12.65) 49.98,12.31 51.76,12.31 53.09,12.08 54.58,12.34 55.84,12.12 57.14,12.35 58.62,12.09 60.04,12.34 60.68,12.23 61.38,12.1 62.75,12.35 64.15,12.1 65.5,12.34 68.05,12.34 arc(68.93,12.51) 69.67,13.01 69.67,13.01 arc(69.91,13.17) 70.19,13.23 73.08,13.23 arc(74.85,13.58) 76.35,14.58 90.11,28.34 arc(90.68,29.2) 90.88,30.2 90.88,32.49 90.68,33.66 90.87,34.78 90.75,35.48 90.64,36.11 90.88,37.44 90.65,38.73 90.88,40.04 90.78,40.61 90.69,41.11 90.88,42.19 90.7,43.25 90.88,44.29 90.79,44.81 90.81,44.93 arc(90.86,45.28) 90.87,45.62 90.87,45.88 arc(91.14,47.21) 91.89,48.35 95.98,52.44 96,52.44 100.98,52.44 arc(102.6,52.77) 103.97,53.68 107.13,56.84 arc(107.75,57.25) 108.48,57.4 117.64,57.4 arc(118.7,57.61) 119.6,58.21 122.73,61.34 arc(122.77,61.37) 122.82,61.38 126.57,61.38 arc(126.78,61.4) 126.97,61.47 126.99,61.47 arc(127,61.48) 127,61.48 128.74,61.85 arc(128.74,61.85) 128.74,61.85 131.88,61.85 arc(132.31,61.76) 132.67,61.52 135.45,58.74 arc(136.24,58.21) 137.16,58.03 138.41,58.03 arc(138.96,57.92) 139.42,57.61 140.34,56.7 arc(140.73,56.43) 141.19,56.34 v4(141.74,56.34)
  BOTTOM w0.081: v5(25.08,50.36) 25.2,50.48 arc(25.25,50.56) 25.27,50.65 25.27,50.76 arc(25.25,50.85) 25.2,50.93 RT112.1
TBT_0_AUXP_R: length 7.6
  IN3 w0.076: v4(26.02,56.39) 25.96,56.33 arc(25.91,56.26) 25.89,56.17 25.89,56.17 arc(25.8,55.72) 25.55,55.35 25.54,55.34 arc(25.34,55.21) 25.11,55.16 arc(24.92,55.12) 24.76,55.02 24.58,54.83 arc(24.46,54.66) 24.42,54.45 24.42,51.89 arc(24.48,51.61) 24.64,51.37 arc(24.74,51.3) 24.86,51.27 25.16,51.27 arc(25.3,51.33) 25.36,51.48 25.36,51.77 arc(25.33,51.85) 25.24,51.88 25.21,51.88 arc(25.12,51.85) 25.08,51.76 v4(25.08,51.63)
TBT_0_LSX_RX: length 201.5
  TOP w0.069: RC691.2 R6172.2 167.79,51.05 167.23,50.49 v3(167.17,50.49)
  IN1 w0.061: v3(36.29,21.63) 36.29,22.04 35.72,22.61 35.72,23.34 35.36,23.7 35.36,24.19 33.99,25.56 33.99,37.75 31.25,40.5 31.25,42.01 28.47,44.78 28.01,44.78 24.37,48.42 24.37,48.5 24.36,48.51 24.36,52.28 23.89,52.75 23.32,52.75 v2(22.82,53.24)
  IN3 w0.061: v3(167.17,50.49) 167.04,50.61 166.37,50.61 v4(166.08,50.91) 164.47,50.91 163.31,52.06 139.21,52.06 138.85,51.71 136.34,51.71 134.53,49.9 126.99,49.9 126.54,50.35 124.37,50.35 123.78,50.94 115.36,50.94 115.26,50.84 101.18,50.84 100.29,49.95 94.22,49.95 90.76,46.49 90.76,28.68 82.33,20.26 81.46,20.26 74.85,13.65 44.68,13.65 36.69,21.63 v3(36.29,21.63)
TBT_0_LSX_RX_R: length 6.9
  TOP w0.069: v3(23.41,53.24) RT2.2 23.95,52.06 v1(24.17,52.06)
  IN3 w0.061: v3(23.41,53.24) 23.76,53.6 23.76,55.69 24.14,56.08 24.41,56.08 v4(24.45,56.12)
  BOTTOM w0.076: v4(24.45,56.12) 24.98,56.12 25.39,55.71 25.73,55.71 25.96,55.93 26.02,55.93 URT1.L7
TBT_0_LSX_TX: length 202.8
  TOP w0.069: v2(22.82,53.88) 22.26,53.32 v1(22.26,51.76)
  IN1 w0.061: v2(22.82,53.88) 22.52,53.57 22.52,52.8 22.98,52.34 23.94,52.34 24.17,52.11 24.17,48.43 24.18,48.42 24.18,48.34 27.93,44.59 28.04,44.59 28.39,44.59 31.06,41.93 31.06,40.4 33.8,37.67 33.8,25.48 35.17,24.11 35.17,23.61 35.53,23.25 35.53,22.29 v3(35.85,21.96)
  IN3 w0.061: v3(35.85,21.96) 35.88,21.99 36.62,21.99 44.77,13.83 74.77,13.83 81.39,20.44 82.25,20.44 90.57,28.76 90.57,46.57 94.15,50.15 100.19,50.15 101.07,51.03 115.18,51.03 115.28,51.13 123.85,51.13 124.44,50.54 126.62,50.54 127.07,50.09 134.45,50.09 136.26,51.89 138.77,51.89 139.13,52.25 163.39,52.25 164.47,51.17 166.47,51.17 v4(166.73,50.91)
TBT_0_LSX_TX_R: length 7.1
  TOP w0.069: v1(23.69,55.54) 23.65,55.5 RT1.2 23.65,54.12 v3(23.41,53.88)
  IN3 w0.061: v4(24.1,56.36) 23.41,55.67 23.41,54.4 23.31,54.3 23,54.3 22.9,54.2 22.9,53.97 22.99,53.88 v3(23.41,53.88)
  BOTTOM w0.076: URT1.M7 25.4,55.93 24.96,56.38 24.53,56.38 24.5,56.41 24.15,56.41 v4(24.1,56.36)
TBT_0_SBU1: length 35.7
  TOP w0.069: v1(10.4,69.36) 10.4,69.07 v2(10.95,68.52) 10.95,67.86 CT206.2 v3(10.85,67.12)
  IN1 w0.061: v2(10.95,68.52) 10.51,68.96 10.51,76.06 v3(9.67,76.9)
  IN3 w0.061: v4(25.24,57.53) 25.72,57.04 26.23,57.04 26.38,57.19 26.38,57.68 26.08,57.97 26.08,58.33 25.64,58.77 25.64,60.61 25.53,60.72 25.53,61.63 23.52,63.63 20.05,63.63 18.02,65.65 13.46,65.65 11.99,67.12 v3(10.85,67.12) ; v4(9.67,77.59) v3(9.67,76.9)
  BOTTOM w0.069: URT1.M10 25.45,57.31 v4(25.24,57.53)
TBT_0_SBU2: length 34.4
  TOP w0.069: v2(10.06,68.52) 10.06,67.86 CT207.2 v3(10.16,67.12) 10.16,66.71 9.79,66.34 v1(9.79,66.18)
  IN1 w0.061: v2(10.06,68.52) 10.35,68.81 10.35,75.79 10.15,75.99 9.01,75.99 v5(8.88,75.86)
  IN3 w0.061: v4(26.02,57.31) 26.02,57.8 25.92,57.9 25.92,58.18 25.47,58.63 25.47,60.54 25.36,60.66 25.36,61.56 23.46,63.47 19.98,63.47 17.96,65.49 13.4,65.49 12.12,66.77 10.52,66.77 v3(10.16,67.12)
  BOTTOM w0.069: v5(8.88,75.86) 8.85,75.84 JUSBC1.B8
TBT_0_TRX_C_RD_DTX_N0: length 2.2
  BOTTOM w0.076: CT4.2 27.66,51.66 arc(27.73,51.76) 27.75,51.88 27.75,52.76 arc(27.74,52.83) 27.7,52.89 27.69,52.9 arc(27.65,52.96) 27.63,53.03 27.63,53.31 arc(27.65,53.4) 27.7,53.47 URT1.G2
TBT_0_TRX_C_RD_DTX_N1: length 2.3
  BOTTOM w0.076: CT8.2 29.35,51.75 arc(29.3,51.82) 29.28,51.91 arc(29.25,52.07) 29.15,52.21 28.9,52.46 arc(28.89,52.48) 28.88,52.51 28.88,52.77 arc(28.9,52.85) 28.94,52.92 28.95,52.93 arc(29,52.99) 29.01,53.07 29.01,53.25 arc(28.98,53.39) 28.9,53.51 URT1.E2
TBT_0_TRX_C_RD_DTX_P0: length 2.2
  BOTTOM w0.076: URT1.G1 27.86,53.25 arc(27.87,53.3) 27.9,53.34 arc(27.98,53.38) 28.06,53.34 arc(28.09,53.31) 28.09,53.26 28.09,53.08 arc(28.08,53) 28.03,52.92 28.02,52.91 arc(27.97,52.84) 27.95,52.75 27.95,51.94 arc(27.96,51.88) 28,51.82 CT3.2
TBT_0_TRX_C_RD_DTX_P1: length 2.3
  BOTTOM w0.076: CT7.2 29.01,51.75 arc(29.06,51.82) 29.08,51.91 arc(29.06,52) 29.01,52.07 28.76,52.32 arc(28.7,52.41) 28.68,52.51 28.68,52.78 arc(28.67,52.85) 28.62,52.92 28.61,52.93 arc(28.57,53) 28.55,53.07 28.55,53.22 arc(28.57,53.3) 28.61,53.36 arc(28.67,53.38) 28.74,53.36 28.74,53.35 arc(28.77,53.31) 28.78,53.25 URT1.E1
TBT_0_TRX_DTX_N0: length 176.2
  IN1 w0.076: v5(27.62,50.36) 27.74,50.24 arc(27.79,50.16) 27.81,50.08 27.81,48.59 arc(27.9,48.13) 28.16,47.74 28.85,47.05 arc(29.01,46.94) 29.2,46.91 arc(29.43,46.86) 29.63,46.73 29.96,46.4 33.56,42.79 arc(33.89,42.31) 34,41.73 arc(34.09,41.29) 34.34,40.92 35.38,39.87 arc(35.75,39.32) 35.88,38.67 35.88,37.07 36.14,35.6 35.93,34.4 36.06,33.65 36.18,32.97 35.93,31.56 36.15,30.32 35.97,29.27 36.21,27.91 36.21,27.15 arc(36.39,26.25) 36.9,25.49 47.77,14.62 arc(48.74,13.97) 49.88,13.74 51.6,13.74 52.99,13.5 54.4,13.75 55.81,13.5 57.21,13.74 58.67,13.48 60.07,13.73 61.32,13.51 62.65,13.74 64.14,13.48 65.47,13.72 67.77,13.72 arc(68.38,13.84) 68.89,14.18 arc(69.36,14.49) 69.92,14.6 73.09,14.6 arc(74.32,14.85) 75.37,15.55 88.88,29.06 arc(89.34,29.75) 89.5,30.57 89.5,32.49 89.3,33.64 89.51,34.82 89.26,36.23 89.49,37.55 89.29,38.73 89.39,39.31 89.5,39.96 89.29,41.14 89.49,42.26 89.32,43.24 89.5,44.28 89.34,45.23 89.48,46.07 arc(89.49,46.09) 89.49,46.11 89.49,48.41 arc(89.6,49) 89.94,49.5 93.09,52.65 arc(94.38,53.51) 95.9,53.81 101.03,53.81 arc(102.06,54.02) 102.94,54.6 106.19,57.86 arc(107.19,58.53) 108.37,58.76 116.75,58.76 arc(118.14,59.04) 119.33,59.83 122.48,62.98 arc(123.21,63.47) 124.07,63.64 126.17,63.64 arc(126.44,63.69) 126.66,63.84 arc(126.82,63.95) 127,63.98 129.49,63.98 arc(129.73,63.93) 129.93,63.8 arc(130.58,63.37) 131.33,63.22 132.01,63.22 arc(133.1,63) 134.02,62.39 134.25,62.16 arc(135.22,61.51) 136.36,61.28 136.53,61.28 arc(137.55,61.08) 138.41,60.5 138.52,60.39 139.21,59.71 arc(139.94,59.22) 140.8,59.05 141.13,59.05 arc(141.63,58.95) 142.05,58.67 142.27,58.45 arc(142.84,58.07) 143.51,57.93 144.36,57.93 arc(144.48,57.96) 144.59,58.03 arc(144.65,58.07) 144.71,58.08 v4(145.17,58.08)
  BOTTOM w0.081: UC1.BH2 145.21,58.08 v4(145.17,58.08) ; v5(27.62,50.36) 27.74,50.48 arc(27.79,50.56) 27.81,50.65 27.81,50.76 arc(27.79,50.85) 27.74,50.93 CT4.1
TBT_0_TRX_DTX_N1: length 174.4
  IN1 w0.076: v4(144.51,59.35) 144.3,59.56 arc(144.24,59.58) 144.18,59.56 144.18,59.55 arc(144.15,59.5) 144.13,59.43 144.13,59.32 arc(144.08,59.19) 143.96,59.14 143.24,59.14 arc(142.85,59.22) 142.52,59.44 arc(141.94,59.83) 141.27,59.96 140.81,59.96 arc(140.24,60.07) 139.77,60.39 139,61.16 138.85,61.31 arc(137.82,62) 136.6,62.24 arc(135.52,62.46) 134.6,63.07 134.58,63.09 arc(133.46,63.84) 132.15,64.1 131.75,64.1 arc(130.95,64.26) 130.26,64.71 130.26,64.71 arc(130.1,64.82) 129.91,64.86 126.33,64.86 126.15,64.83 125.91,64.83 arc(125.74,64.87) 125.59,64.97 125.54,65.02 arc(125.1,65.31) 124.58,65.42 124.49,65.42 arc(123.73,65.27) 123.1,64.84 119.24,60.99 arc(117.75,59.99) 115.98,59.64 108.29,59.64 arc(106.85,59.35) 105.62,58.53 102.77,55.68 arc(101.68,54.95) 100.4,54.7 95.49,54.7 arc(94.01,54.41) 92.76,53.57 89.1,49.91 arc(88.72,49.34) 88.59,48.67 88.59,46.08 arc(88.59,46.08) 88.59,46.08 88.42,45.1 88.58,44.17 88.4,43.16 88.57,42.22 88.38,41.16 88.59,39.98 88.38,38.76 88.59,37.56 88.36,36.26 88.6,34.86 88.39,33.63 88.57,32.61 88.57,30.81 arc(88.43,30.13) 88.05,29.55 74.5,16.01 arc(73.98,15.66) 73.37,15.54 69.61,15.54 arc(68.93,15.41) 68.36,15.02 arc(67.91,14.72) 67.38,14.62 65.2,14.62 64.12,14.43 62.75,14.67 61.35,14.42 60.08,14.65 58.7,14.41 57.98,14.53 57.19,14.67 55.74,14.42 54.4,14.65 53.08,14.42 53.06,14.42 51.74,14.65 51.66,14.65 51.66,14.65 49.93,14.65 arc(49.06,14.82) 48.32,15.32 37.56,26.08 arc(37.21,26.59) 37.09,27.2 37.09,28 36.89,29.14 37.08,30.17 36.83,31.53 36.95,32.21 37.08,32.96 36.84,34.32 37.06,35.58 36.77,37.26 36.77,39.06 arc(36.57,40.07) 35.99,40.92 35.23,41.69 arc(35.05,41.96) 34.98,42.28 34.98,42.28 arc(34.92,42.59) 34.74,42.86 30.02,47.58 arc(29.82,47.72) 29.58,47.76 arc(29.54,47.77) 29.5,47.8 29.3,48 arc(29.28,48.02) 29.28,48.05 29.28,48.51 arc(29.3,48.59) 29.35,48.67 v5(29.47,48.79)
  BOTTOM w0.081: v5(29.47,48.79) 29.35,48.91 arc(29.3,48.99) 29.28,49.08 29.28,50.76 arc(29.3,50.85) 29.35,50.93 CT8.1 ; UC1.BF1 v4(144.51,59.35)
TBT_0_TRX_DTX_P0: length 176.1
  IN1 w0.076: v4(145.21,58.73) 145.2,58.73 arc(145,58.65) 144.92,58.45 144.92,58.37 arc(144.89,58.31) 144.83,58.28 144.71,58.28 arc(144.57,58.25) 144.45,58.17 arc(144.41,58.14) 144.36,58.13 143.51,58.13 arc(142.91,58.25) 142.41,58.59 142.19,58.81 arc(141.71,59.13) 141.13,59.25 140.8,59.25 arc(140.01,59.4) 139.35,59.85 138.72,60.48 138.55,60.64 arc(137.62,61.26) 136.53,61.48 136.36,61.48 arc(135.29,61.69) 134.39,62.3 134.16,62.53 arc(133.17,63.19) 132.01,63.42 131.33,63.42 arc(130.65,63.55) 130.08,63.94 arc(129.81,64.12) 129.49,64.18 127,64.18 arc(126.74,64.13) 126.52,63.98 arc(126.36,63.87) 126.17,63.84 124.07,63.84 arc(123.13,63.65) 122.34,63.12 119.19,59.97 arc(118.07,59.22) 116.75,58.96 108.37,58.96 arc(107.11,58.71) 106.05,58 102.8,54.74 arc(101.99,54.2) 101.03,54.01 95.9,54.01 arc(94.3,53.7) 92.95,52.79 89.8,49.64 arc(89.42,49.08) 89.29,48.41 89.29,46.1 arc(89.29,46.1) 89.29,46.1 89.13,45.23 89.3,44.28 89.12,43.24 89.29,42.26 89.09,41.14 89.3,39.96 89.08,38.73 89.29,37.55 89.18,36.92 89.06,36.23 89.31,34.82 89.1,33.64 89.31,32.47 89.31,30.57 arc(89.16,29.83) 88.74,29.2 75.23,15.69 arc(74.25,15.03) 73.09,14.8 69.92,14.8 arc(69.29,14.68) 68.75,14.32 arc(68.3,14.02) 67.77,13.91 65.46,13.91 64.14,13.68 62.65,13.94 61.32,13.71 60.73,13.82 60.73,13.82 60.07,13.93 58.67,13.69 57.21,13.94 55.81,13.7 54.4,13.95 52.99,13.7 51.62,13.94 49.88,13.94 arc(48.81,14.15) 47.91,14.76 37.04,25.63 arc(36.57,26.33) 36.41,27.15 36.41,27.93 36.17,29.27 36.35,30.32 36.14,31.56 36.38,32.97 36.13,34.4 36.34,35.6 36.08,37.09 36.08,38.67 arc(35.94,39.4) 35.53,40.01 34.48,41.06 arc(34.27,41.36) 34.2,41.73 arc(34.07,42.38) 33.7,42.93 30.1,46.54 29.77,46.87 arc(29.51,47.04) 29.2,47.1 arc(29.09,47.13) 28.99,47.19 28.3,47.88 arc(28.08,48.21) 28,48.59 28,50.07 arc(28.02,50.16) 28.07,50.23 v5(28.2,50.36)
  BOTTOM w0.081: UC1.BH1 v4(145.21,58.73) ; CT3.1 28.08,50.93 arc(28.03,50.85) 28.01,50.76 28.01,50.65 arc(28.03,50.56) 28.08,50.48 v5(28.2,50.36)
TBT_0_TRX_DTX_P1: length 174.4
  IN1 w0.076: v3(144.51,58.69) 144.33,58.88 arc(144.25,58.93) 144.17,58.95 143.24,58.95 arc(142.77,59.04) 142.38,59.3 arc(141.87,59.64) 141.27,59.76 140.81,59.76 arc(140.17,59.89) 139.63,60.25 138.8,61.08 138.71,61.17 arc(137.74,61.82) 136.6,62.04 arc(135.44,62.28) 134.46,62.93 134.44,62.95 arc(133.39,63.65) 132.15,63.9 131.75,63.9 arc(130.87,64.07) 130.12,64.57 130.12,64.57 arc(130.02,64.64) 129.91,64.66 126.34,64.66 126.17,64.64 125.91,64.64 arc(125.66,64.68) 125.45,64.82 125.4,64.88 arc(125.02,65.13) 124.58,65.22 124.49,65.22 arc(123.81,65.08) 123.24,64.7 119.38,60.85 arc(117.82,59.81) 115.98,59.44 108.29,59.44 arc(106.92,59.17) 105.76,58.39 102.91,55.54 arc(101.76,54.77) 100.4,54.5 95.49,54.5 arc(94.09,54.22) 92.9,53.43 89.24,49.77 arc(88.91,49.27) 88.79,48.67 88.79,46.08 arc(88.79,46.06) 88.78,46.04 88.62,45.1 88.78,44.17 88.61,43.16 88.77,42.22 88.58,41.16 88.79,39.98 88.58,38.76 88.79,37.56 88.56,36.26 88.8,34.86 88.59,33.63 88.76,32.63 88.76,30.81 arc(88.61,30.05) 88.19,29.41 74.64,15.87 arc(74.06,15.48) 73.37,15.34 69.61,15.34 arc(69.01,15.22) 68.5,14.88 arc(67.99,14.54) 67.38,14.42 65.21,14.42 64.12,14.23 62.75,14.47 62.08,14.35 61.35,14.22 60.68,14.34 60.68,14.34 60.08,14.45 58.7,14.2 57.19,14.47 55.74,14.22 55.03,14.34 54.4,14.45 53.12,14.23 53.06,14.22 51.74,14.45 51.66,14.45 51.66,14.45 49.93,14.45 arc(48.98,14.64) 48.18,15.18 37.42,25.94 arc(37.03,26.51) 36.89,27.19 36.89,27.99 36.69,29.14 36.87,30.17 36.63,31.53 36.88,32.96 36.88,32.96 36.64,34.32 36.65,34.36 36.86,35.58 36.57,37.24 36.57,39.06 arc(36.38,39.99) 35.85,40.78 35.09,41.55 arc(34.86,41.88) 34.79,42.28 34.79,42.28 arc(34.74,42.52) 34.6,42.72 29.88,47.44 arc(29.74,47.53) 29.58,47.57 29.58,47.57 arc(29.46,47.59) 29.36,47.66 29.16,47.86 arc(29.1,47.95) 29.08,48.05 29.08,48.51 arc(29.06,48.59) 29.01,48.67 v5(28.89,48.79)
  BOTTOM w0.081: CT7.1 29.01,50.93 arc(29.06,50.85) 29.08,50.76 29.08,49.08 arc(29.06,48.99) 29.01,48.91 v5(28.89,48.79) ; UC1.BF2 v4(144.52,58.69)
TBT_0_TRX_RD_DTX_N1: length 29.6
  TOP w0.081: v5(8.88,74.74) 8.98,74.64 arc(9.06,74.59) 9.16,74.57 arc(9.66,74.47) 10.08,74.18 10.09,74.18 arc(10.61,73.39) 10.8,72.47 10.8,70.87 arc(10.81,70.78) 10.87,70.7 D81.1 10.87,70.41 arc(10.81,70.33) 10.8,70.24 10.8,70.19 arc(10.8,70.19) 10.8,70.19 arc(10.81,70.09) 10.85,70 arc(10.87,69.97) 10.9,69.94 10.92,69.92 arc(11.03,69.84) 11.16,69.82 arc(11.7,69.71) 12.16,69.4 13.85,67.71 arc(16.56,65.91) 19.75,65.27 19.75,65.27 arc(23.04,64.62) 25.83,62.75 26.51,62.08 arc(26.85,61.57) 26.97,60.97 26.97,60.67 arc(26.98,60.57) 27.04,60.49 v5(27.16,60.37)
  BOTTOM w0.076: URT1.J11 27.1,57.94 arc(27.15,58.01) 27.17,58.1 27.17,58.38 arc(27.16,58.45) 27.12,58.51 27.11,58.52 arc(27.07,58.58) 27.06,58.65 27.06,59.28 arc(27.04,59.38) 26.98,59.47 arc(26.97,59.48) 26.96,59.5 26.96,59.79 26.97,59.79 26.97,59.81
  BOTTOM w0.081: v5(8.88,74.74) 8.83,74.8 arc(8.78,74.82) 8.73,74.84 JUSBC1.B10 ; v5(27.16,60.37) 27.03,60.25 arc(26.98,60.18) 26.97,60.09 26.97,59.81
TBT_0_TRX_RD_DTX_N2: length 34
  IN3 w0.076: v4(12.66,70.55) 12.86,70.36 arc(12.88,70.33) 12.88,70.3 12.88,70.15 arc(12.9,70.06) 12.95,69.99 14.37,68.56 arc(15.26,67.97) 16.31,67.76 arc(21.31,66.96) 25.81,64.62 arc(26.73,63.89) 27.6,63.09 29.48,61.2 arc(29.63,60.98) 29.68,60.72 29.68,60.41 29.61,59.94 29.61,59.4 arc(29.58,59.28) v4(29.52,59.18)
  BOTTOM w0.076: v4(29.52,59.18) 29.57,59.13 arc(29.6,59.08) 29.61,59.03 29.61,58.64 arc(29.59,58.56) 29.55,58.49 29.54,58.48 arc(29.49,58.41) 29.47,58.34 29.47,58.16 arc(29.5,58.01) 29.58,57.89 URT1.C11
  BOTTOM w0.081: JUSBC1.A10 10.01,78.59 arc(10.1,78.6) 10.17,78.65 10.18,78.66 arc(10.26,78.72) 10.35,78.73 10.43,78.73 arc(10.72,78.67) 10.97,78.51 11.47,78.02 arc(12.67,76.17) 13.09,74.01 13.09,73.89 13.09,73.88 13.09,73.33 13.09,73.32 v7(13.09,72.05) 13.09,71.04 arc(13.06,70.95) 12.97,70.91 12.91,70.91 arc(12.74,70.84) 12.66,70.66 v4(12.66,70.55)
TBT_0_TRX_RD_DTX_P1: length 29.6
  TOP w0.081: v5(8.88,74.19) 8.96,74.1 arc(9.07,74.03) 9.19,74.01 arc(9.27,74.04) 9.31,74.13 9.31,74.23 arc(9.35,74.31) 9.44,74.33 arc(9.71,74.22) 9.94,74.04 9.95,74.03 arc(10.42,73.32) 10.59,72.47 10.59,70.87 arc(10.57,70.78) 10.52,70.7 D79.1 10.52,70.41 arc(10.57,70.33) 10.59,70.24 10.59,70.19 arc(10.61,70.04) 10.67,69.9 arc(10.71,69.84) 10.76,69.79 10.77,69.78 arc(10.95,69.66) 11.16,69.61 arc(11.63,69.52) 12.02,69.26 13.71,67.57 arc(16.48,65.72) 19.75,65.07 arc(22.96,64.43) 25.69,62.61 26.36,61.93 arc(26.66,61.49) 26.76,60.97 26.76,60.67 arc(26.74,60.57) 26.69,60.49 v5(26.57,60.37)
  BOTTOM w0.076: 26.76,59.81 26.76,59.79 26.77,59.79 26.77,59.5 arc(26.78,59.41) 26.84,59.33 arc(26.85,59.3) 26.86,59.28 26.86,58.66 26.86,58.65 arc(26.84,58.57) 26.79,58.5 26.78,58.49 arc(26.73,58.41) 26.71,58.33 26.71,58.14 arc(26.72,58.1) 26.74,58.06 arc(26.82,58.03) 26.9,58.06 arc(26.93,58.11) 26.94,58.16 26.94,58.16 URT1.J12
  BOTTOM w0.081: v5(26.57,60.37) 26.7,60.25 arc(26.75,60.18) 26.76,60.09 26.76,59.81 ; v5(8.88,74.19) 8.8,74.27 arc(8.72,74.32) 8.63,74.33 JUSBC1.B11
TBT_0_TRX_RD_DTX_P2: length 34
  IN3 w0.076: v4(13.3,70.55) 13.1,70.36 arc(13.09,70.33) 13.08,70.3 13.08,70.15 arc(13.08,70.14) 13.09,70.13 14.51,68.7 arc(15.34,68.15) 16.31,67.96 arc(21.38,67.14) 25.93,64.78 arc(26.86,64.04) 27.74,63.23 29.62,61.34 arc(29.81,61.06) 29.88,60.72 29.88,60.39 29.8,59.92 29.8,59.4 arc(29.83,59.28) v4(29.9,59.18)
  BOTTOM w0.076: URT1.C12 29.7,58.13 arc(29.71,58.1) 29.73,58.07 29.75,58.05 arc(29.81,58.03) 29.88,58.05 arc(29.92,58.11) 29.93,58.18 29.93,58.33 arc(29.92,58.41) 29.87,58.48 29.86,58.49 arc(29.82,58.56) 29.8,58.63 29.8,59.03 arc(29.82,59.08) 29.85,59.13 v4(29.9,59.18)
  BOTTOM w0.081: JUSBC1.A11 10,79.08 arc(10.09,79.07) 10.17,79.02 10.18,79.01 arc(10.26,78.95) 10.35,78.94 10.43,78.94 arc(10.8,78.86) 11.12,78.65 11.61,78.16 arc(12.86,76.25) 13.3,74.01 v7(13.3,73.6) 13.3,72.32 13.31,72.31 13.31,71.79 13.3,71.78 13.3,70.55 v4(13.3,70.55)
TBT_0_TTX_C_DRX_N1: length 5.5
  BOTTOM w0.081: JUSBC1.A3 9.99,75.08 arc(10.08,75.07) 10.16,75.02 10.17,75.01 arc(10.24,74.95) 10.33,74.94 10.39,74.94 arc(10.85,74.75) 11.04,74.29 11.05,74.28 11.05,73.66 11.04,73.65 v7(11.04,71.77) 11.04,70.61 CT31.2
TBT_0_TTX_C_DRX_N2: length 2.5
  TOP w0.081: CT33.2 10.09,79.09 arc(10.01,79.15) 9.91,79.16 9.73,79.16 arc(9.69,79.16) 9.67,79.14 9.47,78.94 arc(9.38,78.88) 9.27,78.86 9.16,78.86 arc(9.06,78.84) 8.98,78.79 v5(8.88,78.68)
  BOTTOM w0.081: JUSBC1.B3 8.39,78.33 arc(8.4,78.34) 8.41,78.34 8.75,78.68 v5(8.88,78.68)
TBT_0_TTX_C_DRX_P1: length 5.4
  BOTTOM w0.081: JUSBC1.A2 9.97,74.59 arc(10.06,74.6) 10.13,74.65 10.14,74.66 arc(10.22,74.72) 10.31,74.73 10.39,74.73 arc(10.7,74.6) 10.83,74.29 v7(10.83,73.96) 10.83,72.04 10.83,72.03 10.83,71.51 10.83,71.5 10.83,71.13 arc(10.81,71.06) 10.75,71.04 10.61,71.04 arc(10.51,71) 10.47,70.9 CT30.2
TBT_0_TTX_C_DRX_P2: length 2.6
  TOP w0.081: CT32.2 10.07,79.44 arc(9.99,79.39) 9.89,79.37 9.72,79.37 arc(9.62,79.35) 9.52,79.28 9.33,79.09 arc(9.3,79.07) 9.27,79.06 9.16,79.06 arc(9.06,79.08) 8.98,79.13 v5(8.88,79.24)
  BOTTOM w0.081: v5(8.88,79.24) 8.54,78.91 arc(8.47,78.85) 8.37,78.83 JUSBC1.B2
TBT_0_TTX_C_RD_DRX_N0: length 2.3
  BOTTOM w0.076: URT1.J2 26.78,53.47 arc(26.73,53.4) 26.71,53.31 26.71,53.03 arc(26.73,52.96) 26.77,52.9 26.78,52.89 arc(26.82,52.83) 26.83,52.76 26.83,52.6 arc(26.8,52.43) 26.7,52.28 26.62,52.2 arc(26.56,52.11) 26.54,52.01 26.54,51.91 arc(26.52,51.82) 26.47,51.75 CT2.2
TBT_0_TTX_C_RD_DRX_N1: length 2.7
  BOTTOM w0.076: CT6.2 30.62,51.75 arc(30.57,51.82) 30.55,51.91 arc(30.44,52.18) 30.17,52.29 29.96,52.29 arc(29.85,52.33) 29.8,52.45 29.8,52.77 arc(29.82,52.85) 29.86,52.92 29.87,52.93 arc(29.92,52.99) 29.93,53.07 29.93,53.25 arc(29.9,53.39) 29.82,53.51 URT1.C2
TBT_0_TTX_C_RD_DRX_P0: length 2.3
  BOTTOM w0.076: CT1.2 26.78,51.78 arc(26.75,51.82) 26.74,51.87 26.74,52.01 arc(26.74,52.04) 26.76,52.06 26.84,52.14 arc(26.98,52.35) 27.03,52.6 27.03,52.75 arc(27.05,52.84) 27.1,52.91 27.11,52.92 arc(27.16,53) 27.17,53.08 27.17,53.26 arc(27.17,53.31) 27.14,53.34 arc(27.06,53.38) 26.98,53.34 arc(26.95,53.3) 26.94,53.25 26.94,53.24 URT1.J1
TBT_0_TTX_C_RD_DRX_P1: length 2.7
  BOTTOM w0.076: URT1.C1 29.7,53.25 arc(29.69,53.31) 29.66,53.35 29.66,53.36 arc(29.59,53.38) 29.53,53.36 arc(29.49,53.3) 29.47,53.22 29.47,53.07 arc(29.49,53) 29.53,52.93 29.54,52.92 arc(29.59,52.85) 29.6,52.78 29.6,52.45 arc(29.71,52.19) 29.96,52.09 30.17,52.09 arc(30.3,52.04) 30.35,51.91 30.35,51.88 arc(30.34,51.82) 30.3,51.77 CT5.2
TBT_0_TTX_DRX_N0: length 175.9
  IN1 w0.076: v5(26.37,49.04) 26.49,48.92 arc(26.52,48.88) 26.53,48.83 26.53,48.52 arc(26.59,48.22) 26.76,47.98 28.35,46.38 arc(28.53,46.26) 28.74,46.22 arc(29.09,46.15) 29.39,45.95 29.4,45.94 32.92,42.42 arc(33.14,42.09) 33.22,41.71 arc(33.34,41.11) 33.68,40.6 34.65,39.62 arc(35.06,39.02) 35.2,38.31 35.2,36.98 35.44,35.6 35.23,34.41 35.48,32.98 35.24,31.57 35.45,30.35 35.26,29.27 35.5,27.91 35.5,27.1 arc(35.71,26.01) 36.33,25.09 47.32,14.1 arc(48.54,13.29) 49.99,13 51.74,13 53.01,12.77 54.47,13.03 55.8,12.8 57.13,13.03 58.59,12.77 59.99,13.02 61.31,12.79 62.67,13.03 64.09,12.78 65.45,13.02 67.94,13.02 arc(68.66,13.16) 69.27,13.57 arc(69.64,13.82) 70.09,13.91 73.07,13.91 arc(74.59,14.21) 75.87,15.07 89.53,28.73 arc(90.03,29.47) 90.2,30.34 90.2,32.47 90,33.61 90.21,34.79 89.96,36.18 90.2,37.52 89.98,38.73 90.2,39.98 90,41.11 90.2,42.26 90.03,43.27 90.21,44.29 90.04,45.24 90.19,46.09 arc(90.19,46.11) 90.19,46.13 90.19,48.5 arc(90.24,48.76) 90.39,48.99 93.58,52.17 arc(94.61,52.86) 95.83,53.1 100.95,53.1 arc(102.29,53.37) 103.43,54.13 106.49,57.19 arc(107.47,57.85) 108.64,58.08 117.63,58.08 arc(118.47,58.25) 119.19,58.73 122.24,61.77 arc(123.47,62.6) 124.92,62.89 126.27,62.89 arc(126.63,62.96) 126.94,63.16 arc(127.09,63.27) 127.28,63.3 129.31,63.3 arc(129.44,63.28) 129.56,63.2 129.56,63.2 arc(130.33,62.68) 131.24,62.5 132.07,62.5 arc(132.61,62.4) 133.06,62.09 135.8,59.35 arc(136.5,58.89) 137.32,58.72 138.79,58.72 arc(139.26,58.63) 139.66,58.36 139.78,58.25 arc(139.95,58.13) 140.16,58.09 140.87,58.09 arc(141.58,57.95) 142.18,57.54 142.51,57.22 arc(142.55,57.15) 142.57,57.06 142.57,56.99 arc(142.56,56.96) 142.54,56.93 142.54,56.92 v4(142.29,56.67)
  BOTTOM w0.081: CT2.1 26.47,50.93 arc(26.51,50.86) 26.53,50.77 26.53,49.3 arc(26.51,49.21) 26.47,49.14 v5(26.37,49.04) ; v4(142.29,56.67) 142.61,56.99 UC1.BB5
TBT_0_TTX_DRX_N1: length 178.2
  IN1 w0.076: v5(30.7,50.36) 30.56,50.22 arc(30.51,50.15) 30.49,50.06 30.49,48.92 arc(30.63,48.23) 31.02,47.65 35.63,43.04 arc(35.74,42.88) 35.78,42.68 arc(35.86,42.27) 36.09,41.92 36.71,41.3 arc(37.26,40.48) 37.45,39.5 37.45,37.4 37.78,35.56 37.56,34.31 37.79,32.97 37.54,31.55 37.8,30.09 37.63,29.12 37.78,28.25 37.78,27.3 arc(37.87,26.85) 38.13,26.47 48.81,15.79 arc(49.3,15.46) 49.88,15.35 51.77,15.35 53.03,15.13 54.37,15.36 55.09,15.24 55.75,15.12 57.16,15.37 58.62,15.11 60.08,15.37 61.43,15.13 62.76,15.37 64.08,15.13 65.47,15.38 67.35,15.38 arc(67.65,15.44) 67.9,15.61 68.03,15.74 arc(68.57,16.1) 69.2,16.22 73.24,16.22 arc(73.69,16.31) 74.07,16.57 87.61,30.11 arc(87.79,30.37) 87.85,30.68 87.85,32.6 87.67,33.63 87.79,34.3 87.79,34.3 87.89,34.91 87.66,36.24 87.89,37.56 87.68,38.76 87.79,39.4 87.89,39.96 87.68,41.15 87.85,42.13 87.69,43.05 87.88,44.12 87.71,45.08 87.88,46.03 arc(87.88,46.03) 87.88,46.04 87.88,49.09 arc(87.98,49.61) 88.28,50.05 94.12,55.9 arc(94.48,56.14) 94.9,56.22 102.16,56.22 arc(102.33,56.26) 102.48,56.36 105.16,59.04 arc(106.58,59.99) 108.26,60.32 115.99,60.32 arc(116.71,60.39) 117.41,60.6 arc(118.05,60.94) 118.61,61.41 122.84,65.64 arc(123.73,66.23) 124.78,66.44 131.44,66.44 arc(131.72,66.38) 131.95,66.23 132.1,66.08 arc(132.19,65.95) 132.22,65.8 132.22,65.6 arc(132.28,65.28) 132.46,65.01 132.48,64.99 arc(132.79,64.78) 133.15,64.71 134.94,64.71 arc(135.24,64.65) 135.5,64.48 136.38,63.6 arc(136.87,63.27) 137.46,63.16 arc(137.93,63.06) 138.33,62.8 140.22,60.9 arc(140.51,60.71) 140.85,60.64 141.54,60.64 arc(142.23,60.51) 142.81,60.12 142.97,59.96 arc(142.99,59.94) 143.02,59.94 143.19,59.94 arc(143.28,59.95) 143.35,60 v3(143.46,60.12)
  IN3 w0.076: v4(140.83,56.34) 140.69,56.48 140.53,56.48 140.28,56.73 140.28,57.68 142.71,60.12 v3(143.46,60.12)
  BOTTOM w0.081: v5(30.7,50.36) 30.62,50.44 arc(30.56,50.52) 30.54,50.62 30.54,50.75 arc(30.56,50.85) 30.62,50.92 CT6.1
TBT_0_TTX_DRX_P0: length 175.8
  IN1 w0.076: v3(142.89,56.63) 142.89,56.63 142.78,56.81 arc(142.77,56.87) 142.77,56.94 142.76,56.94 arc(142.76,56.96) 142.77,56.99 142.77,57.13 arc(142.74,57.23) 142.69,57.32 142.32,57.68 arc(141.66,58.13) 140.87,58.29 140.16,58.29 arc(140.03,58.31) 139.92,58.39 139.8,58.5 arc(139.34,58.81) 138.79,58.92 137.32,58.92 arc(136.58,59.07) 135.94,59.49 133.2,62.23 arc(132.68,62.58) 132.07,62.7 131.24,62.7 arc(130.4,62.87) 129.7,63.34 arc(129.52,63.46) 129.31,63.5 127.28,63.5 arc(127.02,63.45) 126.8,63.3 arc(126.56,63.14) 126.27,63.09 124.92,63.09 arc(123.39,62.78) 122.1,61.91 119.05,58.87 arc(118.4,58.43) 117.63,58.28 108.64,58.28 arc(107.4,58.03) 106.35,57.33 103.29,54.27 arc(102.22,53.55) 100.95,53.3 95.83,53.3 arc(94.53,53.05) 93.44,52.31 90.25,49.13 arc(90.06,48.84) 89.99,48.5 89.99,46.13 arc(89.99,46.13) 89.99,46.12 89.84,45.24 90,44.29 89.82,43.27 90,42.26 89.8,41.11 90,39.98 89.9,39.39 89.78,38.73 89.99,37.52 89.76,36.18 90,34.79 90.01,34.79 89.8,33.61 90,32.45 90,30.34 arc(89.84,29.54) 89.39,28.87 75.73,15.21 arc(74.51,14.39) 73.07,14.11 70.09,14.11 arc(69.57,14) 69.13,13.71 arc(68.58,13.34) 67.94,13.22 65.43,13.22 64.09,12.98 62.67,13.23 61.31,12.99 60.68,13.1 59.99,13.22 58.59,12.98 57.13,13.23 55.8,13 54.47,13.23 54.43,13.23 53.01,12.98 51.76,13.2 49.99,13.2 arc(48.62,13.47) 47.46,14.24 36.47,25.23 arc(35.9,26.09) 35.7,27.1 35.7,27.93 35.46,29.27 35.65,30.35 35.44,31.57 35.69,32.98 35.43,34.41 35.64,35.6 35.4,37 35.4,38.31 arc(35.24,39.09) 34.79,39.76 33.82,40.74 arc(33.52,41.18) 33.41,41.71 33.41,41.71 arc(33.32,42.17) 33.06,42.56 29.53,46.09 arc(29.17,46.33) 28.74,46.42 arc(28.6,46.45) 28.49,46.52 26.9,48.12 arc(26.77,48.3) 26.73,48.52 26.73,48.68 arc(26.75,48.81) 26.83,48.92 v5(26.95,49.04)
  IN3 w0.076: v3(142.89,56.63) v4(142.89,56.63)
  BOTTOM w0.081: v5(26.95,49.04) 26.93,49.04 26.81,49.17 arc(26.76,49.24) 26.74,49.33 26.73,49.36 26.73,50.75 26.74,50.8 arc(26.75,50.86) 26.78,50.9 CT1.1 ; UC1.BB6 142.66,56.39 142.89,56.62 v4(142.89,56.63)
TBT_0_TTX_DRX_P1: length 178.2
  IN1 w0.076: v3(143.46,59.58) 143.38,59.67 arc(143.3,59.72) 143.22,59.74 143.02,59.74 arc(142.92,59.76) 142.83,59.82 142.67,59.98 arc(142.15,60.32) 141.54,60.44 140.85,60.44 arc(140.43,60.53) 140.08,60.76 138.19,62.66 arc(137.85,62.88) 137.46,62.96 arc(136.8,63.09) 136.24,63.46 135.36,64.34 arc(135.17,64.47) 134.94,64.51 133.15,64.51 arc(132.71,64.6) 132.34,64.85 132.32,64.87 arc(132.1,65.2) 132.02,65.6 132.02,65.8 arc(132,65.87) 131.96,65.94 131.81,66.09 arc(131.64,66.2) 131.44,66.24 124.78,66.24 arc(123.81,66.05) 122.98,65.5 118.75,61.27 arc(118.16,60.78) 117.48,60.42 arc(116.75,60.2) 115.99,60.12 108.26,60.12 arc(106.66,59.8) 105.3,58.9 102.62,56.22 arc(102.41,56.07) 102.16,56.02 94.9,56.02 arc(94.56,55.96) 94.26,55.76 88.42,49.91 arc(88.16,49.54) 88.08,49.09 88.08,46.04 arc(88.07,46.02) 88.07,46 87.91,45.08 88.08,44.12 87.89,43.05 88.06,42.13 87.88,41.15 88.09,39.96 87.88,38.76 88.09,37.56 87.86,36.24 88.09,34.91 87.87,33.63 88.05,32.62 88.05,30.68 arc(87.97,30.3) 87.75,29.97 74.21,16.43 arc(73.76,16.13) 73.24,16.02 69.2,16.02 arc(68.64,15.91) 68.17,15.6 68.04,15.47 arc(67.73,15.26) 67.35,15.18 65.49,15.18 64.08,14.93 62.76,15.17 61.43,14.93 60.08,15.17 58.62,14.91 57.85,15.05 57.85,15.05 57.16,15.17 55.75,14.92 54.37,15.16 53.03,14.93 51.76,15.15 49.88,15.15 arc(49.22,15.28) 48.67,15.65 37.99,26.33 arc(37.69,26.78) 37.59,27.3 37.59,28.24 37.43,29.12 37.6,30.09 37.34,31.55 37.59,32.97 37.48,33.6 37.36,34.31 37.58,35.56 37.42,36.47 37.26,37.38 37.26,39.5 arc(37.08,40.4) 36.57,41.16 35.95,41.78 arc(35.68,42.19) 35.58,42.68 arc(35.56,42.8) 35.49,42.9 30.88,47.51 arc(30.45,48.16) 30.3,48.92 30.3,50.08 arc(30.28,50.17) 30.23,50.25 v5(30.12,50.36)
  IN3 w0.076: v4(140.83,56.99) 140.83,56.76 140.75,56.68 140.61,56.68 140.48,56.81 140.48,57.6 142.8,59.92 143.13,59.92 v3(143.46,59.58)
  BOTTOM w0.081: CT5.1 30.27,50.94 arc(30.32,50.86) 30.34,50.76 30.34,50.69 arc(30.32,50.59) 30.27,50.51 v5(30.12,50.36)
TBT_0_TTX_RD_DRX_N1: length 24.5
  IN3 w0.076: v4(11.06,69.33) 10.87,69.14 arc(10.85,69.11) 10.84,69.08 10.84,69.01 arc(10.9,68.88) 11.03,68.83 11.66,68.83 arc(12.14,68.73) 12.55,68.46 arc(14,67.49) 15.72,67.14 15.87,67.14 arc(21.85,65.96) 26.92,62.57 27.79,61.7 arc(27.93,61.5) 27.98,61.25 27.98,59.4 arc(28,59.28) v4(28.07,59.17)
  BOTTOM w0.076: URT1.G11 28.02,57.94 arc(28.07,58.01) 28.09,58.1 28.09,58.38 arc(28.08,58.45) 28.04,58.51 28.03,58.52 arc(27.99,58.58) 27.98,58.65 27.98,59.08 v4(28.07,59.17)
  BOTTOM w0.081: v4(11.06,69.33) 10.93,69.47 arc(10.88,69.55) 10.86,69.64 10.86,69.75 arc(10.88,69.85) 10.93,69.92 CT31.1
TBT_0_TTX_RD_DRX_N2: length 33.5
  TOP w0.081: v5(28.5,60.34) 28.71,60.55 arc(28.71,60.56) 28.72,60.57 28.72,60.9 arc(28.63,61.34) 28.38,61.71 27.14,62.95 arc(23.51,65.38) 19.23,66.23 19.22,66.23 arc(16.66,66.74) 14.48,68.19 13,69.68 arc(12.91,69.81) 12.88,69.96 12.88,70.24 arc(12.86,70.33) 12.81,70.41 D78.2 12.81,70.7 arc(12.86,70.78) 12.88,70.87 12.88,71.25 arc(12.91,71.42) 13.01,71.57 arc(13.05,71.63) 13.07,71.71 13.07,74.99 arc(12.9,75.84) 12.42,76.57 arc(12.04,77.14) 11.9,77.81 11.9,78.5 arc(11.82,78.9) 11.59,79.25 arc(11.47,79.33) 11.33,79.36 11.23,79.36 arc(11.17,79.33) 11.14,79.26 11.14,79.18 arc(11.08,79.05) 10.95,78.99 CT33.1
  BOTTOM w0.076: URT1.E11 28.66,57.89 arc(28.58,58.01) 28.55,58.16 28.55,58.34 arc(28.57,58.41) 28.62,58.48 28.63,58.49 arc(28.67,58.56) 28.69,58.64 28.69,59.81
  BOTTOM w0.081: v5(28.5,60.34) 28.64,60.2 arc(28.68,60.15) 28.69,60.1 28.69,59.81
TBT_0_TTX_RD_DRX_P1: length 24.5
  IN3 w0.076: v4(10.43,69.33) 10.62,69.14 arc(10.64,69.11) 10.65,69.08 10.65,69.01 arc(10.76,68.74) 11.03,68.63 11.66,68.63 arc(12.07,68.55) 12.41,68.32 arc(13.93,67.3) 15.72,66.95 15.87,66.95 arc(21.78,65.77) 26.78,62.43 27.65,61.56 arc(27.74,61.42) 27.78,61.25 27.78,59.4 arc(27.75,59.28) v4(27.69,59.17)
  BOTTOM w0.076: URT1.G12 27.86,58.15 arc(27.79,58.04) 27.66,58.06 arc(27.64,58.1) 27.63,58.14 27.63,58.33 arc(27.65,58.41) 27.7,58.49 27.71,58.5 arc(27.76,58.57) 27.78,58.66 27.78,59.08 v4(27.69,59.17)
  BOTTOM w0.081: v4(10.43,69.33) 10.58,69.49 arc(10.64,69.57) 10.66,69.66 10.66,69.74 arc(10.64,69.83) 10.58,69.91 CT30.1
TBT_0_TTX_RD_DRX_P2: length 33.5
  TOP w0.081: CT32.1 11.33,79.56 arc(11.55,79.52) 11.73,79.39 arc(12.01,78.98) 12.1,78.5 12.1,77.81 arc(12.22,77.21) 12.56,76.71 arc(13.09,75.92) 13.27,74.99 13.27,71.71 arc(13.24,71.56) 13.16,71.43 arc(13.1,71.35) 13.08,71.25 13.08,70.87 arc(13.1,70.78) 13.15,70.7 D76.2 13.15,70.41 arc(13.1,70.33) 13.08,70.24 13.08,69.96 arc(13.1,69.89) 13.14,69.82 14.63,68.34 arc(16.74,66.93) 19.22,66.43 19.23,66.43 arc(23.59,65.56) 27.29,63.09 28.53,61.85 arc(28.82,61.42) 28.92,60.9 28.92,60.74 arc(28.96,60.52) v5(29.09,60.34)
  BOTTOM w0.076: 28.88,59.81 28.88,58.63 arc(28.9,58.56) 28.94,58.49 28.95,58.48 arc(29,58.41) 29.01,58.33 29.01,58.18 arc(29,58.11) 28.96,58.05 arc(28.89,58.03) 28.83,58.05 28.83,58.06 arc(28.79,58.1) 28.78,58.16 URT1.E12
  BOTTOM w0.081: 28.88,59.81 28.88,59.86 arc(28.94,60.12) 29.09,60.34 v5(29.09,60.34)
TBT_2_AUXN: length 193.5
  IN1 w0.076: v4(263.36,53.88) 263.51,53.73 arc(263.58,53.68) 263.67,53.66 263.67,53.66 arc(263.88,53.62) 264.05,53.5 arc(264.16,53.34) 264.2,53.15 264.2,52.98 arc(264.17,52.83) 264.08,52.7 264.06,52.68 arc(263.99,52.58) 263.97,52.46 263.97,51.75 arc(264.14,50.89) 264.63,50.16 266.3,48.49 arc(266.76,48.18) 267.3,48.07 270.38,48.07 arc(270.68,48.01) 270.93,47.84 271.07,47.71 arc(271.22,47.47) 271.28,47.19 271.28,45.75 arc(271.32,45.58) 271.41,45.43 273.01,43.84 arc(273.2,43.56) 273.26,43.22 273.26,36.07 arc(273.13,35.4) 272.75,34.83 arc(272.49,34.46) 272.38,34.02 arc(272.38,33.98) 272.38,33.94 272.38,33.03 arc(272.22,32.24) 271.78,31.57 271.78,31.57 arc(271.77,31.56) 271.77,31.55 271.77,31.38 arc(271.71,31.08) 271.54,30.83 271.01,30.3 arc(270.95,30.21) 270.93,30.1 arc(270.83,29.6) 270.55,29.17 269.45,28.08 arc(268.76,27.61) 267.94,27.45 265.8,27.45 arc(265.62,27.42) 265.46,27.31 264.67,26.52 arc(264.41,26.35) 264.1,26.29 263.8,26.29 arc(263.56,26.24) 263.36,26.1 261.66,24.4 arc(261.41,24.24) 261.12,24.18 259.68,24.18 arc(259.47,24.14) 259.3,24.02 259.26,23.98 258.88,23.6 arc(258.67,23.46) 258.42,23.41 257.75,23.41 arc(257.65,23.39) 257.57,23.33 arc(257.28,23.14) 256.94,23.07 254.66,23.07 arc(254.47,23.04) 254.31,22.93 254.01,22.63 arc(253.89,22.54) 253.74,22.51 253.06,22.51 arc(252.75,22.45) 252.48,22.27 251.7,21.5 arc(251.46,21.13) 251.37,20.69 251.37,20.24 arc(251.32,19.97) 251.17,19.75 250.29,18.87 arc(249.07,18.05) 247.64,17.77 246.93,17.77 arc(246.71,17.73) 246.53,17.61 245.66,16.73 arc(245.43,16.58) 245.17,16.53 243.63,16.53 arc(243.53,16.51) 243.45,16.45 243.36,16.36 arc(243.11,16.19) 242.81,16.13 242.24,16.13 arc(242.12,16.11) 242.03,16.04 241.43,15.45 arc(240.95,15.13) 240.39,15.02 236.21,15.02 235.26,14.85 233.9,15.09 232.49,14.85 231.07,15.1 229.7,14.85 228.5,15.07 227.58,14.9 arc(227.33,14.82) 227.11,14.66 226.89,14.44 arc(226.65,14.28) 226.36,14.22 224.8,14.22 arc(224.59,14.26) 224.41,14.38 224.41,14.38 arc(224.35,14.42) 224.28,14.43 215.19,14.43 arc(214.37,14.6) 213.67,15.06 arc(213.2,15.38) 212.64,15.49 212.54,15.49 arc(211.99,15.6) 211.52,15.91 211.05,16.39 arc(210.98,16.44) 210.9,16.45 208.65,16.45 arc(208.01,16.58) 207.48,16.94 202.54,21.87 arc(202.14,22.48) 201.99,23.19 201.99,26.15 arc(202.22,27.26) 202.84,28.2 202.98,28.34 arc(203.23,28.71) 203.32,29.15 203.32,33.43 arc(203.17,34.21) 202.72,34.87 202.69,34.91 arc(202.29,35.5) 202.15,36.2 202.15,36.99 arc(202.13,37.09) 202.08,37.17 198.73,40.52 198.67,40.57 arc(198.5,40.69) 198.29,40.73 198.21,40.73 arc(197.86,40.8) 197.56,41 196.37,42.19 arc(196.29,42.25) 196.2,42.26 195.7,42.26 arc(195.41,42.32) 195.16,42.48 189.76,47.89 arc(189.33,48.54) 189.17,49.3 arc(189.13,49.5) 189.02,49.67 188.23,50.46 arc(188.02,50.77) 187.95,51.14 187.95,51.33 arc(187.92,51.49) 187.82,51.63 183.9,55.55 arc(183.65,55.72) 183.36,55.78 183.36,55.78 arc(181.28,56.19) 179.52,57.36 179.48,57.41 arc(179.16,57.62) 178.78,57.7 177.28,57.7 arc(176.14,57.92) 175.16,58.57 174.62,59.12 arc(172.64,60.44) 170.3,60.91 169.94,60.91 169.09,60.76 167.52,61.03 165.82,60.73 165.29,60.73 arc(164.67,60.61) 164.14,60.26 arc(163.87,60.08) 163.55,60.01 161.89,60.01 161.58,59.94 160.4,59.94 158.67,59.64 157.79,59.79 156.86,59.63 154.75,60 153.66,59.81 152.51,59.81 arc(152,59.71) 151.56,59.42 149.72,57.57 arc(149.38,57.35) 148.99,57.27 148.99,57.27 arc(148.82,57.24) 148.68,57.14 147.84,56.3 arc(147.54,56.1) 147.18,56.03 146.56,56.03 arc(146.31,56.08) 146.09,56.22 146,56.32 arc(145.98,56.33) 145.95,56.34 v4(145.4,56.34)
TBT_2_AUXN_R: length 2.2
  BOTTOM w0.076: RT117.2 264.09,53.73 arc(264.17,53.68) 264.25,53.66 264.39,53.66 arc(264.5,53.64) 264.58,53.58 264.77,53.4 arc(264.79,53.38) 264.82,53.38 265,53.38 arc(265.09,53.39) 265.16,53.44 265.17,53.46 arc(265.25,53.51) 265.34,53.52 265.49,53.52 arc(265.56,53.51) 265.61,53.48 265.61,53.47 arc(265.64,53.41) 265.61,53.35 265.61,53.34 arc(265.56,53.31) 265.5,53.3 URT2.M8
TBT_2_AUXP: length 193.5
  IN1 w0.076: v4(263.36,53.24) 263.52,53.4 arc(263.59,53.45) 263.67,53.46 arc(263.8,53.44) 263.91,53.36 arc(263.98,53.27) 264,53.15 264,53.15 264,52.98 arc(263.99,52.91) 263.94,52.84 263.92,52.82 arc(263.81,52.66) 263.77,52.46 263.77,51.75 arc(263.96,50.81) 264.49,50.02 266.16,48.35 arc(266.68,48) 267.3,47.88 270.38,47.88 arc(270.6,47.83) 270.79,47.7 270.93,47.57 arc(271.04,47.4) 271.08,47.19 271.08,45.75 arc(271.13,45.5) 271.27,45.29 272.87,43.7 arc(273.01,43.48) 273.06,43.22 273.06,36.07 arc(272.94,35.48) 272.61,34.97 272.6,34.97 arc(272.31,34.54) 272.18,34.03 arc(272.18,33.99) 272.18,33.94 272.18,33.03 arc(272.04,32.32) 271.64,31.71 arc(271.59,31.64) 271.57,31.56 271.57,31.38 arc(271.53,31.16) 271.4,30.97 270.87,30.44 arc(270.77,30.29) 270.73,30.1 270.73,30.1 arc(270.65,29.67) 270.41,29.31 269.31,28.22 arc(268.68,27.8) 267.94,27.65 265.8,27.65 arc(265.54,27.6) 265.32,27.45 264.53,26.66 arc(264.33,26.53) 264.1,26.48 263.8,26.48 arc(263.49,26.42) 263.22,26.24 261.52,24.54 arc(261.34,24.42) 261.12,24.38 259.68,24.38 259.68,24.38 arc(259.4,24.32) 259.16,24.16 259.12,24.12 258.74,23.74 arc(258.59,23.64) 258.42,23.61 257.75,23.61 arc(257.58,23.57) 257.43,23.48 arc(257.2,23.32) 256.94,23.27 254.66,23.27 arc(254.4,23.22) 254.17,23.07 253.87,22.77 arc(253.81,22.73) 253.74,22.71 253.06,22.71 arc(252.67,22.64) 252.34,22.41 251.56,21.64 arc(251.28,21.2) 251.17,20.69 251.17,20.24 arc(251.14,20.05) 251.03,19.89 250.15,19.01 arc(249,18.24) 247.64,17.97 246.93,17.97 arc(246.64,17.91) 246.39,17.75 245.52,16.87 arc(245.36,16.76) 245.17,16.73 243.63,16.73 arc(243.46,16.69) 243.31,16.59 243.21,16.5 arc(243.03,16.38) 242.81,16.33 242.24,16.33 arc(242.05,16.29) 241.89,16.18 241.29,15.59 arc(240.88,15.31) 240.39,15.22 236.19,15.22 235.26,15.05 233.9,15.3 232.49,15.05 231.07,15.3 229.7,15.05 228.5,15.27 227.55,15.1 arc(227.23,14.99) 226.97,14.8 226.75,14.58 arc(226.57,14.46) 226.36,14.42 224.8,14.42 arc(224.66,14.45) 224.55,14.52 224.55,14.52 arc(224.42,14.6) 224.28,14.63 215.19,14.63 arc(214.44,14.78) 213.81,15.2 213.81,15.2 arc(213.27,15.56) 212.64,15.69 212.54,15.69 arc(212.07,15.78) 211.66,16.05 211.19,16.53 arc(211.05,16.62) 210.9,16.65 208.65,16.65 arc(208.09,16.76) 207.62,17.08 202.68,22.01 arc(202.32,22.55) 202.19,23.19 202.19,26.15 arc(202.4,27.18) 202.98,28.06 203.12,28.2 arc(203.42,28.64) 203.52,29.15 203.52,33.43 arc(203.35,34.29) 202.86,35.01 202.83,35.05 arc(202.47,35.58) 202.35,36.2 202.35,36.99 arc(202.32,37.16) 202.22,37.31 198.81,40.71 arc(198.57,40.88) 198.29,40.93 198.21,40.93 arc(197.93,40.99) 197.7,41.14 197.65,41.19 196.51,42.33 arc(196.37,42.43) 196.2,42.46 195.7,42.46 arc(195.48,42.5) 195.3,42.62 189.9,48.03 arc(189.51,48.61) 189.37,49.31 arc(189.32,49.58) 189.16,49.81 188.37,50.6 arc(188.21,50.85) 188.15,51.14 188.15,51.33 arc(188.1,51.57) 187.96,51.77 184.04,55.69 arc(183.73,55.9) 183.36,55.97 183.36,55.97 arc(181.36,56.37) 179.66,57.5 179.62,57.55 arc(179.24,57.8) 178.78,57.89 177.28,57.89 arc(176.21,58.11) 175.3,58.71 174.76,59.26 arc(172.71,60.62) 170.3,61.1 169.93,61.1 169.09,60.96 167.52,61.23 165.81,60.93 165.29,60.93 arc(164.59,60.79) 164,60.4 arc(163.79,60.26) 163.55,60.21 161.86,60.21 161.56,60.14 160.38,60.14 158.67,59.84 157.79,60 156.86,59.83 154.75,60.2 153.64,60.01 152.51,60.01 arc(151.92,59.89) 151.42,59.56 149.58,57.71 arc(149.31,57.53) 148.99,57.47 148.99,57.47 arc(148.75,57.42) 148.54,57.28 147.7,56.44 arc(147.46,56.28) 147.18,56.23 146.56,56.23 arc(146.38,56.26) 146.23,56.36 146.14,56.46 arc(146.05,56.52) 145.95,56.54 145.74,56.54 arc(145.71,56.54) 145.68,56.57 145.64,56.6 145.64,56.66 145.79,56.82 arc(145.81,56.85) 145.82,56.88 145.82,56.9 arc(145.81,56.93) 145.79,56.96 145.78,56.97 arc(145.76,56.98) 145.73,56.99 v4(145.4,56.99)
TBT_2_AUXP_R: length 2.3
  BOTTOM w0.076: RT116.2 264.1,53.4 arc(264.18,53.45) 264.26,53.46 264.39,53.46 arc(264.42,53.46) 264.44,53.44 264.63,53.26 arc(264.72,53.2) 264.82,53.18 265.05,53.18 arc(265.11,53.16) 265.17,53.13 265.18,53.12 arc(265.23,53.08) 265.3,53.07 265.58,53.07 arc(265.67,53.08) 265.74,53.13 URT2.L8
TBT_2_LSX_RX: length 157.2
  TOP w0.069: R6174.2 RC693.2 176.19,42.34 175.49,41.64 v1(175.4,41.64) v3(174.97,41.64)
  IN3 w0.061: v4(259.93,52.2) 259.93,52.43 259.9,52.47 259.25,52.47 258.99,52.21 258.99,47 256.99,44.99 256.99,35.73 258.69,34.03 258.69,30.62 256.31,28.24 254.97,28.24 253.93,27.2 250.5,27.2 245.08,21.78 244.69,21.78 238.47,15.57 227.81,15.57 226.95,14.71 208.24,14.71 206.07,12.53 195.89,12.53 194.19,14.23 193.09,14.23 191.56,15.76 191.56,20.44 191.86,20.74 191.86,23.57 195.69,27.39 195.69,29.59 195.45,29.83 195.45,31.7 194.93,32.21 194.93,34.3 192.53,36.7 192.53,37.65 191.3,38.88 190.08,38.88 189.68,39.29 188.89,39.29 187.98,40.2 186.8,40.2 186.22,40.78 184.96,40.78 184.73,41.01 183.76,41.01 183.44,40.69 183,40.69 182.09,41.6 181.37,41.6 180.58,42.39 179.1,42.39 178.82,42.11 175.1,42.11 174.97,41.98 v3(174.97,41.64) 174.6,42 174.16,42 173.64,42.52 171.09,42.52 170.49,43.12 168.81,43.12 168.56,43.37 168,43.37 167.56,42.93 167.56,42.83 167.37,42.64 166.77,42.64 v4(166.73,42.67)
TBT_2_LSX_RX_R: length 5.6
  IN3 w0.061: v4(265.9,52.84) 265.84,52.77 264.38,52.77 263.97,52.36 261.29,52.36 v4(261.13,52.2)
  BOTTOM w0.069: RT166.2 v4(261.13,52.2)
TBT_2_LSX_TX: length 155.2
  IN3 w0.061: v4(166.08,42.67) 166.38,42.97 166.75,42.97 167.25,43.47 167.77,43.47 167.86,43.56 168.64,43.56 168.89,43.31 170.56,43.31 171.17,42.71 173.76,42.71 174.26,42.21 174.88,42.21 174.97,42.29 178.74,42.29 179.03,42.58 180.66,42.58 181.45,41.79 182.17,41.79 183.08,40.88 183.36,40.88 184.08,41.6 185.78,41.6 187,40.38 188.06,40.38 188.97,39.47 189.75,39.47 190.16,39.07 191.34,39.07 192.72,37.69 192.72,36.78 195.12,34.38 195.12,32.29 195.64,31.78 195.64,29.91 195.87,29.67 195.87,27.25 193.79,25.16 193.79,23.63 192.05,21.89 192.05,20.65 191.74,20.35 191.74,15.84 193.17,14.41 194.27,14.41 195.96,12.72 205.99,12.72 208.32,15.04 223.75,15.04 224.46,15.76 238.4,15.76 244.61,21.97 245,21.97 250.43,27.39 253.85,27.39 254.89,28.43 256.23,28.43 258.5,30.7 258.5,33.95 256.8,35.66 256.8,45.07 258.8,47.07 258.8,52.29 259.18,52.67 259.82,52.67 v4(259.93,52.78)
TBT_2_LSX_TX_R: length 5.7
  BOTTOM w0.069: RT167.2 RT3.2 261.15,52.78 261.6,53.24 262.43,53.24 v1(262.51,53.32) 262.83,53.32 262.85,53.29 262.85,52.91 263.04,52.72 265.05,52.72
  BOTTOM w0.076: 265.05,52.72 265.16,52.84 URT2.M7
TBT_2_SBU1: length 25.1
  IN3 w0.061: v4(276.57,57.47) 278.5,59.4 281.09,59.4 282.06,60.37 282.06,63.14 283.17,64.25 v4(283.17,64.65) ; v4(275.35,57.47) 275.11,57.72 273.18,57.72 270.47,55.01 267.08,55.01 266.01,53.94 265.54,53.94 v4(265.11,54.37)
  BOTTOM w0.069: v4(275.35,57.47) CT306.2 275.93,57.47 275.94,57.47 v4(276.57,57.47)
  BOTTOM w0.076: v4(265.11,54.37) 265.27,54.22 URT2.M10
TBT_2_SBU2: length 28.2
  IN3 w0.061: v4(265.9,54.22) 266.87,55.19 270.4,55.19 273.11,57.89 275.14,57.89 v4(275.35,58.11) ; v4(276.57,58.23) 278.14,59.81 280.76,59.81 281.42,60.47 281.42,65.17 282.87,66.62 283.58,66.62 283.78,66.42 284.55,66.42 v4(284.57,66.4)
  BOTTOM w0.069: v1(277.51,59.3) 277.51,58.95 276.8,58.23 v4(276.57,58.23) 276.04,58.23 CT307.2 v4(275.35,58.11)
TBT_2_TRX_C_RD_DTX_N0: length 2.5
  BOTTOM w0.076: URT2.G2 267.58,50.37 arc(267.53,50.3) 267.51,50.21 267.51,49.93 arc(267.53,49.86) 267.57,49.8 267.58,49.79 arc(267.61,49.73) 267.63,49.66 267.63,49.12 arc(267.62,49.09) 267.61,49.07 267.51,48.97 arc(267.45,48.88) 267.43,48.78 267.43,48.64 arc(267.41,48.55) 267.36,48.48 CT12.2
TBT_2_TRX_C_RD_DTX_N1: length 2.4
  BOTTOM w0.076: CT16.2 268.96,48.48 arc(268.91,48.55) 268.9,48.64 268.9,48.95 arc(268.87,49.08) 268.8,49.19 arc(268.77,49.23) 268.76,49.29 268.76,49.67 arc(268.77,49.75) 268.82,49.82 268.83,49.83 arc(268.87,49.9) 268.89,49.97 268.89,50.15 arc(268.86,50.29) 268.78,50.42 URT2.E2
TBT_2_TRX_C_RD_DTX_P0: length 2.5
  BOTTOM w0.076: CT11.2 267.69,48.48 arc(267.64,48.55) 267.63,48.64 267.63,48.78 arc(267.63,48.81) 267.65,48.83 267.75,48.93 arc(267.81,49.02) 267.83,49.12 267.83,49.65 267.83,49.66 arc(267.85,49.74) 267.89,49.81 267.91,49.82 arc(267.95,49.9) 267.97,49.98 267.97,50.17 arc(267.96,50.21) 267.94,50.25 arc(267.86,50.28) 267.78,50.25 arc(267.75,50.2) 267.74,50.15 267.74,50.15 URT2.G1
TBT_2_TRX_C_RD_DTX_P1: length 2.4
  BOTTOM w0.076: CT15.2 268.63,48.48 arc(268.68,48.55) 268.7,48.64 268.7,48.95 arc(268.69,49.01) 268.66,49.05 arc(268.59,49.16) 268.56,49.29 268.56,49.68 arc(268.54,49.75) 268.5,49.82 268.49,49.83 arc(268.45,49.9) 268.43,49.97 268.43,50.13 arc(268.44,50.2) 268.48,50.26 arc(268.55,50.28) 268.62,50.26 268.62,50.25 arc(268.65,50.21) 268.66,50.15 URT2.E1
TBT_2_TRX_DTX_N0: length 179.1
  IN1 w0.076: v4(146.56,59.25) 146.56,59.05 arc(146.57,59.01) 146.59,58.98 146.6,58.97 arc(146.63,58.95) 146.66,58.95 146.87,58.95 arc(146.9,58.95) 146.92,58.97 147.01,59.06 arc(147.03,59.08) 147.03,59.11 147.03,59.28 arc(147.09,59.56) 147.25,59.81 147.3,59.85 arc(147.44,59.95) 147.61,59.98 148.61,59.98 arc(148.86,60.03) 149.07,60.17 151.4,62.51 arc(151.81,62.78) 152.3,62.88 153.04,62.88 154.17,62.68 155.28,62.88 156.35,62.69 157.63,62.92 158.26,62.8 159.55,63.03 161.88,63.03 arc(161.98,63.05) 162.06,63.1 arc(162.74,63.56) 163.54,63.72 164.35,63.72 165.96,63.43 167.44,63.69 169.29,63.37 171.27,63.72 172.72,63.72 arc(173.1,63.65) 173.43,63.45 173.43,63.45 176.41,60.48 arc(177.04,60.06) 177.78,59.91 179.18,59.91 arc(180.1,59.73) 180.88,59.21 180.96,59.13 arc(182.2,58.3) 183.67,58.01 arc(184.83,57.78) 185.81,57.12 189.73,53.2 arc(190.08,52.67) 190.21,52.04 190.21,51.98 arc(190.27,51.66) 190.46,51.38 191.15,50.69 arc(191.36,50.38) 191.43,50.02 191.43,49.84 arc(191.52,49.41) 191.76,49.03 195.91,44.89 arc(196.15,44.73) 196.43,44.67 arc(197.07,44.54) 197.6,44.19 198.38,43.41 arc(198.56,43.29) 198.78,43.25 199.82,43.25 arc(200.23,43.17) 200.58,42.93 203.58,39.93 arc(204.19,39.02) 204.41,37.94 204.41,36.68 arc(204.44,36.5) 204.55,36.35 204.82,36.07 arc(205.36,35.19) 205.55,34.17 205.55,28.85 arc(205.34,27.79) 204.74,26.89 204.67,26.82 arc(204.38,26.39) 204.28,25.87 204.28,23.82 arc(204.37,23.35) 204.63,22.96 208.57,19.02 arc(208.91,18.79) 209.31,18.71 211.19,18.71 arc(211.85,18.58) 212.4,18.21 arc(212.83,17.92) 213.34,17.82 213.7,17.82 arc(214.29,17.71) 214.79,17.37 arc(215.36,16.99) 216.03,16.86 218.78,16.86 arc(219.32,16.97) 219.78,17.27 219.83,17.32 arc(220.11,17.5) 220.44,17.57 223.82,17.57 arc(223.95,17.54) 224.07,17.47 arc(224.15,17.41) 224.25,17.39 225.97,17.39 227.13,17.19 228.31,17.4 229.65,17.16 231.1,17.42 232.61,17.15 233.99,17.39 235.26,17.17 236.66,17.41 237.53,17.26 238.81,17.26 arc(239.92,17.48) 240.87,18.11 241.58,18.82 arc(241.71,18.91) 241.86,18.94 241.88,18.94 arc(241.88,18.95) 241.88,18.95 242.75,19.82 arc(243.41,20.26) 244.19,20.41 245.67,20.41 arc(245.87,20.37) 246.04,20.26 246.15,20.15 arc(246.29,20.06) 246.44,20.03 246.88,20.03 arc(247.06,20.06) 247.21,20.17 253.17,26.13 arc(253.53,26.37) 253.96,26.45 260.06,26.45 arc(260.38,26.52) 260.66,26.7 262.36,28.4 arc(262.63,28.58) 262.94,28.64 263.4,28.64 arc(263.6,28.68) 263.77,28.8 265.08,30.1 arc(265.31,30.26) 265.58,30.31 266.04,30.31 arc(266.21,30.35) 266.36,30.45 267.22,31.31 arc(267.5,31.5) 267.84,31.56 268.75,31.56 arc(268.96,31.61) 269.13,31.72 269.39,31.98 arc(269.48,32.12) 269.51,32.28 269.51,32.28 arc(269.58,32.61) 269.77,32.89 269.82,32.94 arc(270.06,33.31) 270.15,33.74 270.15,35.32 arc(270.31,36.15) 270.78,36.86 270.89,36.96 arc(271,37.12) 271.04,37.32 271.04,40.41 arc(270.86,41.29) 270.36,42.04 270.14,42.26 arc(269.98,42.5) 269.93,42.78 269.93,43.34 arc(269.89,43.55) 269.77,43.72 269.46,44.03 arc(269.4,44.07) 269.33,44.09 arc(269.17,44.12) 269.03,44.21 267.71,45.53 arc(267.56,45.76) 267.5,46.03 267.5,46.82 arc(267.5,46.86) 267.49,46.91 arc(267.47,46.95) 267.44,46.98 v5(267.23,47.19)
  BOTTOM w0.081: v5(267.23,47.19) 267.38,47.33 arc(267.41,47.38) 267.43,47.44 267.43,47.46 arc(267.41,47.52) 267.38,47.57 CT12.1 ; UC1.BL1 v4(146.56,59.25)

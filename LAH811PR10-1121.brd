# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_2_TRX_DTX_N1: length 177.8
  IN1 w0.076: v5(269.09,47.19) 268.99,47.08 arc(268.94,47.01) 268.92,46.92 268.92,46.75 arc(268.94,46.66) 268.99,46.59 269.2,46.37 arc(269.32,46.2) 269.36,46 269.36,45.83 arc(269.44,45.42) 269.67,45.07 270.68,44.06 arc(270.81,43.87) 270.85,43.63 270.85,43.02 arc(270.88,42.9) 270.94,42.8 271.17,42.58 arc(271.73,41.75) 271.92,40.76 271.92,37.07 arc(271.84,36.65) 271.6,36.3 arc(271.18,35.67) 271.03,34.92 271.03,33.5 arc(270.91,32.89) 270.56,32.36 270.56,32.36 arc(270.44,32.18) 270.4,31.97 270.4,31.97 arc(270.34,31.69) 270.19,31.45 269.63,30.9 arc(269.39,30.74) 269.1,30.68 268.74,30.68 arc(268.42,30.62) 268.14,30.43 arc(268.07,30.32) 268.04,30.2 268.04,29.84 arc(267.98,29.52) 267.8,29.26 267.44,28.9 arc(267.32,28.82) 267.18,28.79 265.28,28.79 arc(265.03,28.74) 264.81,28.59 264.21,28 arc(263.95,27.82) 263.64,27.76 263.21,27.76 arc(262.98,27.71) 262.79,27.58 261.09,25.89 261.06,25.86 arc(260.74,25.64) 260.36,25.57 254.22,25.57 arc(253.88,25.5) 253.6,25.32 247.57,19.29 arc(247.38,19.15) 247.14,19.11 246.16,19.11 arc(246.06,19.09) 245.97,19.03 245.81,18.86 arc(245.58,18.71) 245.32,18.66 242.98,18.66 arc(242.85,18.63) 242.74,18.56 242.31,18.13 arc(242.23,18.08) 242.15,18.06 242.1,18.06 arc(242.09,18.06) 242.08,18.06 241.49,17.47 arc(240.29,16.66) 238.87,16.38 237.16,16.38 236.56,16.49 235.24,16.25 233.98,16.47 232.58,16.23 231.12,16.49 229.73,16.24 228.31,16.49 227.11,16.28 225.92,16.49 224.57,16.49 arc(224.19,16.41) 223.86,16.2 223.62,15.95 arc(223.42,15.82) 223.18,15.77 216.08,15.77 arc(215.19,15.95) 214.44,16.45 arc(213.93,16.79) 213.32,16.91 213.03,16.91 arc(212.47,17.02) 212,17.34 211.9,17.44 arc(211.47,17.73) 210.97,17.83 209.24,17.83 arc(208.55,17.97) 207.96,18.36 203.86,22.46 arc(203.49,23.01) 203.37,23.65 203.37,25.91 arc(203.53,26.72) 203.99,27.41 204.1,27.52 arc(204.52,28.15) 204.66,28.88 204.66,33.95 arc(204.48,34.84) 203.98,35.6 arc(203.64,36.1) 203.52,36.69 203.52,37.23 arc(203.45,37.6) 203.24,37.91 199.08,42.07 198.98,42.17 arc(198.81,42.28) 198.62,42.32 198.44,42.32 arc(198.17,42.38) 197.94,42.53 197.92,42.55 197.03,43.44 arc(196.69,43.67) 196.28,43.75 arc(195.78,43.89) 195.36,44.19 190.94,48.62 arc(190.65,49.05) 190.54,49.56 190.54,49.56 arc(190.46,50.01) 190.2,50.39 189.6,50.99 arc(189.39,51.3) 189.32,51.67 189.32,51.78 arc(189.21,52.32) 188.91,52.78 185.35,56.33 arc(184.48,56.92) 183.45,57.12 183.45,57.12 arc(181.8,57.45) 180.41,58.38 180.17,58.62 arc(179.72,58.93) 179.18,59.03 177.77,59.03 arc(176.7,59.24) 175.79,59.85 173.01,62.63 arc(172.83,62.75) 172.63,62.79 171.11,62.79 169.29,62.47 167.44,62.8 165.96,62.53 164.28,62.83 163.56,62.83 arc(163.1,62.74) 162.7,62.47 162.52,62.29 arc(162.34,62.17) 162.13,62.13 159.97,62.13 arc(159.22,61.99) 158.58,61.57 158.57,61.56 158.11,61.24 157.02,61.04 154.78,61.44 153.34,61.19 152.05,61.19 arc(151.38,61.05) 150.82,60.67 148.92,58.78 arc(148.74,58.66) 148.54,58.62 v4(147.7,58.62)
  BOTTOM w0.081: UC1.BM2 v4(147.7,58.62) ; CT16.1 268.95,47.57 arc(268.91,47.52) 268.9,47.46 268.9,47.44 arc(268.91,47.38) 268.95,47.33 v5(269.09,47.19)
TBT_2_TRX_DTX_P0: length 179.2
  IN1 w0.076: v4(146.55,58.61) 146.63,58.68 arc(146.7,58.73) 146.78,58.75 146.87,58.75 arc(146.97,58.77) 147.06,58.83 147.15,58.92 arc(147.21,59.01) 147.23,59.11 147.23,59.28 arc(147.27,59.49) 147.39,59.66 147.44,59.71 arc(147.52,59.77) 147.61,59.78 148.61,59.78 arc(148.93,59.85) 149.21,60.03 151.54,62.37 arc(151.89,62.6) 152.3,62.68 153.02,62.68 154.17,62.48 155.28,62.68 156.35,62.49 157.63,62.71 158.26,62.6 159.57,62.83 161.88,62.83 arc(162.05,62.87) 162.2,62.96 arc(162.81,63.37) 163.54,63.52 164.34,63.52 165.96,63.23 167.44,63.49 169.29,63.17 171.28,63.52 172.72,63.52 arc(173.03,63.46) 173.3,63.3 173.33,63.28 176.27,60.34 arc(176.96,59.87) 177.78,59.71 179.18,59.71 arc(180.03,59.54) 180.74,59.07 180.82,58.99 arc(182.13,58.11) 183.67,57.81 183.67,57.81 arc(184.75,57.59) 185.67,56.98 189.59,53.06 arc(189.9,52.6) 190.01,52.04 190.01,51.98 arc(190.09,51.58) 190.32,51.24 191.01,50.55 arc(191.17,50.31) 191.23,50.02 191.23,49.84 arc(191.33,49.33) 191.62,48.89 195.77,44.75 arc(196.07,44.54) 196.43,44.47 arc(196.99,44.36) 197.46,44.05 198.24,43.27 arc(198.48,43.11) 198.78,43.05 199.82,43.05 arc(200.16,42.98) 200.44,42.79 203.44,39.79 arc(204.01,38.94) 204.21,37.94 204.21,36.68 arc(204.26,36.43) 204.41,36.21 204.68,35.94 arc(205.18,35.12) 205.35,34.17 205.35,28.85 arc(205.16,27.87) 204.6,27.03 204.53,26.96 arc(204.19,26.46) 204.08,25.87 204.08,23.82 arc(204.19,23.28) 204.49,22.82 208.43,18.88 arc(208.84,18.61) 209.31,18.51 211.19,18.51 arc(211.77,18.4) 212.26,18.07 arc(212.76,17.74) 213.34,17.63 213.7,17.63 arc(214.22,17.52) 214.65,17.23 arc(215.28,16.81) 216.03,16.66 218.78,16.66 arc(219.4,16.78) 219.92,17.13 219.97,17.17 arc(220.18,17.32) 220.44,17.37 223.82,17.37 arc(223.88,17.36) 223.93,17.33 arc(224.08,17.23) 224.25,17.19 225.95,17.19 227.13,16.99 228.31,17.19 229.65,16.96 231.1,17.21 232.61,16.95 233.99,17.19 235.26,16.97 236.66,17.21 237.52,17.06 238.81,17.06 arc(240,17.3) 241.01,17.97 241.72,18.68 arc(241.78,18.73) 241.86,18.74 241.95,18.74 241.98,18.77 arc(242,18.79) 242.02,18.81 242.89,19.68 arc(243.49,20.08) 244.19,20.22 245.67,20.22 arc(245.79,20.19) 245.9,20.12 246.01,20.01 arc(246.21,19.88) 246.44,19.83 246.88,19.83 arc(247.13,19.88) 247.35,20.03 253.31,25.99 arc(253.61,26.19) 253.96,26.26 260.06,26.26 arc(260.46,26.34) 260.8,26.56 262.5,28.26 arc(262.7,28.4) 262.94,28.45 263.4,28.45 arc(263.67,28.5) 263.91,28.66 265.22,29.96 arc(265.39,30.08) 265.58,30.12 266.04,30.12 arc(266.29,30.17) 266.5,30.31 267.36,31.17 arc(267.58,31.32) 267.84,31.37 268.75,31.37 arc(269.03,31.42) 269.27,31.58 269.53,31.84 arc(269.66,32.04) 269.71,32.28 269.71,32.28 arc(269.76,32.53) 269.91,32.75 269.96,32.8 arc(270.25,33.23) 270.35,33.74 270.35,35.32 arc(270.5,36.07) 270.93,36.72 271.03,36.82 arc(271.18,37.05) 271.24,37.32 271.24,40.41 arc(271.04,41.37) 270.5,42.18 270.28,42.4 arc(270.17,42.57) 270.13,42.78 270.13,43.34 arc(270.07,43.62) 269.91,43.86 269.6,44.17 arc(269.48,44.26) 269.33,44.29 arc(269.24,44.3) 269.17,44.35 267.85,45.67 arc(267.74,45.83) 267.7,46.03 267.7,46.9 arc(267.73,47.06) v5(267.82,47.19)
  BOTTOM w0.081: UC1.BL2 v4(146.55,58.61) ; v5(267.82,47.19) 267.68,47.33 arc(267.64,47.38) 267.63,47.44 267.63,47.46 arc(267.64,47.52) 267.68,47.57 CT11.1
TBT_2_TRX_DTX_P1: length 177.9
  IN1 w0.076: v5(268.5,47.19) 268.66,47.03 arc(268.71,46.96) 268.72,46.87 268.72,46.75 arc(268.76,46.59) 268.85,46.44 269.06,46.23 arc(269.13,46.13) 269.16,46 269.16,45.83 arc(269.26,45.34) 269.53,44.93 270.54,43.92 arc(270.62,43.79) 270.66,43.63 270.66,43.02 arc(270.69,42.83) 270.8,42.66 271.03,42.44 arc(271.54,41.67) 271.72,40.76 271.72,37.07 arc(271.66,36.73) 271.46,36.44 arc(271,35.74) 270.83,34.92 270.83,33.5 arc(270.73,32.96) 270.42,32.5 270.42,32.5 arc(270.26,32.26) 270.2,31.97 270.2,31.97 arc(270.16,31.76) 270.04,31.59 269.49,31.04 arc(269.31,30.92) 269.1,30.88 268.74,30.88 arc(268.34,30.8) 268,30.57 arc(267.88,30.4) 267.85,30.2 267.85,29.84 arc(267.8,29.6) 267.66,29.4 267.3,29.04 arc(267.25,29) 267.18,28.99 265.28,28.99 arc(264.95,28.92) 264.67,28.73 264.07,28.14 arc(263.88,28) 263.64,27.96 263.21,27.96 arc(262.9,27.9) 262.65,27.72 260.95,26.03 260.92,26 arc(260.66,25.83) 260.36,25.77 254.22,25.77 arc(253.81,25.69) 253.46,25.46 247.43,19.43 arc(247.3,19.34) 247.14,19.3 246.16,19.3 arc(245.98,19.27) 245.83,19.17 245.67,19 arc(245.51,18.9) 245.32,18.86 242.98,18.86 arc(242.77,18.82) 242.6,18.7 242.35,18.45 242.17,18.27 arc(242.16,18.26) 242.15,18.26 242.1,18.26 arc(242.01,18.24) 241.94,18.2 241.35,17.61 arc(240.21,16.85) 238.87,16.58 237.18,16.58 236.56,16.69 235.24,16.45 233.98,16.68 232.58,16.43 231.12,16.69 229.73,16.44 228.31,16.69 227.11,16.48 225.94,16.69 224.57,16.69 arc(224.11,16.59) 223.72,16.34 223.48,16.09 arc(223.34,16) 223.18,15.97 216.08,15.97 arc(215.27,16.13) 214.58,16.59 arc(214,16.98) 213.33,17.11 213.03,17.11 arc(212.55,17.21) 212.14,17.48 212.04,17.58 arc(211.55,17.91) 210.97,18.03 209.24,18.03 arc(208.62,18.15) 208.1,18.5 204,22.6 arc(203.68,23.08) 203.56,23.65 203.56,25.91 arc(203.71,26.65) 204.13,27.27 204.24,27.38 arc(204.7,28.07) 204.86,28.88 204.86,33.95 arc(204.67,34.92) 204.12,35.74 arc(203.82,36.18) 203.72,36.69 203.72,37.23 arc(203.63,37.68) 203.38,38.05 199.36,42.07 199.12,42.31 arc(198.89,42.47) 198.62,42.52 198.44,42.52 arc(198.24,42.56) 198.08,42.67 198.06,42.69 197.17,43.58 arc(196.77,43.85) 196.29,43.94 arc(195.87,44.07) 195.5,44.33 191.08,48.76 arc(190.83,49.13) 190.74,49.56 190.74,49.56 arc(190.64,50.09) 190.34,50.53 189.74,51.13 arc(189.58,51.38) 189.52,51.67 189.52,51.78 arc(189.4,52.4) 189.05,52.92 185.49,56.47 arc(184.56,57.1) 183.45,57.32 183.45,57.32 arc(181.88,57.63) 180.55,58.52 180.31,58.76 arc(179.79,59.11) 179.18,59.23 177.77,59.23 arc(176.77,59.43) 175.93,59.99 173.15,62.77 arc(172.91,62.93) 172.63,62.99 171.09,62.99 169.29,62.67 167.44,63 165.96,62.74 164.29,63.03 163.56,63.03 arc(163.02,62.92) 162.56,62.61 162.38,62.43 arc(162.27,62.36) 162.13,62.33 159.97,62.33 arc(159.14,62.17) 158.44,61.71 158.03,61.43 157.02,61.25 154.78,61.64 153.32,61.38 152.05,61.38 arc(151.31,61.24) 150.68,60.81 148.78,58.92 arc(148.67,58.84) 148.54,58.82 148.17,58.82 arc(148.13,58.82) 148.11,58.84 148.1,58.85 arc(148.08,58.88) 148.07,58.91 148.07,59.17 arc(148.05,59.24) 147.98,59.26 v4(147.69,59.26)
  BOTTOM w0.081: UC1.BM1 v4(147.69,59.26) ; v5(268.5,47.19) 268.65,47.33 arc(268.68,47.38) 268.7,47.44 268.7,47.46 arc(268.68,47.52) 268.65,47.57 CT15.1
TBT_2_TRX_RD_DTX_N1: length 26.9
  TOP w0.081: v5(284.04,67.43) 283.92,67.55 arc(283.84,67.6) 283.75,67.62 281.73,67.62 arc(281.41,67.56) 281.14,67.37 arc(281.04,67.31) 280.93,67.29 280.8,67.29 arc(280.7,67.27) 280.63,67.22 v2(280.48,67.07)
  IN1 w0.076: v2(280.48,67.07) 280.48,67.31 arc(280.44,67.39) 280.35,67.41 arc(280.26,67.39) 280.16,67.38 280.1,67.38 arc(279.61,67.28) 279.19,67 278.73,66.54 arc(278.2,65.75) 278.02,64.83 278.02,63.48 arc(277.92,63) 277.65,62.59 275.2,60.14 arc(274.86,59.91) 274.46,59.83 270.75,59.83 arc(269.39,59.56) 268.24,58.79 267.57,58.12 267.12,57.68 arc(266.98,57.47) 266.93,57.22 266.93,57.02 arc(266.95,56.94) 267,56.86 v4(267.1,56.76)
  BOTTOM w0.076: 267.05,56.71 266.99,56.65 266.93,56.53 266.93,56.29 266.93,55.55 arc(266.95,55.48) 266.99,55.42 267,55.41 arc(267.04,55.35) 267.05,55.28 267.05,55 arc(267.03,54.91) 266.98,54.84 266.92,54.77 URT2.J11
  BOTTOM w0.081: JUSBC2.B10 284.07,67.4 v5(284.04,67.43) ; 267.05,56.71 v4(267.1,56.76)
TBT_2_TRX_RD_DTX_N2: length 19
  IN3 w0.076: v4(269.39,56.08) 269.41,56.1 arc(269.46,56.18) 269.48,56.28 269.48,56.95 arc(269.57,57.41) 269.83,57.79 270.25,58.21 arc(271.54,59.07) 273.05,59.37 275.09,59.37 arc(275.49,59.45) 275.83,59.68 278.21,62.06 arc(278.95,62.56) 279.83,62.73 280.01,62.73 arc(280.14,62.74) 280.26,62.78 arc(280.39,62.84) v4(280.51,62.93)
  BOTTOM w0.076: v4(269.39,56.08) 269.44,56.03 arc(269.47,55.98) 269.48,55.93 269.48,55.54 arc(269.47,55.46) 269.42,55.39 269.41,55.38 arc(269.37,55.32) 269.35,55.24 269.35,55.06 arc(269.38,54.92) 269.46,54.79 URT2.C11
  BOTTOM w0.081: JUSBC2.A10 282.88,63.65 arc(282.79,63.63) 282.71,63.58 282.7,63.57 arc(282.63,63.52) 282.54,63.5 282.46,63.5 arc(282.28,63.47) 282.12,63.36 v7(281.87,63.11) 281.59,62.83 arc(281.47,62.75) 281.32,62.72 280.82,62.72 arc(280.73,62.74) 280.65,62.79 v4(280.51,62.93)
TBT_2_TRX_RD_DTX_P1: length 27
  TOP w0.081: v2(280.48,67.71) 280.63,67.56 arc(280.7,67.51) 280.8,67.49 280.93,67.49 arc(280.97,67.5) 280.99,67.52 arc(281.33,67.74) 281.73,67.82 283.75,67.82 arc(283.84,67.84) 283.92,67.89 v5(284.04,68.01)
  IN1 w0.076: v4(266.57,56.76) 266.67,56.86 arc(266.72,56.94) 266.74,57.02 266.74,57.22 arc(266.8,57.54) 266.98,57.82 267.43,58.26 268.1,58.93 arc(269.32,59.75) 270.75,60.03 274.46,60.03 arc(274.78,60.1) 275.05,60.28 277.51,62.73 arc(277.74,63.08) 277.82,63.48 277.82,64.83 arc(278.02,65.83) 278.59,66.68 279.05,67.14 arc(279.53,67.46) 280.1,67.58 280.16,67.58 arc(280.23,67.58) 280.29,67.6 arc(280.39,67.64) v2(280.48,67.71)
  BOTTOM w0.076: 266.62,56.71 266.74,56.6 266.74,56.37 266.74,56.37 266.74,55.56 266.73,55.56 arc(266.72,55.47) 266.67,55.4 266.66,55.39 arc(266.61,55.31) 266.59,55.23 266.59,55.04 arc(266.6,55) 266.62,54.97 arc(266.7,54.93) 266.78,54.97 arc(266.81,55.01) 266.82,55.06 266.82,55.07 URT2.J12
  BOTTOM w0.081: v5(284.04,68.01) 284.1,67.95 arc(284.16,67.91) 284.22,67.9 JUSBC2.B11 ; v4(266.57,56.76) 266.58,56.75 266.58,56.75 266.62,56.71
TBT_2_TRX_RD_DTX_P2: length 19
  IN3 w0.076: v4(269.77,56.08) 269.76,56.08 269.7,56.14 arc(269.69,56.16) 269.68,56.18 269.68,56.95 arc(269.76,57.33) 269.97,57.65 270.39,58.07 arc(271.61,58.89) 273.05,59.17 275.09,59.17 arc(275.56,59.27) 275.97,59.54 278.35,61.92 arc(279.03,62.37) 279.83,62.53 280.01,62.53 arc(280.17,62.55) 280.33,62.59 arc(280.45,62.58) 280.51,62.47 v4(280.51,62.3)
  BOTTOM w0.076: v4(269.77,56.08) 269.72,56.03 arc(269.69,55.98) 269.68,55.93 269.68,55.53 arc(269.7,55.46) 269.74,55.39 269.75,55.38 arc(269.8,55.31) 269.81,55.24 269.81,55.05 arc(269.78,54.96) 269.7,54.93 arc(269.61,54.96) 269.58,55.04 URT2.C12
  BOTTOM w0.081: JUSBC2.A11 282.92,63.15 arc(282.83,63.17) 282.75,63.22 282.74,63.23 arc(282.67,63.28) 282.58,63.3 282.46,63.3 arc(282.35,63.28) 282.27,63.22 281.73,62.69 arc(281.54,62.56) 281.32,62.51 280.73,62.51 arc(280.64,62.5) 280.56,62.47 280.51,62.43 arc(280.51,62.42) 280.51,62.41 v4(280.51,62.3)
TBT_2_TTX_C_DRX_N1: length 2.6
  BOTTOM w0.081: CT39.2 280.81,67.23 arc(280.89,67.28) 280.99,67.3 282.53,67.3 arc(282.62,67.28) 282.69,67.23 282.7,67.22 arc(282.78,67.17) 282.87,67.15 JUSBC2.A3
TBT_2_TTX_C_DRX_N2: length 3.3
  TOP w0.081: CT41.2 282.24,62.8 arc(282.32,62.74) 282.42,62.73 282.62,62.73 arc(282.65,62.73) 282.68,62.75 283.42,63.5 arc(283.52,63.56) 283.63,63.58 283.77,63.58 arc(283.86,63.6) 283.94,63.65 v5(284.06,63.77)
  BOTTOM w0.081: JUSBC2.B3 284.27,63.9 arc(284.2,63.88) 284.13,63.84 v5(284.06,63.77)
TBT_2_TTX_C_DRX_P1: length 2.6
  BOTTOM w0.081: CT38.2 280.83,67.57 arc(280.91,67.52) 281.01,67.5 v7(281.83,67.5) 282.53,67.5 arc(282.62,67.52) 282.7,67.57 282.71,67.58 arc(282.78,67.63) 282.87,67.65 JUSBC2.A2
TBT_2_TTX_C_DRX_P2: length 3.3
  TOP w0.081: v5(284.06,63.19) 283.94,63.31 arc(283.86,63.36) 283.77,63.38 283.63,63.38 arc(283.59,63.37) 283.57,63.35 282.82,62.61 arc(282.73,62.54) 282.62,62.52 282.42,62.52 arc(282.32,62.5) 282.24,62.45 CT40.2
  BOTTOM w0.081: JUSBC2.B2 284.38,63.4 arc(284.28,63.38) 284.2,63.33 v5(284.06,63.19)
TBT_2_TTX_C_RD_DRX_N0: length 2.6
  BOTTOM w0.076: CT10.2 266.4,48.5 arc(266.37,48.55) 266.36,48.61 266.36,48.68 arc(266.36,48.7) 266.37,48.72 266.73,49.08 arc(266.87,49.29) 266.92,49.54 266.92,49.67 arc(266.93,49.75) 266.98,49.82 266.99,49.83 arc(267.03,49.9) 267.05,49.97 267.05,50.15 arc(267.02,50.29) 266.94,50.42 URT2.J2
TBT_2_TTX_C_RD_DRX_N1: length 2.6
  BOTTOM w0.076: CT14.2 269.91,48.48 arc(269.95,48.55) 269.97,48.63 269.97,48.71 arc(269.96,48.75) 269.93,48.79 269.62,49.1 arc(269.51,49.27) 269.47,49.47 269.47,49.66 arc(269.46,49.73) 269.42,49.79 269.41,49.8 arc(269.37,49.86) 269.35,49.93 269.35,50.21 arc(269.37,50.3) 269.42,50.37 URT2.C2
TBT_2_TTX_C_RD_DRX_P0: length 2.6
  BOTTOM w0.076: CT9.2 266.09,48.48 arc(266.14,48.55) 266.16,48.64 266.16,48.68 arc(266.18,48.78) 266.23,48.86 266.59,49.22 arc(266.69,49.37) 266.72,49.54 266.72,49.68 arc(266.7,49.75) 266.66,49.82 266.65,49.83 arc(266.61,49.9) 266.59,49.97 266.59,50.13 arc(266.6,50.2) 266.64,50.26 arc(266.71,50.28) 266.78,50.26 266.78,50.25 arc(266.81,50.21) 266.82,50.15 URT2.J1
TBT_2_TTX_C_RD_DRX_P1: length 2.6
  BOTTOM w0.076: CT13.2 270.23,48.48 arc(270.18,48.55) 270.17,48.64 270.17,48.71 arc(270.14,48.83) 270.07,48.93 269.76,49.25 arc(269.69,49.35) 269.67,49.47 269.67,49.65 269.67,49.66 arc(269.69,49.74) 269.73,49.81 269.75,49.82 arc(269.8,49.9) 269.81,49.98 269.81,50.17 arc(269.8,50.21) 269.78,50.25 arc(269.7,50.28) 269.62,50.25 arc(269.59,50.2) 269.58,50.15 269.58,50.14 URT2.C1
TBT_2_TTX_DRX_N0: length 181.1
  IN1 w0.076: v4(144.49,56.34) 144.5,56.34 arc(144.78,56.42) 144.98,56.65 arc(145.01,56.75) 145.02,56.86 145.02,56.98 arc(145.05,57.11) 145.12,57.22 145.28,57.38 arc(145.31,57.4) 145.34,57.4 145.45,57.4 arc(145.55,57.42) 145.64,57.48 145.86,57.7 arc(145.92,57.79) 145.94,57.89 145.94,59.16 arc(146.04,59.7) 146.35,60.15 146.35,60.15 arc(146.7,60.39) 147.13,60.47 148.35,60.47 arc(148.66,60.54) 148.92,60.71 151.13,62.92 arc(151.63,63.25) 152.22,63.37 153.08,63.37 154.17,63.18 155.28,63.38 156.35,63.19 157.63,63.42 158.15,63.32 arc(158.19,63.32) 158.23,63.32 159.3,63.51 161.3,63.51 arc(161.74,63.59) 162.12,63.79 162.21,63.85 arc(162.75,64.12) 163.35,64.21 164.4,64.21 165.96,63.93 167.44,64.19 169.29,63.87 171.22,64.21 172.71,64.21 arc(173.34,64.08) 173.86,63.73 173.92,63.67 176.7,60.89 arc(177.26,60.52) 177.91,60.39 179.39,60.39 arc(180.33,60.21) 181.12,59.68 181.26,59.53 arc(182.42,58.76) 183.79,58.49 arc(185.05,58.24) 186.12,57.52 190.52,53.12 arc(190.68,53.01) 190.87,52.98 arc(190.94,52.96) 191,52.92 191.5,52.42 arc(191.65,52.19) 191.71,51.92 191.71,50.98 arc(191.75,50.78) 191.86,50.61 191.86,50.61 arc(191.9,50.56) 191.91,50.5 191.91,50.02 arc(191.99,49.61) 192.23,49.26 196.05,45.44 arc(196.27,45.29) 196.53,45.23 arc(197.19,45.11) 197.74,44.74 198.5,43.97 arc(198.71,43.84) 198.95,43.79 200.03,43.79 arc(200.38,43.72) 200.69,43.51 203.92,40.28 arc(204.66,39.17) 204.92,37.87 204.92,36.93 arc(204.97,36.68) 205.11,36.48 205.42,36.16 arc(205.88,35.49) 206.03,34.69 206.03,28.63 arc(205.82,27.56) 205.22,26.66 205.02,26.46 arc(204.83,26.18) 204.76,25.84 204.76,23.91 arc(204.83,23.57) 205.03,23.27 208.97,19.33 arc(209.11,19.23) 209.29,19.2 211.31,19.2 arc(212.09,19.05) 212.74,18.61 212.74,18.61 arc(213.01,18.43) 213.33,18.36 213.87,18.36 arc(214.44,18.25) 214.92,17.92 214.98,17.86 arc(215.56,17.48) 216.24,17.34 218.48,17.34 arc(218.95,17.43) 219.35,17.7 arc(219.75,17.97) 220.22,18.06 224.05,18.06 arc(224.08,18.06) 224.1,18.04 arc(224.27,17.93) 224.46,17.89 226.05,17.89 227.13,17.7 228.29,17.91 229.66,17.66 231.07,17.91 231.77,17.79 232.53,17.66 233.99,17.91 235.34,17.67 236.73,17.92 237.69,17.75 238.69,17.75 arc(239.66,17.94) 240.49,18.49 241.38,19.38 arc(241.43,19.42) 241.48,19.43 241.51,19.43 arc(241.64,19.45) 241.75,19.53 242.5,20.27 arc(242.63,20.39) 242.79,20.49 244.26,21.28 244.43,21.45 244.43,21.45 arc(245.03,21.85) 245.73,21.99 248.04,21.99 arc(248.17,22.01) 248.27,22.08 252.85,26.66 arc(253.16,26.87) 253.53,26.94 259.94,26.94 arc(260.19,26.99) 260.4,27.13 262.28,29.01 arc(262.44,29.12) 262.62,29.15 263.21,29.15 arc(263.42,29.19) 263.6,29.32 264.98,30.69 arc(265.13,30.8) 265.32,30.83 265.77,30.83 arc(265.97,30.87) 266.14,30.99 267.16,32.01 arc(267.3,32.22) 267.35,32.47 267.35,32.47 arc(267.41,32.78) 267.59,33.05 269.58,35.04 arc(269.64,35.13) 269.66,35.23 269.66,35.64 arc(269.81,36.38) 270.23,37.01 270.25,37.03 arc(270.44,37.3) 270.54,37.61 270.55,37.62 270.55,39.95 arc(270.36,40.89) 269.83,41.68 268.52,42.99 arc(268.44,43.11) 268.41,43.26 268.41,43.26 268.41,43.68 arc(268.33,44.11) 268.09,44.47 266.93,45.63 arc(266.56,46.17) 266.43,46.82 266.43,46.99 arc(266.45,47.06) 266.48,47.12 v5(266.55,47.19)
  BOTTOM w0.081: CT10.1 266.41,47.57 arc(266.37,47.52) 266.36,47.46 266.36,47.44 arc(266.37,47.38) 266.41,47.33 v5(266.55,47.19)
TBT_2_TTX_DRX_N1: length 180.6
  IN1 w0.076: v4(146.69,57.36) 146.69,57.36 arc(146.88,57.28) 146.95,57.09 146.95,56.98 arc(146.97,56.93) 147.02,56.91 147.19,56.91 arc(147.22,56.91) 147.25,56.93 148.25,57.93 arc(148.5,58.1) 148.79,58.15 148.86,58.15 arc(148.98,58.18) 149.08,58.25 151.04,60.2 arc(151.55,60.55) 152.16,60.67 153.34,60.67 154.67,60.9 156.9,60.51 157.79,60.67 158.54,60.53 160.33,60.85 161.32,60.85 arc(161.33,60.85) 161.33,60.86 arc(161.41,60.9) 161.49,60.92 163.37,60.92 arc(163.57,60.96) 163.74,61.07 163.85,61.19 arc(164.32,61.5) 164.87,61.61 165.42,61.61 167.55,61.98 169.25,61.68 169.27,61.68 arc(172.42,61.48) 175.12,59.84 175.6,59.36 arc(176.49,58.76) 177.56,58.55 179.14,58.55 arc(179.53,58.47) 179.85,58.25 180.07,58.04 arc(181.62,57) 183.46,56.63 arc(184.02,56.52) 184.49,56.2 188.52,52.18 arc(188.73,51.86) 188.81,51.48 188.81,51.47 arc(188.88,51.13) 189.07,50.84 189.74,50.17 arc(189.97,49.82) 190.06,49.4 190.06,49.29 arc(190.14,48.85) 190.39,48.48 195.25,43.62 arc(195.73,43.29) 196.29,43.15 arc(196.6,43.09) 196.86,42.91 197.95,41.82 arc(198.14,41.69) 198.36,41.65 198.44,41.65 arc(198.78,41.58) 199.07,41.39 202.8,37.66 arc(202.96,37.42) 203.01,37.14 203.01,36.4 arc(203.01,36.34) 203.02,36.28 arc(203.14,35.8) 203.43,35.39 arc(203.98,34.56) 204.18,33.58 204.18,29.19 arc(204.01,28.36) 203.54,27.65 arc(203.04,26.89) 202.86,26 202.86,23.52 arc(202.99,22.83) 203.38,22.25 207.69,17.94 arc(208.39,17.47) 209.22,17.31 210.97,17.31 arc(211.32,17.24) 211.62,17.04 211.94,16.72 arc(212.27,16.5) 212.66,16.42 212.77,16.42 arc(213.5,16.28) 214.12,15.86 214.12,15.86 arc(214.75,15.44) 215.5,15.29 223.54,15.29 arc(223.75,15.33) 223.93,15.45 224.2,15.72 arc(224.44,15.88) 224.74,15.94 226.09,15.94 227.13,15.76 228.38,15.98 229.71,15.74 231.04,15.98 232.5,15.72 233.9,15.97 235.23,15.73 236.59,15.97 237.04,15.89 239.47,15.89 arc(240.58,16.11) 241.51,16.74 242.27,17.5 arc(242.35,17.55) 242.43,17.57 arc(242.55,17.59) 242.65,17.66 243.08,18.09 arc(243.17,18.15) 243.27,18.17 245.69,18.17 arc(245.84,18.2) 245.96,18.28 246.12,18.43 arc(246.33,18.57) 246.57,18.62 247.47,18.62 arc(248.73,18.87) 249.8,19.59 250.44,20.23 arc(250.49,20.3) 250.51,20.39 250.51,20.95 arc(250.61,21.46) 250.9,21.9 250.95,21.95 253.81,24.81 arc(254.11,25.01) 254.47,25.08 255.82,25.08 arc(256.25,25) 256.62,24.75 256.93,24.44 arc(257.12,24.31) 257.34,24.27 257.9,24.27 arc(258.22,24.33) 258.5,24.52 258.74,24.76 arc(259.08,24.98) 259.47,25.06 260.74,25.06 arc(260.93,25.1) 261.09,25.21 261.15,25.27 262.9,27.01 arc(263.16,27.19) 263.46,27.25 263.96,27.25 arc(264.16,27.29) 264.33,27.4 264.96,28.03 arc(265.26,28.24) 265.62,28.31 267.39,28.31 arc(268.38,28.5) 269.21,29.06 269.8,29.65 arc(270,29.94) 270.07,30.29 arc(270.12,30.55) 270.27,30.78 270.69,31.2 arc(270.85,31.44) 270.91,31.71 270.91,31.72 arc(270.96,31.98) 271.11,32.2 271.18,32.27 arc(271.43,32.65) 271.52,33.1 271.52,34.6 arc(271.64,35.23) 272,35.76 arc(272.3,36.21) 272.41,36.74 272.41,42.96 arc(272.36,43.2) 272.23,43.4 270.86,44.77 arc(270.2,45.75) 269.97,46.92 arc(269.95,47.01) 269.9,47.08 v5(269.77,47.21)
  BOTTOM w0.081: CT14.1 269.93,47.56 arc(269.95,47.52) 269.97,47.47 269.97,47.45 arc(269.96,47.4) 269.93,47.36 v5(269.77,47.21) ; UC1.BJ5 v4(146.69,57.36)
TBT_2_TTX_DRX_P0: length 181
  IN1 w0.076: v5(265.96,47.19) 266.17,46.98 arc(266.22,46.91) 266.23,46.82 arc(266.38,46.1) 266.79,45.49 267.95,44.33 arc(268.14,44.03) 268.21,43.68 268.21,43.26 arc(268.26,43.04) 268.38,42.85 269.69,41.54 arc(270.18,40.81) 270.35,39.95 270.35,37.76 270.35,37.76 arc(270.35,37.7) 270.34,37.64 arc(270.26,37.39) 270.11,37.17 270.09,37.15 arc(269.63,36.46) 269.46,35.64 269.46,35.23 arc(269.46,35.2) 269.44,35.18 267.45,33.19 arc(267.23,32.86) 267.15,32.47 267.15,32.47 arc(267.12,32.29) 267.02,32.15 266,31.13 arc(265.89,31.06) 265.77,31.03 265.32,31.03 arc(265.06,30.98) 264.84,30.83 263.46,29.46 arc(263.34,29.38) 263.21,29.35 262.62,29.35 arc(262.36,29.3) 262.14,29.15 260.26,27.27 arc(260.12,27.17) 259.94,27.14 253.53,27.14 arc(253.09,27.05) 252.71,26.8 248.13,22.22 arc(248.09,22.19) 248.04,22.18 245.73,22.18 arc(244.95,22.03) 244.29,21.59 244.14,21.44 242.69,20.66 arc(242.51,20.55) 242.36,20.41 241.61,19.67 arc(241.56,19.64) 241.51,19.63 241.48,19.63 arc(241.35,19.6) 241.24,19.52 240.35,18.63 arc(239.58,18.12) 238.69,17.95 237.71,17.95 236.73,18.12 235.34,17.87 233.99,18.11 232.53,17.86 231.07,18.11 229.66,17.87 228.29,18.11 227.13,17.9 226.07,18.09 224.46,18.09 arc(224.34,18.11) 224.25,18.18 arc(224.15,18.24) 224.05,18.26 220.22,18.26 arc(219.68,18.15) 219.21,17.84 arc(218.88,17.62) 218.48,17.54 216.24,17.54 arc(215.64,17.66) 215.13,18 215.06,18.06 arc(214.51,18.43) 213.87,18.56 213.33,18.56 arc(213.09,18.61) 212.88,18.75 arc(212.16,19.23) 211.31,19.4 209.29,19.4 arc(209.19,19.42) 209.11,19.47 205.17,23.41 arc(205.01,23.64) 204.96,23.91 204.96,25.84 arc(205.01,26.1) 205.16,26.32 205.36,26.52 arc(206,27.49) 206.23,28.63 206.23,34.69 arc(206.06,35.56) 205.56,36.3 205.25,36.62 arc(205.15,36.76) 205.12,36.93 205.12,37.87 arc(204.84,39.25) 204.06,40.42 200.83,43.65 arc(200.46,43.9) 200.03,43.99 198.95,43.99 arc(198.78,44.02) 198.64,44.11 197.88,44.88 arc(197.26,45.29) 196.53,45.43 arc(196.35,45.47) 196.19,45.58 192.37,49.4 arc(192.18,49.68) 192.11,50.02 192.11,50.5 arc(192.08,50.63) 192,50.75 arc(191.93,50.86) 191.91,50.98 191.91,51.92 arc(191.84,52.27) 191.64,52.56 191.14,53.06 arc(191.02,53.15) 190.87,53.18 arc(190.76,53.2) 190.66,53.26 186.26,57.66 arc(185.13,58.42) 183.79,58.69 arc(182.5,58.94) 181.41,59.67 181.26,59.82 arc(180.4,60.39) 179.39,60.59 177.91,60.59 arc(177.33,60.71) 176.84,61.03 174,63.87 arc(173.41,64.27) 172.71,64.41 171.21,64.41 169.29,64.07 167.44,64.4 165.96,64.13 165.19,64.27 164.41,64.41 163.35,64.41 arc(162.69,64.31) 162.1,64.02 162,63.95 arc(161.67,63.77) 161.3,63.71 159.28,63.71 158.19,63.52 arc(158.19,63.52) 158.19,63.52 157.63,63.62 156.35,63.39 155.28,63.58 154.17,63.38 153.1,63.57 152.22,63.57 arc(151.55,63.44) 150.99,63.06 148.78,60.85 arc(148.58,60.72) 148.35,60.67 147.13,60.67 arc(146.63,60.57) 146.21,60.29 arc(145.86,59.77) 145.74,59.16 145.74,57.89 arc(145.73,57.86) 145.72,57.84 145.5,57.62 arc(145.48,57.61) 145.45,57.6 145.34,57.6 arc(145.23,57.58) 145.14,57.52 144.98,57.36 arc(144.87,57.18) 144.82,56.98 144.82,56.86 arc(144.82,56.8) 144.8,56.73 arc(144.75,56.68) 144.69,56.66 144.66,56.66 arc(144.54,56.71) 144.49,56.83 v4(144.49,56.99)
  BOTTOM w0.081: v5(265.96,47.19) 266.11,47.33 arc(266.14,47.38) 266.16,47.44 266.16,47.46 arc(266.14,47.52) 266.11,47.57 CT9.1
TBT_2_TTX_DRX_P1: length 180.6
  IN1 w0.076: v5(270.36,47.21) 270.23,47.08 arc(270.18,47.01) 270.17,46.92 arc(270.38,45.83) 271,44.91 272.37,43.54 arc(272.54,43.27) 272.61,42.96 272.61,36.74 arc(272.49,36.14) 272.14,35.62 arc(271.83,35.15) 271.72,34.6 271.72,33.1 arc(271.61,32.57) 271.32,32.13 271.25,32.06 arc(271.14,31.9) 271.1,31.72 271.1,31.71 arc(271.03,31.36) 270.83,31.06 270.41,30.64 arc(270.3,30.48) 270.27,30.29 270.27,30.29 arc(270.18,29.87) 269.94,29.51 269.35,28.92 arc(268.45,28.32) 267.39,28.11 265.62,28.11 arc(265.34,28.05) 265.1,27.89 264.47,27.26 arc(264.23,27.1) 263.96,27.05 263.46,27.05 arc(263.23,27) 263.04,26.87 261.23,25.07 arc(261.01,24.92) 260.75,24.86 259.47,24.86 arc(259.15,24.8) 258.88,24.62 258.64,24.38 arc(258.3,24.15) 257.9,24.07 257.34,24.07 arc(257.04,24.13) 256.79,24.3 256.48,24.61 arc(256.18,24.81) 255.82,24.88 254.47,24.88 arc(254.19,24.83) 253.95,24.67 251.09,21.81 251.04,21.76 arc(250.79,21.39) 250.71,20.95 250.71,20.39 arc(250.67,20.23) 250.58,20.09 249.94,19.45 arc(248.81,18.69) 247.47,18.43 246.57,18.43 arc(246.4,18.39) 246.26,18.29 246.1,18.14 arc(245.91,18.01) 245.69,17.97 243.27,17.97 arc(243.24,17.97) 243.22,17.95 242.79,17.52 arc(242.62,17.41) 242.43,17.37 arc(242.42,17.37) 242.41,17.36 241.65,16.6 arc(240.65,15.93) 239.47,15.69 237.02,15.69 236.59,15.77 235.23,15.53 233.9,15.77 232.5,15.52 231.04,15.78 229.71,15.54 228.38,15.78 227.13,15.55 226.07,15.74 224.74,15.74 arc(224.52,15.7) 224.34,15.58 224.07,15.31 arc(223.83,15.15) 223.54,15.09 215.5,15.09 arc(214.68,15.25) 213.98,15.72 213.98,15.72 arc(213.42,16.09) 212.77,16.22 212.66,16.22 arc(212.19,16.32) 211.8,16.58 211.48,16.9 arc(211.24,17.06) 210.96,17.11 209.22,17.11 arc(208.32,17.29) 207.55,17.8 203.24,22.11 arc(202.81,22.76) 202.66,23.52 202.66,26 arc(202.85,26.97) 203.4,27.79 arc(203.83,28.43) 203.98,29.19 203.98,33.58 arc(203.8,34.48) 203.29,35.25 203.29,35.25 arc(202.96,35.71) 202.82,36.26 202.81,36.26 202.81,37.14 arc(202.77,37.35) 202.66,37.52 198.93,41.25 arc(198.7,41.4) 198.44,41.45 198.36,41.45 arc(198.06,41.51) 197.81,41.68 196.72,42.77 arc(196.52,42.9) 196.28,42.95 arc(195.65,43.11) 195.11,43.48 190.25,48.34 arc(189.96,48.77) 189.86,49.29 189.86,49.4 arc(189.79,49.74) 189.6,50.03 188.93,50.7 arc(188.69,51.05) 188.61,51.47 188.61,51.48 arc(188.55,51.78) 188.38,52.04 184.35,56.06 arc(183.94,56.34) 183.46,56.44 arc(181.55,56.82) 179.93,57.9 179.71,58.11 arc(179.45,58.29) 179.14,58.35 177.56,58.35 arc(176.42,58.58) 175.45,59.22 174.98,59.7 arc(172.36,61.29) 169.3,61.49 169.25,61.48 167.55,61.78 165.44,61.41 164.87,61.41 arc(164.39,61.31) 163.99,61.05 163.88,60.93 arc(163.64,60.78) 163.37,60.72 161.49,60.72 arc(161.48,60.72) 161.47,60.72 arc(161.4,60.67) 161.32,60.65 160.35,60.65 158.54,60.33 157.79,60.46 156.9,60.31 154.67,60.7 153.36,60.47 152.16,60.47 arc(151.63,60.36) 151.18,60.06 149.22,58.11 arc(149.06,57.99) 148.86,57.96 148.79,57.96 arc(148.57,57.91) 148.39,57.79 147.39,56.79 arc(147.3,56.73) 147.19,56.71 v4(146.69,56.71)
  BOTTOM w0.081: v5(270.36,47.21) 270.21,47.36 arc(270.18,47.4) 270.17,47.45 270.17,47.47 arc(270.18,47.52) 270.21,47.57 CT13.1 ; v4(146.69,56.71) UC1.BJ6
TBT_2_TTX_RD_DRX_N1: length 21.6
  IN3 w0.076: v4(279.34,67.07) 279.34,67.25 arc(279.29,67.35) 279.17,67.38 arc(279.1,67.36) 279.03,67.36 arc(278.87,67.33) 278.74,67.24 278.56,67.06 arc(278.4,66.82) 278.35,66.54 278.35,63.71 arc(278.22,63.09) 277.87,62.55 275.95,60.64 arc(275.4,60.27) 274.75,60.14 272.45,60.14 arc(270.67,59.79) 269.16,58.78 267.96,57.58 arc(267.88,57.46) 267.86,57.32 267.86,56.22 arc(267.87,56.17) 267.9,56.12 v4(267.94,56.08)
  BOTTOM w0.076: v4(267.94,56.08) 267.85,55.98 267.85,55.55 arc(267.87,55.48) 267.91,55.42 267.92,55.41 arc(267.96,55.35) 267.97,55.28 267.97,55 arc(267.95,54.91) 267.9,54.84 URT2.G11
  BOTTOM w0.081: v4(279.34,67.07) 279.49,67.23 arc(279.57,67.28) 279.67,67.3 279.85,67.3 arc(279.94,67.28) 280.02,67.23 CT39.1
TBT_2_TTX_RD_DRX_N2: length 18.2
  TOP w0.081: CT41.1 281.41,62.77 arc(281.35,62.73) 281.28,62.72 arc(281.26,62.72) 281.25,62.72 280.82,62.72 arc(280.73,62.74) 280.65,62.79 v2(280.51,62.93)
  IN1 w0.076: v4(268.4,56.76) 268.43,56.8 arc(268.53,56.94) 268.56,57.12 268.56,57.35 arc(268.63,57.69) 268.83,57.99 269.27,58.43 arc(269.92,58.86) 270.69,59.02 274.49,59.02 arc(275.11,59.14) 275.64,59.49 278.24,62.09 arc(278.86,62.52) 279.59,62.71 280.1,62.75 arc(280.32,62.8) v2(280.51,62.93)
  BOTTOM w0.076: URT2.E11 268.54,54.79 arc(268.46,54.92) 268.43,55.06 268.43,55.24 arc(268.45,55.32) 268.49,55.38 268.5,55.39 arc(268.55,55.46) 268.56,55.54 268.56,56.43 arc(268.53,56.58) 268.45,56.71
  BOTTOM w0.081: 268.45,56.71 v4(268.4,56.76)
TBT_2_TTX_RD_DRX_P1: length 21.7
  IN3 w0.076: v4(267.56,56.08) 267.62,56.13 arc(267.65,56.18) 267.66,56.23 267.66,57.32 arc(267.7,57.54) 267.82,57.72 269.02,58.92 arc(270.59,59.97) 272.45,60.34 274.75,60.34 arc(275.32,60.45) 275.81,60.78 277.73,62.7 arc(278.04,63.16) 278.15,63.71 278.15,66.54 arc(278.22,66.9) 278.42,67.2 278.6,67.38 arc(278.8,67.51) 279.03,67.56 arc(279.08,67.56) 279.12,67.57 arc(279.22,67.6) 279.29,67.66 v4(279.34,67.71)
  BOTTOM w0.076: v4(267.56,56.08) 267.66,55.98 267.66,55.56 arc(267.64,55.47) 267.59,55.4 267.58,55.39 arc(267.53,55.31) 267.51,55.23 267.51,55.04 arc(267.52,55) 267.54,54.97 arc(267.67,54.94) 267.74,55.05 URT2.G12
  BOTTOM w0.081: CT38.1 280.01,67.58 arc(279.93,67.52) 279.84,67.51 279.64,67.51 arc(279.55,67.52) 279.47,67.58 v4(279.34,67.71)
TBT_2_TTX_RD_DRX_P2: length 18.2
  TOP w0.081: CT40.1 281.42,62.46 arc(281.36,62.5) 281.3,62.51 280.73,62.51 arc(280.63,62.49) 280.54,62.44 arc(280.52,62.4) 280.51,62.35 v2(280.51,62.3)
  IN1 w0.076: v2(280.51,62.3) 280.51,62.47 arc(280.45,62.58) 280.33,62.59 arc(280.22,62.56) 280.11,62.55 279.6,62.51 arc(278.94,62.34) 278.38,61.95 275.78,59.35 arc(275.19,58.96) 274.49,58.82 270.69,58.82 arc(270,58.68) 269.41,58.29 268.97,57.85 arc(268.82,57.62) 268.76,57.35 268.76,56.94 arc(268.77,56.88) 268.81,56.82 268.83,56.8 arc(268.88,56.77) v4(268.93,56.76)
  BOTTOM w0.076: URT2.E12 268.66,55.04 arc(268.78,54.92) 268.89,55.04 268.89,55.27 arc(268.88,55.32) 268.85,55.36 268.78,55.43 arc(268.77,55.45) 268.76,55.47 268.76,56.53 arc(268.77,56.59) 268.8,56.64 268.88,56.71
  BOTTOM w0.081: 268.88,56.71 v4(268.93,56.76)
TBT_I2C_INT#: length 363.6
  TOP w0.069: v2(263.28,44.34) 263.28,44.59 264.24,45.55 v1(268.09,45.55) 269.97,45.55 271,46.59 271,50.26 269.76,51.5 269.76,52.57 270.02,52.82 270.02,53.28 269.84,53.46 269.41,53.46 269.36,53.51 269.36,54.09 271.24,55.97 v2(272.35,55.97) ; RC687.1 157.15,39.49 v2(156.91,39.49)
  IN1 w0.061: v3(24.7,42.08) 24.7,41.01 26.18,39.54 29.76,39.54 32.45,36.85 32.45,31.97 31.1,30.62 31.1,27.35 32.24,26.21 32.24,23.74 33.67,22.31 33.67,22 35.57,20.1 38.28,20.1 47.68,10.71 69.34,10.71 70.35,11.72 75.44,11.72 91.4,27.68 104.79,27.68 106.78,29.67 108.14,29.67 108.55,30.08 v3(108.55,30.19) ; v3(157.42,35.7) 157.42,36.64 157.57,36.8 157.57,37.81 156.91,38.47 v2(156.91,39.49) v3(156.91,39.99) ; v3(259.2,45) 259.65,44.54 261.63,44.54 261.86,44.32 263.03,44.32 263.05,44.34 v2(263.28,44.34) ; v2(272.35,55.97) 272.35,56.18 v3(272.51,56.33)
  IN2 w0.051: v3(157.42,35.7) 157.42,35.04 157.82,34.64 157.82,32.62 158.7,31.74 163.41,31.74 164.13,31.03 164.62,31.03 164.87,31.29 169.06,31.29 171.33,29.01 174.2,29.01 174.75,28.47 177.78,28.47 177.99,28.25 177.99,27.73 178.7,27.02 179.72,27.02 182.16,24.58 185.37,24.58 186.03,23.92 187.23,23.92 187.78,23.37 187.78,22.17 188.66,21.29 188.66,18.21 189.68,17.19 195.38,17.19 201.85,10.71 210.2,10.71 210.92,9.99 216.27,9.99 216.75,9.51 222.11,9.51 222.32,9.72 223.59,9.72 224.41,10.53 233.33,10.53 233.83,11.03 235.86,11.03 236.37,11.55 241.54,11.55 245.94,15.95 245.94,15.95 247.01,17.03 247.47,17.03 250.41,19.96 250.41,22.74 255.68,28.01 255.79,28.01 256.48,28.7 257.93,28.7 258.42,29.2 258.42,33.83 256.79,35.46 256.79,40.52 257.99,41.72 258.24,41.72 258.86,41.72 259.58,42.44 259.58,44.62 v3(259.2,45) ; v3(108.55,30.19) 108.9,30.55 112.05,30.55 113.35,31.84 149.92,31.84 153.71,35.63 153.71,38.17 154.19,38.65 154.38,38.65 154.84,39.11 155.07,39.11 155.94,39.99 v3(156.91,39.99)
  IN3 w0.061: v4(21.76,56.22) 21.26,55.73 21.26,48.69 21.93,48.02 21.93,46.62 23.03,45.52 23.03,43.38 24.38,42.03 24.65,42.03 v3(24.7,42.08) 24.75,42.03 27.06,42.03 v4(27.12,41.97) ; v3(272.51,56.33) 272.63,56.33 272.84,56.53 v4(272.84,56.54) ; v4(156.64,40.26) v3(156.91,39.99)
TBT_L_CC1: length 48.8
  TOP w0.127: v5(23.37,37.04) v1(22.67,37.04)
  IN1 w0.508: v3(11.06,70.38) 11.06,69.35 14.03,66.39 15.22,66.39 17.51,64.09 17.51,57.14 16.9,56.53 16.9,53.54 17.54,52.9 17.54,47.37 22.34,42.57 22.34,38.08 v5(23.37,37.04)
  IN3 w0.381: v3(11.06,70.38) 10.94,70.5 v3(10.94,74.68) 10.94,75.38 10.23,76.08 v4(9.67,76.08)
  BOTTOM w0.203: v5(23.37,37.04) 23.45,37.12 UPD1.24
  BOTTOM w0.381: v5(23.37,37.04) 23.18,36.85 CPD3.1
TBT_L_CC2: length 52.8
  TOP w0.127: v1(22.79,38.94) 23.61,38.12 v5(23.61,38.1)
  IN1 w0.457: v5(8.85,77.56) 8.88,77.54 9.59,77.54
  IN1 w0.508: v5(23.61,38.1) 23.45,38.1 23.18,38.37 23.18,42.81 18.3,47.68 18.3,53.33 17.67,53.97 17.67,56.18 18.28,56.79 18.28,64.51 15.56,67.23 14.39,67.23 11.85,69.77 11.85,70.68 v3(11.53,71) ; 9.59,77.54 10.83,77.54 v3(11.01,77.72)
  IN3 w0.381: v3(11.01,77.72) 11.01,77.72 12.03,76.7 12.03,74.77 11.6,74.34 11.6,71.07 v3(11.53,71)
  BOTTOM w0.203: 23.61,38.09 23.78,37.92 UPD1.26 ; 23.61,38.09 23.53,38.09 23.24,38.38 CPD2.1 ; 23.61,38.09 v5(23.61,38.1)
  BOTTOM w0.254: v5(8.85,77.56) 8.73,77.56 8.5,77.33 JUSBC1.B5
TBT_L_FLASH_BUSY#: length 14.1
  IN3 w0.061: v4(31.11,57.13) 31.3,57.32 31.5,57.32 32.01,57.82 33.88,57.82 34.83,56.87 34.83,54.14 34.36,53.67 34.36,49.81 v4(35.14,49.02)
  BOTTOM w0.069: RT8.1 v4(35.14,49.02)
  BOTTOM w0.076: URT1.A9 30.83,56.85 v4(31.11,57.13)
TBT_L_FLASH_MSTR_SLV: length 16.4
  IN3 w0.061: v4(31.62,54.51) 31.71,54.51 32.45,53.77 32.45,46.38 v4(34.52,44.31)
  BOTTOM w0.069: RT16.1 37.03,45.22 36.13,44.31 v1(35.8,44.31) v4(34.52,44.31) ; URT1.A5 31.12,55.01 v4(31.62,54.51)
TBT_L_FLASH_SHARE_EN: length 12.6
  IN3 w0.061: v4(31.04,54.5) 31.12,54.5 31.4,54.78 31.89,54.78 32.61,54.06 32.61,47.83 34.15,46.3 34.95,46.3 v4(35.14,46.1)
  BOTTOM w0.069: v4(35.14,46.1) RT13.1
  BOTTOM w0.076: v4(31.04,54.5) 30.99,54.55 URT1.A4
TBT_L_GPIO_5: length 18.7
  IN3 w0.061: v4(30.16,56.85) 31.27,56.85 32.08,57.66 33.82,57.66 34.67,56.81 34.67,54.21 34.2,53.74 34.2,48.91 34.35,48.76 35.19,48.76 35.62,48.33 35.62,46 v4(35.14,45.52)
  BOTTOM w0.069: v4(35.14,45.52) RT172.1
TBT_L_GPIO_6: length 15.2
  IN3 w0.061: v4(35.14,48.44) 34.83,48.13 34.41,48.13 34.03,48.5 34.03,53.8 34.5,54.27 34.5,56.74 33.75,57.49 32.14,57.49 31.19,56.54 v4(31.01,56.54)
  BOTTOM w0.069: v4(35.14,48.44) RT12.1
  BOTTOM w0.076: v4(31.01,56.54) 31.01,56.49 30.91,56.39 URT1.A8
TBT_L_GPIO_12: length 14.2
  IN3 w0.061: v4(35.14,46.69) 34.75,47.08 34.13,47.08 32.91,48.3 32.91,54.09 33.67,54.86 33.67,55.24 33.46,55.45 31.17,55.45 v4(30.98,55.26)
  BOTTOM w0.069: v4(35.14,46.69) RT18.1
  BOTTOM w0.076: v4(30.98,55.26) 30.76,55.47 URT1.A6
TBT_L_JTAG_TCK: length 8.4
  TOP w0.069: RT64.1 30.68,53.18 TP46.1 30.7,54.2 RT218.1 31.13,53.92 31.97,53.92 32.53,54.48 v2(32.73,54.48)
  IN1 w0.061: v2(32.73,54.48) 32.75,54.5 v3(32.75,55.1)
  IN3 w0.061: v4(30.16,55.01) 30.25,54.93 31.08,54.93 31.4,55.25 32.61,55.25 v3(32.75,55.1)
TBT_L_JTAG_TDI: length 5.5
  TOP w0.069: TP45.1 31.99,52.79 31.99,52.71 30.56,51.27 30.09,51.27 29.81,51.55 RT63.1
  IN1 w0.061: v3(31.4,53.08) 31.72,53.08 v2(31.99,52.81)
  IN3 w0.061: v4(31.4,53.43) v3(31.4,53.08)
  BOTTOM w0.069: v4(31.4,53.43) 30.74,54.09 URT1.A3
TBT_L_JTAG_TDO: length 6.8
  TOP w0.069: v2(31.86,53.56) 30.34,52.04 TP48.1 29.71,51.84 RT97.1
  IN1 w0.061: v2(31.86,53.56) 31.86,53.59 v3(31.64,53.81)
  IN3 w0.061: v4(29.48,54.76) 29.73,54.51 29.73,54.12 30.03,53.81 v3(31.64,53.81)
  BOTTOM w0.076: v4(29.48,54.76) 29.39,54.84 URT1.C5
TBT_L_JTAG_TMS: length 6.5
  TOP w0.069: v2(31.65,51.51) 31.24,51.09 29.55,51.09 RT65.1
  IN1 w0.061: v2(31.65,51.51) 31.38,51.51 v3(31.05,51.83)
  IN3 w0.061: v4(29.47,54.1) 29.47,54.01 31.05,52.42 v3(31.05,51.83)
  BOTTOM w0.076: v4(29.47,54.1) 29.47,54.33 URT1.C3
TBT_L_PERST#: length 15.2
  IN3 w0.061: v4(35.14,49.61) 34.52,50.23 34.52,53.6 35,54.08 35,56.94 33.95,57.99 31.94,57.99 31.44,57.49 30.34,57.49 29.87,57.03 29.87,56.69 v4(30.16,56.39)
  BOTTOM w0.069: RT162.1 v4(35.14,49.61)
TBT_L_RBIAS: length 2.6
  TOP w0.069: v1(24.58,53.33) 25.19,53.33 v2(26.04,54.18)
  IN1 w0.061: v2(26.04,54.18) 25.86,54.18 25.85,54.19 v3(25.71,54.19)
  IN3 w0.061: v3(25.71,54.19) 25.72,54.19 25.72,54.25 v4(26.02,54.55)
TBT_L_RESET#: length 5.8
  TOP w0.069: 25.97,59.15 25.97,58.77 QT1.3 25.47,57.65 RT226.1 26.05,57.57 26.38,57.9 v1(26.53,57.9) ; 25.97,59.15 25.88,59.24 RT227.1 ; 25.97,59.15 26.25,59.15 v4(26.38,59.28)
  BOTTOM w0.069: 26.12,58.92 26.38,59.17 v4(26.38,59.28)
  BOTTOM w0.076: 26.12,58.92 26.12,58.57 26.25,58.44 26.25,58 URT1.L11
TBT_L_ROM_CLK: length 33.3
  IN1 w0.061: v3(33.44,56.46) 33.66,56.68 v2(33.66,56.98) 33.78,56.98 34.89,58.09 34.89,62.46 v4(35.29,62.86)
  IN3 w0.061: v3(33.44,56.46) 33.29,56.46 33.26,56.48 32.42,56.48 31.88,55.95 30.11,55.95 v4(29.7,56.35)
  BOTTOM w0.069: v4(35.29,62.86) 34.92,62.48 v1(18.58,62.48) 17.62,63.45 17.62,64.84 18,65.22 UTS1.6
  BOTTOM w0.076: URT1.C7 v4(29.7,56.35)
TBT_L_ROM_CS#: length 23.2
  TOP w0.069: v2(33.66,58.48) 33.33,58.48 32.58,59.23 v1(32.58,59.86)
  IN1 w0.061: v3(32.5,55.85) 32.5,57.32 v2(33.66,58.48) 33.66,62.18 31.1,64.74 29.27,64.74 27.27,66.74 27.27,67.29 v4(27.74,67.76)
  IN3 w0.061: v4(30.16,55.47) 30.3,55.62 32.27,55.62 v3(32.5,55.85)
  BOTTOM w0.069: v4(27.74,67.76) UTS1.1
TBT_L_ROM_DI: length 29.4
  IN1 w0.061: v3(33.41,55.92) 33.08,56.25 33.08,56.9 v2(33.66,57.48) 34.45,58.27 34.45,62.67 v4(35.27,63.49)
  IN3 w0.061: v4(29.77,55.7) 29.85,55.78 31.95,55.78 32.4,56.23 33.11,56.23 v3(33.41,55.92)
  BOTTOM w0.069: UTS1.5 19.78,63.95 20.79,62.93 v1(34.43,62.93) 34.71,62.93 v4(35.27,63.49)
  BOTTOM w0.076: URT1.C6 v4(29.77,55.7)
TBT_L_ROM_DO: length 23.3
  IN1 w0.061: v3(33.31,55.04) 32.86,55.49 32.86,57.19 33.64,57.98 v2(33.66,57.98) 33.97,58.29 33.97,62.5 31.26,65.22 29.52,65.22 v4(27.74,67)
  IN3 w0.061: v3(33.31,55.04) 33.03,54.75 32.57,54.75 32.25,55.08 31.46,55.08 31.15,54.76 30.37,54.76 v4(30.16,54.55)
  BOTTOM w0.069: v1(27.73,66.13) 27.75,66.16 27.75,66.98 v4(27.74,67) 27.73,66.98 27.46,66.98 26.96,66.49 UTS1.2
TBT_L_ROM_HOLD#: length 3.6
  BOTTOM w0.069: v1(16.22,66.74) 16.44,66.96 RT23.1 17.78,66.96 18.25,66.49 UTS1.7
TBT_L_ROM_WP#: length 3.3
  BOTTOM w0.069: UTS1.3 RT22.1 27.74,64.65 v1(27.47,64.38)
TBT_L_RSENSE: length 0.8
  IN1 w0.061: v2(26.04,55.09) 26.21,55.27 v3(26.35,55.27)
  IN3 w0.061: v3(26.35,55.27) 26.1,55.01 v4(26.02,55.01)
TBT_L_SMBCLK: length 15.4
  IN3 w0.061: v4(31.71,56.66) 31.79,56.57 31.9,56.57 32.46,57.13 33.53,57.13 34.14,56.52 34.14,54.42 33.67,53.96 33.67,48.3 34.31,47.66 34.94,47.66 v4(35.14,47.86)
  BOTTOM w0.069: RT159.1 35.66,47.66 35.34,47.66 v4(35.14,47.86) ; URT1.A7 30.98,55.93 v4(31.71,56.66)
TBT_L_SMBDAT: length 15.9
  IN3 w0.061: v4(31.71,56.27) 31.81,56.38 31.98,56.38 32.54,56.94 33.45,56.94 33.95,56.44 33.95,54.5 33.48,54.03 33.48,48.22 34.24,47.47 34.94,47.47 v4(35.14,47.27)
  BOTTOM w0.069: URT1.B7 30.39,55.71 31.14,55.71 v4(31.71,56.27) ; RT160.1 35.66,47.47 35.34,47.47 v4(35.14,47.27)
TBT_L_TEST_PWR_GOOD: length 6.3
  IN1 w0.061: v3(32.07,51.76) 32.17,51.86 v2(32.98,51.86)
  IN3 w0.061: v3(32.07,51.76) 31.93,51.61 v4(31.45,51.61) 31.45,51.97 32.02,52.54 32.02,53.97 31.74,54.24 31.43,54.24 31.28,54.09 v4(30.16,54.09)
TBT_L_THERMDA: length 1.9
  BOTTOM w0.069: TP6A4.1 25.16,58.18 URT1.M11
TBT_L_XTAL_25_IN: length 2.3
  BOTTOM w0.069: RT53.1 24.56,57.32 24.79,57.09 25.79,57.09 URT1.L9
TBT_L_XTAL_25_IN_R: length 1.7
  BOTTOM w0.069: RT53.2 CT42.1 23.34,57.88 23.73,58.26 YT1.1
TBT_L_XTAL_25_OUT: length 3.7
  BOTTOM w0.069: URT1.M9 25.52,56.9 24.77,56.9 24.69,56.97 22.41,56.97 22.12,57.26 RT54.1
TBT_L_XTAL_25_OUT_R: length 3
  BOTTOM w0.069: YT1.3 22.99,59.24 22.99,58.22 22.71,57.94 CT43.1 RT54.2
TBT_R_CC1: length 42.5
  TOP w0.203: UPD2.24 266.96,39.46 267.03,39.39
  TOP w0.381: v3(267.56,39.2) 267.22,39.2 267.03,39.39
  IN2 w0.508: v3(267.56,39.2) 267.12,39.64 267.12,40.45 267.48,40.81 268.77,40.81 v3(269.08,41.11) 269.86,41.9 269.86,43.96 270.6,44.7 273.98,44.7 277.2,47.92 277.2,63.41 279.24,65.45 v3(279.24,66.24) 279.24,66.74 279.97,67.48 282.39,67.48 283.17,66.7 v4(283.17,66.15)
TBT_R_CC2: length 42
  TOP w0.127: v1(279.26,62.78) 279.26,62.79 D421.2
  TOP w0.254: UPD2.26 266.62,40.26 266.94,40.58 267.36,40.58 v2(267.5,40.72)
  IN1 w0.508: v2(267.5,40.72) 268.01,40.21 268.01,40.1 v3(268.06,40.05)
  IN2 w0.508: v3(268.06,40.05) 269.9,40.05 270.7,40.85 270.7,43.63 271.01,43.93 275.27,43.93 277.99,46.65 277.99,62.98 278.7,63.7 v3(279.24,63.7) 280.76,65.22 v3(282,65.22)
  IN3 w0.279: 284.06,64.89 284.07,64.9 v4(284.62,64.9)
  IN3 w0.381: v3(282,65.22) 283.3,65.22 283.63,64.89 284.06,64.89
TBT_R_FLASH_BUSY#: length 3.4
  BOTTOM w0.069: URT2.A9 271.07,53.76 271.67,54.35 271.67,54.56 RT189.1 RT190.1
TBT_R_FLASH_MSTR_SLV: length 4.5
  BOTTOM w0.069: RT38.1 RT39.1 271.82,49.12 271.66,49.27 271.66,51.15 270.9,51.92 URT2.A5
TBT_R_FLASH_SHARE_EN: length 5.2
  BOTTOM w0.069: URT2.A4 271.1,51.46 271.48,51.07 271.48,49.2 271.84,48.84 271.84,48.14 271.99,48 RT37.1 RT36.1
TBT_R_GPIO_5: length 3.4
  BOTTOM w0.069: RT173.1 RT33.1 272.08,54.26 271.35,53.53 270.27,53.53 URT2.B9
TBT_R_GPIO_6: length 2.7
  BOTTOM w0.069: RT35.1 RT34.1 271.77,53.68 271.38,53.3 URT2.A8
TBT_R_GPIO_12: length 3.6
  BOTTOM w0.069: URT2.A6 270.7,52.18 270.97,52.18 271.84,51.3 271.84,50.56 RT41.1 RT40.1
TBT_R_JTAG_TCK: length 9.7
  TOP w0.069: TP51.1 271.44,44.87 v2(272.3,45.74)
  IN1 w0.061: v4(272.26,46.88) 272.3,46.84 v2(272.3,45.74)
  IN3 w0.061: v4(270.04,51.92) 270.2,51.76 270.37,51.76 v4(270.93,51.2)
  BOTTOM w0.069: 270.98,51.15 271.31,50.82 271.31,49.13 271.64,48.8 271.64,47.24 272,46.88 v4(272.26,46.88) 272.38,46.77 RT98.1
  BOTTOM w0.076: 270.98,51.15 v4(270.93,51.2)
TBT_R_JTAG_TDI: length 7.3
  BOTTOM w0.069: 270.98,50.67 271.13,50.52 271.13,48.91 271.47,48.57 271.47,47.44 270.98,46.95 270.98,46.57 270.75,46.34 270.3,46.34 TP49.1 269.39,45.95 RT71.1 ; 270.96,50.69 270.66,51 URT2.A3
  BOTTOM w0.076: 270.96,50.69 270.98,50.67
TBT_R_JTAG_TDO: length 5.3
  TOP w0.069: RT73.1 269.97,48.71 270.46,49.21 270.46,49.67 270.22,49.92 270.22,50.23 TP52.1 270.02,50.44 v3(269.43,50.44)
  IN3 w0.061: v4(269.27,51.96) 269.56,51.67 269.56,50.56 v3(269.43,50.44)
TBT_R_JTAG_TMS: length 6.2
  TOP w0.069: v3(269.08,50.87) 269.08,50.39 268.67,49.98 267.04,49.98 266.92,49.85 266.92,49.71 266.92,49.71 266.92,49.41 266.92,49.41 TP50.1 268.31,48.58 RT72.1
  IN3 w0.061: v4(269.27,51.31) 269.27,51.06 v3(269.08,50.87)
TBT_R_PERST#: length 9.8
  TOP w0.069: v1(271.82,45.99) 271.87,46.04 271.87,46.89 272.31,47.34 272.55,47.34 272.77,47.56 272.77,48.08 RT163.1 271.88,48.96 RT62.1 271.87,48.97 271.87,52.9 v5(271.74,53.03)
  BOTTOM w0.069: v5(271.74,53.03) 271.62,53.03 271.58,53.06 270.27,53.06 URT2.B8
TBT_R_RBIAS: length 2.6
  TOP w0.069: v1(264.35,50.59) 264.89,51.13 v2(265.3,51.13)
  IN1 w0.061: v3(265.75,51.02) 265.63,51.13 v2(265.3,51.13)
  IN3 w0.061: v3(265.75,51.02) 265.97,51.24 266.19,51.24 v4(266.19,51.24)
  BOTTOM w0.076: v4(266.19,51.24) 265.98,51.46 URT2.L4
TBT_R_RESET#: length 7
  BOTTOM w0.069: RT224.1 262.67,56.71 QT2.3 263.25,56.71 263.53,56.99 264.92,56.99 264.95,56.96 264.95,56.71 ; 265.3,56.71 265.43,56.84 v1(266.1,56.84) 266.23,56.84 266.28,56.79 266.28,56.71
  BOTTOM w0.076: URT2.L11 266.13,54.9 266.13,55.38 266.02,55.49 266.02,55.84 266.5,56.32 266.5,56.43 266.28,56.65 266.28,56.71 ; 264.95,56.71 265.08,56.58 RT175.1 265.3,56.71
TBT_R_ROM_CLK: length 23.7
  IN1 w0.061: v5(269.61,52.99) 269.67,52.93 271.08,52.93 272.17,51.84 v5(276.57,51.84) 276.58,51.84 278.73,49.69 278.73,41.31 v2(278.39,40.97)
  BOTTOM w0.069: v5(276.57,51.84) 276.99,52.27 v1(277.97,52.27) 278.2,52.27 278.6,51.86 UTS2.6
  BOTTOM w0.093: URT2.C7 269.54,52.99 v5(269.61,52.99)
TBT_R_ROM_CS#: length 23.4
  TOP w0.069: JDB4.5 277.2,42.47 v5(277.06,42.62)
  IN1 w0.061: v5(277.06,42.62) 276.01,43.67 276.01,44.09 273.8,46.3 273.8,48.65 270.73,51.71 270.73,51.88 v3(270.47,52.14)
  IN3 w0.061: v4(270.04,52.38) 270.24,52.38 v3(270.47,52.14)
  BOTTOM w0.069: UTS2.1 281.14,42.39 RT42.1 281.14,42.11 279.69,40.66 277.28,40.66 276.59,41.34 v1(276.59,42.16) v5(277.06,42.62)
TBT_R_ROM_DI: length 21.5
  TOP w0.069: JDB4.3 277.67,41.47 v2(277.64,41.45)
  IN1 w0.061: v4(269.6,52.28) 269.8,52.48 270.9,52.48 271.98,51.4 276.16,51.4 v5(276.57,51) 276.59,51 277.95,49.64 277.95,41.76 v2(277.64,41.45)
  BOTTOM w0.069: v1(275.88,51.61) 276.49,51 v5(276.57,51) 277.28,51 277.33,50.94 UTS2.5
  BOTTOM w0.076: URT2.C6 v4(269.6,52.28)
TBT_R_ROM_DO: length 20.9
  TOP w0.069: v5(277.05,41.98) 277.06,41.97 JDB4.4
  IN1 w0.061: v5(277.05,41.98) 275.81,43.22 275.81,44.02 273.61,46.22 273.61,48.57 271.05,51.13 270.37,51.13 v4(270.04,51.46)
  BOTTOM w0.069: v5(277.05,41.98) 277.1,41.93 277.1,41.45 v1(277.56,40.99) 279.36,40.99 280,41.62 RT43.1 280,42.61 279.87,42.74 UTS2.2
TBT_R_ROM_HOLD#: length 3.2
  BOTTOM w0.069: v1(279.49,52.39) RT45.1 280.38,52.03 279.87,51.52 UTS2.7
TBT_R_ROM_WP#: length 2.1
  BOTTOM w0.069: RT44.1 278.6,42.51 v1(278.6,43.22) UTS2.3
TBT_R_RSENSE: length 3.4
  TOP w0.069: v2(265.87,52.04) 265.86,52.05 RT50.1 265.02,52.05 264.86,51.88 v1(263.89,51.88)
  IN1 w0.061: v2(265.87,52.04) v3(265.62,52.29)
  IN3 w0.061: v3(265.62,52.29) 265.99,52.29 v4(266.18,52.1)
  BOTTOM w0.076: v4(266.18,52.1) 266,51.92 URT2.L5
TBT_R_SMBCLK: length 2.5
  BOTTOM w0.069: RT196.1 RT200.1 271.97,52.54 271.87,52.44 271.64,52.44 271.41,52.68 270.98,52.68
  BOTTOM w0.076: 270.98,52.68 270.85,52.81 270.53,52.81 URT2.A7
TBT_R_SMBDAT: length 3.5
  BOTTOM w0.069: 270.47,52.6 270.27,52.6 URT2.B7 ; 270.84,52.54 270.85,52.53 270.85,52.53 270.9,52.48 270.98,52.48 271.06,52.48 271.07,52.47 271.32,52.47 271.84,51.94 271.84,51.77 272.22,51.4 RT195.1 RT201.1
  BOTTOM w0.076: 270.84,52.54 270.77,52.6 270.47,52.6
TBT_R_TEST_PWR_GOOD: length 3.4
  BOTTOM w0.069: RT30.2 270.9,48.57 270.9,50.53 270.67,50.77 270.27,50.77 URT2.B3
TBT_R_THERMDA: length 0.8
  BOTTOM w0.076: v4(264.96,55.14) 265.08,55.01 265.08,54.86 265.27,54.68 URT2.M11
TBT_R_XTAL_25_IN: length 3.3
  BOTTOM w0.069: RT55.1 263.64,55.26 263.66,55.24 263.89,55.24 264.17,54.96 v1(264.17,54.89) 265.07,53.99 265.67,53.99 URT2.L9
TBT_R_XTAL_25_IN_R: length 2.3
  BOTTOM w0.069: RT55.2 262.04,55.26 261.76,54.98 CT45.1 261.29,55.34 YT2.1
TBT_R_XTAL_25_OUT: length 2.5
  BOTTOM w0.069: RT56.1 263.64,54.7 263.66,54.68 263.9,54.68 264.82,53.76 URT2.M9
TBT_R_XTAL_25_OUT_R: length 3.8
  BOTTOM w0.069: RT56.2 262.34,54.7 262.17,54.53 261.88,54.53 CT44.1 261.3,54.64 260.25,54.64 259.57,53.96 YT2.3
TCP0_RST#: length 36.6
  TOP w0.069: RT227.2 25.3,59.02 QT1.1 25.09,58.96 24.79,59.26 24.79,59.72 24.79,59.73 24.79,59.92 v3(24.96,60.09) 24.96,60.16 25.19,60.39 25.26,60.39 25.46,60.6 v1(25.97,60.6)
  IN3 w0.061: v3(24.96,60.09) 24.83,59.96 24.83,58.46 24.55,58.18 22.44,58.18 20.94,56.68 20.94,47.15 22.66,45.44 22.66,39.35 22.06,38.75 22.06,35.07 22.69,34.44 22.69,33.26 22.41,32.98 v4(22.41,32.36)
  BOTTOM w0.069: v4(22.41,32.36) RPD169.1 RPD124.1
TCP0_RST#_R: length 1.9
  BOTTOM w0.069: RPD124.2 23.06,33.5 23.88,34.32 UPD1.17
TCP2_RST#: length 35.3
  TOP w0.069: RPD168.1 RPD167.1 RPD132.1 267.99,35.96 268.42,36.39 v4(268.59,36.39)
  IN1 w0.061: v4(274.28,41.6) 274.77,42.08 274.77,44.39 273.47,45.69 272.89,45.69 272.68,45.9 272.68,48.36 271.72,49.32 270.5,49.32 270.24,49.07 267.12,49.07 266.23,49.95 266.23,52.32 265.49,53.05 265.49,53.33 264.02,54.81 v3(264.02,55.44)
  IN3 w0.061: v4(264.38,55.77) 264.05,55.44 v3(264.02,55.44)
  BOTTOM w0.069: 264.33,56.58 263.95,56.58 263.87,56.51 QT2.1 ; v1(274.28,42.77) v4(274.28,41.6) 274.28,41.29 269.39,36.39 v4(268.59,36.39)
  BOTTOM w0.076: 264.33,56.58 RT175.2 264.59,55.99 v4(264.38,55.77)
TCP2_RST#_R: length 1.9
  TOP w0.069: UPD2.17 266.59,36.66 RPD132.2
TCRCOMP_DN: length 3.1
  BOTTOM w0.081: v1(140.45,61.09) RC1.1 141.33,60.63 141.59,60.37 UC1.AY1

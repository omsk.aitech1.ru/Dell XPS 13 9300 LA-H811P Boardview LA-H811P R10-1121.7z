# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TCRCOMP_DP: length 3.8
  BOTTOM w0.081: UC1.AY2 141.92,58.69 RC1.2 142.1,61.27 v1(142.1,61.94)
THERMTRIP1#: length 6.2
  TOP w0.069: RE124.1 189.93,24.07 188.33,24.07 187.26,23.01 187.26,22.47 186.9,22.11 186.09,22.11 185.77,21.79 UE1.B12
THERMTRIP2#: length 32.8
  IN1 w0.061: v3(175.55,27.65) 175.55,28.96 v2(175.5,29.02) ; v2(178.33,16.99) 178.25,17.07 178.25,17.29 v3(178.33,17.37)
  IN3 w0.061: v3(175.55,27.65) 174.54,27.65 174.45,27.74 v4(173.97,27.74) ; v3(178.33,17.37) 178.08,17.37 177.64,16.93 v4(177.1,16.93)
  BOTTOM w0.069: QE16.1 162.46,29.55 CE61.1 163.06,29.55 163.41,29.2 RE215.2 163.41,28.81 163.34,28.73 163.34,27.88 165.38,25.83 169.05,25.83 170.96,27.74 v4(173.97,27.74) 177.1,24.6 v4(177.1,16.93)
TOUCH_SCREEN_PD#: length 6.6
  TOP w0.069: v3(168.59,53.54) 168.84,53.28 v1(169.03,53.28) 170.91,53.28 171.92,52.27 RH654.1 172.39,51.43 D468.1 172.3,51.34 RH655.1
  IN3 w0.061: v4(168.86,53.85) 168.86,53.81 v3(168.59,53.54)
TOUCH_SCREEN_PD#_R: length 67.9
  TOP w0.069: RH654.2 173.39,52.68 QC2.3 ; RH654.2 173.86,51.38 D468.2 174.04,50.52 RH743.2 ; RH654.2 172.59,52.65 172.05,52.65 171.14,53.56 v3(170.05,53.56) ; TP123.1 128.49,59.91 v3(127.97,60.43) 127.97,61.57 127.68,61.87 D465.2 127.22,62.51 arc(127.21,62.53) v4(127.2,62.54)
  IN2 w0.051: v3(170.05,53.56) 170.04,53.56 168.92,54.68 164.76,54.68 164.63,54.55 163.28,54.55 162.4,55.44 158.65,55.44 156.34,57.75 153.1,57.75 152.87,57.52 148.52,57.52 146.72,55.72 144.01,55.72 143.68,56.05 143.68,57.9 143.27,58.31 141.59,58.31 140.83,59.07 138.27,59.07 138.01,58.82 130.87,58.82 130.11,59.58 128.75,59.58 127.97,60.36 v3(127.97,60.43)
  BOTTOM w0.069: JEDP1.42 127.7,66.06 127.55,65.91 126.61,65.91 126.05,66.46 125.21,66.46 124.83,66.08 124.83,65.07 124.6,64.84 124.6,64.03 126.58,62.04 127.01,62.04 127.2,62.24 v4(127.2,62.54)
TOUCHPAD_INTR#: length 26.3
  IN3 w0.061: v4(219.95,6.83) 219.82,6.97 206.95,6.97 206.76,6.77 204.38,6.77 v4(204.26,6.9)
  BOTTOM w0.069: v4(204.26,6.9) 204.21,6.95 JTP1.5 204.21,10.94 v1(204.48,11.21) 205.04,11.78 R6214.1 205.31,12.49 Q351.4 205.34,12.74 204.38,13.69 204.38,14.07 Q351.1 ; v4(219.95,6.83) 219.77,6.83 219.35,7.25 219.35,8.23 JIO1.15
TP_AH10: length 1.4
  TOP w0.069: v5(135.79,53.95) 135.9,54.06 TP90.1
  BOTTOM w0.069: UC1.AH10 135.8,53.95 v5(135.79,53.95)
TP_AK10: length 2.3
  TOP w0.069: v5(136.71,53.95) 136.71,55.27 136.77,55.33 TP89.1
  BOTTOM w0.069: UC1.AK10 136.71,53.95 v5(136.71,53.95)
TP_AM10: length 1.4
  TOP w0.069: v5(137.62,53.95) 137.23,53.95 137.15,54.03 TP93.1
  BOTTOM w0.069: UC1.AM10 137.62,54.57 v5(137.62,53.95)
TP_BC10: length 2.3
  TOP w0.069: TP91.1 142.53,52.85 143.12,53.43 v5(143.12,53.83)
  BOTTOM w0.069: UC1.BC10 v5(143.12,53.83)
TP_BH10: length 2.8
  TOP w0.069: v5(145.45,53.48) 145.86,53.48 TP94.1
  BOTTOM w0.069: UC1.BH10 145.86,53.89 v5(145.45,53.48)
TP_BW11: length 0.7
  TOP w0.069: TP3.1 150.64,53.86 v4(150.89,54.11)
TP_C1: length 4.5
  BOTTOM w0.069: TP59.1 120.49,61.89 123.19,59.18 UC1.C1
TP_CA11:
  vias: v2(151.81,54.11) v3(151.81,54.11) v4(151.81,54.11)
TP_CH33: length 2.6
  TOP w0.069: v5(155.14,44.39) 155.14,44.76 155.13,44.76 155.13,45.33 TP92.1
  BOTTOM w0.069: UC1.CH33 v5(155.14,44.39)
TP_CL32: length 1.5
  TOP w0.069: v5(156.29,44.13) 156.29,44.66 TP97.1
  BOTTOM w0.069: v5(156.29,44.13) 156.64,43.79 UC1.CL32
TP_CM33: length 2.9
  TOP w0.069: v5(157.09,44.14) 157.09,45.29 TP16.1
  BOTTOM w0.069: v5(157.09,44.14) UC1.CM33
TP_CN32: length 1.1
  TOP w0.069: v5(157.91,44.15) 157.91,44.53 TP98.1
  BOTTOM w0.069: v5(157.91,44.15) 157.8,44.03 UC1.CN32
TP_DA11: length 0.9
  TOP w0.069: TP96.1 161.7,53.66 v2(161.84,53.66)
  IN1 w0.061: v4(161.87,54.11) 161.87,53.7 v2(161.84,53.66)
TP_DB10: length 1.1
  TOP w0.069: v4(162.33,55.01) 162.93,55.01 TP15.1
  BOTTOM w0.069: UC1.DB10 v4(162.33,55.01)
TP_DV3: length 4.6
  BOTTOM w0.069: UC1.DV3 170.66,58.21 170.93,58.21 173.09,60.37 TP19.1
TP_DV47: length 5.2
  BOTTOM w0.069: TP24.1 173.85,34.16 172.89,34.16 170.96,36.09 170.66,36.09 UC1.DV47
TP_DW3: length 3.5
  BOTTOM w0.069: UC1.DW3 171.59,57.9 172.18,58.49 173.5,58.49 TP17.1
TP_DW47: length 3.6
  BOTTOM w0.069: TP23.1 172.91,35.1 171.61,36.39 UC1.DW47
TP_E1: length 4.4
  BOTTOM w0.069: UC1.E1 121.85,61.66 121.58,61.66 TP60.1
TP_EN: length 36.5
  IN3 w0.061: v4(205.73,7.36) 205.39,7.7 203.63,7.7 203.57,7.64 200.29,7.64 199.78,8.15 198.28,8.15 197.19,7.06 196.66,7.06 196.27,6.67 195.96,6.67 195.57,7.06 191.45,7.06 191.1,7.42 191.1,7.48 187.61,10.97 186.11,10.97 183.58,13.49 183.58,16.02 183.12,16.48 v3(183.12,16.99)
  BOTTOM w0.069: v4(205.73,7.36) 205.73,6.01 208.07,3.68 R6211.1 209.07,3.26 v1(209.56,2.76)
TP_EN_R: length 2.4
  BOTTOM w0.069: U713.3 210.66,4.48 210.43,4.24 R6212.2 210.43,3.9 210.2,3.68 R6211.2
TP_F15: length 1.6
  TOP w0.069: v5(125.08,52.32) 124.96,52.44 TP7.1
  BOTTOM w0.069: UC1.F15 124.75,51.99 v5(125.08,52.32)
TP_G15: length 1.3
  TOP w0.069: v5(125.67,52.31) 125.41,52.56 TP8.1
  BOTTOM w0.069: v5(125.67,52.31) 125.4,52.04 UC1.G15
TP_J34: length 1.1
  TOP w0.069: TP95.1 126.25,42.36 v5(126.76,42.36)
  BOTTOM w0.069: v5(126.76,42.36) 126.4,42.71 UC1.J34
TP_N34: length 1
  TOP w0.069: v5(128.72,42.4) 129.17,42.4 TP88.1
  BOTTOM w0.069: UC1.N34 v5(128.72,42.4)
TP_P01: length 2.1
  TOP w0.069: UW1.10 266.95,12.59 RW1236.1 267.35,12.98 DR12.2
TP_P17: length 2
  TOP w0.069: UW1.9 266.8,12.09 266.95,12.24 RW1235.1 267.34,12.17 DR9.2
TP_P23: length 2.1
  TOP w0.069: DR6.1 266.84,13.95 266.84,13.48 266.45,13.09 UW1.11
TP_P25: length 2.4
  TOP w0.069: DR7.1 266.59,14.51 266.59,13.81 266.36,13.59 UW1.12
TP_P26: length 1.6
  TOP w0.069: DR8.2 264.73,15.82 UW1.14
TP_R1: length 1.9
  BOTTOM w0.069: TP18.1 129.3,60.62 129.3,59.64 129.38,59.55 UC1.R1
TP_WAKE_KBC#: length 56.4
  IN1 w0.061: v2(177.53,17.79) v3(177.53,17.39)
  IN3 w0.061: v4(190.64,6.59) 190.29,6.59 187.85,9.03 187.85,9.61 187.14,10.31 185.79,10.31 184.28,11.83 183.32,11.83 181.44,13.71 181.44,15.53 181.87,15.96 181.87,17.81 181.41,18.26 178.4,18.26 v3(177.53,17.39)
  BOTTOM w0.069: v4(190.64,6.59) 190.95,6.28 190.95,5.63 192.34,4.23 192.34,2.46 192.5,2.3 193.05,2.3 193.43,2.69 193.43,5.48 193.35,5.56 193.35,6.59 193.38,6.62 194.74,6.62 194.94,6.54 194.95,6.54 195.44,6.33 198.89,6.33 199.52,5.7 201.48,5.7 202.92,7.14 202.92,8.72 202.25,9.39 202.25,10.54 203.32,11.61 v1(203.32,11.83) 203.17,11.97 203.17,14.98 204.32,16.13 204.5,16.13 205.58,15.05 205.58,14.66 Q351.3 205.75,14 RE449.1
TPM_GPIO0: length 1.6
  BOTTOM w0.069: R747.2 187.62,45.23 187.81,45.04 187.88,45.04 188.32,44.61 U712.6
TPM_GPIO0_NU: length 1.7
  BOTTOM w0.069: R54.2 183.7,41.96 184.41,41.96 184.43,41.99 U712.29
TPM_GPP_B17_SMI#_NMI: length 1.7
  TOP w0.069: v2(154.69,36.04) RC339.2
  IN1 w0.061: v3(154.78,36.44) 154.73,36.39 154.73,36.08 v2(154.69,36.04)
  IN3 w0.061: v3(154.78,36.44) 154.72,36.44 154.62,36.54 154.14,36.54 v4(154.1,36.59)
TPM_PIRQ#: length 3
  TOP w0.069: RC255.2 155.95,36.42 RC338.2 156.38,36.41 v2(156.45,36.34) 156.71,36.59 v1(157.04,36.59)
  IN1 w0.061: v3(156.99,36.64) 156.68,36.34 v2(156.45,36.34)
  IN3 w0.061: v3(156.99,36.64) 156.93,36.59 v4(156.6,36.59)
TPM_PIRQ#_R: length 45.8
  TOP w0.069: v2(155.61,35.41) 155.61,35.48 RC255.1 155.07,35.84 RC254.1
  IN1 w0.061: v3(156.3,40.58) 156.3,40.12 156.48,39.95 156.48,37.99 156.2,37.71 156.2,36.52 155.64,35.96 155.64,35.44 v2(155.61,35.41)
  IN3 w0.061: v4(188.79,38.47) 188.79,38.63 187.83,39.59 185.45,39.59 185.36,39.68 184.89,39.68 184.73,39.51 184.44,39.51 184.05,39.91 181.83,39.91 181.25,40.49 181.15,40.49 180.49,41.15 177.32,41.15 175.86,39.7 175.6,39.7 175.34,39.96 172.89,39.96 172.55,40.3 171.36,40.3 171.2,40.14 170.58,40.14 170.14,40.59 168.86,40.59 168.62,40.83 166.34,40.83 166.02,41.15 162.2,41.15 160.96,39.91 158.55,39.91 157.87,40.58 v3(156.3,40.58)
  BOTTOM w0.069: v1(190.63,38.08) 190.41,37.86 R656.2 189.74,37.86 189.43,38.18 189.08,38.18 v4(188.79,38.47) 188.81,38.5 U712.18
TS_DET#: length 73.9
  TOP w0.069: R237.1 128.12,61.87 127.79,62.2 v4(127.79,62.53)
  IN2 w0.051: v3(161.52,38.12) 161.53,38.12 162.09,38.69 162.09,40.28 163.46,41.65 165.2,41.65 167.29,43.73 167.47,43.73 168.75,45.01 168.75,45.88 171.03,48.16 171.03,49.73 171.76,50.46 171.76,55.21 169.04,57.93 167.77,57.93 167.15,58.55 164.39,58.55 163.97,58.97 159.65,58.97 158.28,60.34 149.39,60.34 148.14,61.59 141.92,61.59 141.76,61.43 139.38,61.43 138.95,61.87 133.79,61.87 133.75,61.9 128.21,61.9 127.79,62.32 v4(127.79,62.53)
  IN3 w0.061: v4(161.21,38.31) 161.31,38.31 161.5,38.12 v3(161.52,38.12)
  BOTTOM w0.069: JEDP1.33 129.1,63.72 128.69,63.31 128.45,63.31 127.77,62.64 127.77,62.54 v4(127.79,62.53)
TS_INT#: length 58.3
  TOP w0.069: R288.1 125.97,63.17 126.03,63.11 126.33,63.11 126.45,62.99 D471.2 126.71,62.5 v4(126.71,62.32) 126.53,62.14 126.53,62.09 TP124.1 126.25,61.03 126.85,60.43 v3(127.45,60.43)
  IN2 w0.051: v3(127.45,60.43) 127.45,60.24 127.65,60.04 128.08,60.04 129.45,58.67 139.57,58.67 140.25,57.98 143.27,57.98 143.52,57.73 143.52,55.99 144.04,55.47 146.68,55.47 148.58,57.37 154.38,57.37 155.12,56.63 156.96,56.63 158.31,55.29 161.53,55.29 162.42,54.4 164.7,54.4 164.82,54.52 168.24,54.52 169.02,53.74 169.02,53.69 v3(169.18,53.54)
  IN3 w0.061: v3(169.18,53.54) 169.18,53.92 169.38,54.12 170.2,54.12 170.56,53.75 170.56,53.17 170.16,52.77 v4(170.16,52.55)
  BOTTOM w0.069: JEDP1.39 128.05,63.54 127.76,63.25 127.1,63.25 126.71,62.86 v4(126.71,62.32)
TS_RST#: length 91.2
  TOP w0.069: TP125.1 126.41,66.51 126.57,66.36 R245.1 v4(126.96,65.58)
  IN2 w0.051: v3(165.06,35.27) 165.22,35.43 165.22,36.44 165.66,36.89 166.68,36.89 166.99,37.2 166.99,39.39 169.28,41.67 169.28,43.13 170.5,44.35 170.5,44.39 172.68,46.58 172.68,48.16 173.27,48.75 173.27,51.14 173.11,51.31 173.11,55.78 169.51,59.38 169.51,60.47 166.54,63.43 159.04,63.43 158.93,63.54 148.64,63.54 148.08,64.1 141.13,64.1 140.24,63.21 134.58,63.21 134.46,63.34 129.97,63.34 129.52,63.78 125.58,63.78 v4(124.91,64.46)
  IN3 w0.061: v3(165.06,35.27) 163.99,35.27 162.98,36.29 161.94,36.29 161.24,35.59 160.76,35.59 160.34,36 v4(160.34,36.59)
  BOTTOM w0.069: v4(124.91,64.46) 125.06,64.61 125.06,66.07 125.28,66.29 125.98,66.29 126.67,65.6 126.96,65.6 v4(126.96,65.58) 126.96,65.35 127.7,64.61 JEDP1.41
UART_2_CCTS_DRTS: length 15.3
  TOP w0.069: JUART1.4 179.08,45.06 179.08,45.69 v1(179.03,45.74) 179.03,47.03 178.58,47.49 v3(178.58,47.95)
  IN3 w0.061: v3(178.58,47.95) 178.45,47.82 177.31,47.82 177.12,47.63 175.97,47.63 175.45,48.15 174.46,48.15 174,47.69 172.64,47.69 172.51,47.82 172.51,48.38 172.35,48.53 v4(172.35,49.19)
  BOTTOM w0.069: RC656.1 172.4,49.15 v4(172.35,49.19) 172.15,48.99 169.89,48.99 UC1.DU22
UART_2_CRTS_DCTS: length 16.4
  TOP w0.069: JUART1.1 178.94,42.3 178.63,42.61 178.63,43.83 178.38,44.08 178.38,46.36 177.89,46.86 177.46,46.86 177.26,47.06 177.26,47.55 v1(177.6,47.89) v3(177.89,48.18)
  IN3 w0.061: v3(177.89,48.18) 177.44,48.18 177.05,47.8 176.11,47.8 175.39,48.51 173.4,48.51 v4(172.89,48)
  BOTTOM w0.069: v4(172.89,48) 172.38,48.51 171.11,48.51 170.93,48.33 170.68,48.33 170.39,48.61 UC1.DV22
UART_2_CRXD_DTXD: length 102.5
  TOP w0.069: v2(178.58,46.96) 178.58,46.89 178.72,46.74 178.72,44.22 179.04,43.9 JUART1.3 ; v3(108.29,67.12) 108.73,67.12 109.69,68.09 109.96,68.09 R157.2
  IN1 w0.061: v3(172.79,49.57) 172.81,49.57 172.81,49.55 172.83,49.55 173.79,48.59 174.18,48.59 174.8,47.96 175.44,47.96 175.69,47.72 178.1,47.72 178.51,47.3 178.51,47.03 v2(178.58,46.96)
  IN2 w0.051: v3(108.29,67.12) 108.22,67.05 108.22,62.02 109.91,60.32 112.28,60.32 112.69,59.91 117.92,59.91 121.49,63.48 129.37,63.48 129.81,63.04 134.33,63.04 134.46,62.91 141.29,62.91 142.17,63.78 147.97,63.78 148.51,63.24 158.8,63.24 158.92,63.12 166.42,63.12 169.2,60.34 169.2,59.25 172.8,55.65 172.8,51.18 172.89,51.1 172.89,49.66 v3(172.79,49.57)
  IN3 w0.061: v3(172.79,49.57) v4(172.35,50)
  BOTTOM w0.069: RC222.1 172.64,49.72 v4(172.35,50) 172.15,50.21 171.49,50.21 170.88,49.6 168.72,49.6 168.57,49.45 168.57,48.91 UC1.DT22
UART_2_CRXD_R_DTXD: length 7.7
  TOP w0.069: JMIPI60.56 104.38,70.27 104.74,69.92 109.45,69.92 R157.1
UART_2_CTXD_DRXD: length 99
  TOP w0.069: R249.2 109.63,68.46 v3(108.66,67.49) ; v2(178.15,46.97) 178.15,46.87 178.55,46.47 178.55,44.15 178.8,43.9 178.8,43.22 178.92,43.1 JUART1.2
  IN1 w0.061: v2(178.15,46.97) 178.18,46.99 178.18,47.4 178.03,47.55 175.62,47.55 175.38,47.8 174.74,47.8 174.11,48.43 173.42,48.43 v3(172.89,48.96)
  IN2 w0.051: v3(172.89,48.96) 173.12,49.2 173.12,51.08 172.95,51.24 172.95,55.71 169.36,59.31 169.36,60.4 166.48,63.28 158.98,63.28 158.87,63.39 148.58,63.39 148.02,63.95 142.11,63.95 141.23,63.06 134.52,63.06 134.39,63.19 129.9,63.19 129.46,63.63 121.39,63.63 117.82,60.06 112.75,60.06 112.34,60.48 109.98,60.48 108.57,61.88 108.57,66.85 108.66,66.93 v3(108.66,67.49)
  IN3 w0.061: v3(172.89,48.96) v4(172.89,48.58)
  BOTTOM w0.069: UC1.DW22 170.99,48.79 172.43,48.79 172.64,48.58 v4(172.89,48.58)
UART_2_CTXD_R_DRXD: length 7.7
  TOP w0.069: JMIPI60.54 103.88,70.04 104.51,69.41 109.32,69.41 R249.1
UART_WAKE#: length 6.5
  BOTTOM w0.069: UWL1.53 263.09,18.01 263.26,18.18 263.26,21.18 263.03,21.4 261.99,21.4 RW47.2 261.43,21.96 v1(260.62,21.96)
UART_WAKE_HOST: length 158.9
  IN3 w0.061: v4(175.85,40.33) 176.03,40.33 177.18,41.48 180.63,41.48 181.29,40.82 181.39,40.82 181.97,40.23 183.61,40.23 183.94,40.57 184.54,40.57 184.78,40.34 186.03,40.34 186.62,39.75 187.89,39.75 188.77,38.88 189.35,38.88 189.75,38.47 191.48,38.47 192.04,37.91 192.04,36.57 194.49,34.12 194.49,32.03 195.01,31.52 195.01,29.65 195.24,29.41 195.24,27.66 191.27,23.68 191.27,22.41 189.83,20.97 189.83,18.38 190.97,17.24 190.97,15.71 193.54,13.15 194.34,13.15 195.49,12 212.57,12 213.56,13 219.47,13 220.74,14.26 227.13,14.26 227.99,15.13 238.66,15.13 244.24,20.71 245.2,20.71 245.39,20.9 246.36,20.9 247.29,21.83 247.59,21.83 249.64,23.87 251.39,23.87 252.98,25.47 253.52,25.47 254.03,25.98 v4(256.22,25.98) ; v4(267.07,7.26) 267.5,7.69 267.5,18.05 266.82,18.74 266.49,18.74 266.33,18.89 266.33,20.36 264,22.7 261.89,22.7 v4(261.58,22.4)
  BOTTOM w0.069: RH748.2 264.17,6.47 264.96,7.26 v4(267.07,7.26) ; UC1.DL38 166.86,40.84 167.2,40.51 168.52,40.51 168.62,40.4 170.18,40.4 170.28,40.51 170.7,40.51 170.87,40.34 171.99,40.34 172.45,40.81 173.51,40.81 174.21,40.1 175.35,40.1 v1(175.38,40.07) 175.59,40.07 v4(175.85,40.33) ; v4(256.22,25.98) 256.33,25.98 256.99,25.32 258.33,25.32 258.99,24.66 258.99,23.18 259.78,22.4 v4(261.58,22.4)
UPD_L_SMBCLK: length 1.7
  TOP w0.069: UM1.18 32.73,66.52 32.83,66.41 33.24,66.41 33.34,66.31 33.69,66.31 RM19.1
UPD_L_SMBDAT: length 1.7
  TOP w0.069: RM20.1 33.71,66.12 33.26,66.12 33.16,66.22 32.84,66.22 32.74,66.12 UM1.17
UPD_L_SMBINT#: length 218.3
  TOP w0.069: RE108.1 189.7,19.39 189.7,19.46 189.54,19.63 188.43,19.63 187.08,18.27 184.25,18.27 UE1.F10
  IN1 w0.061: v2(183.93,18.59) v3(183.93,17.49)
  IN2 w0.051: v4(28.08,43.77) 30.1,43.77 33.39,40.48 33.39,31.56 30.16,28.34 30.16,21.61 32.68,19.09 32.68,15.64 31.59,14.55 31.59,10.58 31.84,10.33 31.84,8.83 32.48,8.19 35.77,8.19 36.21,8.63 37.36,8.63 38.09,7.9 38.09,6.98 38.67,6.39 39.73,6.39 39.92,6.59 39.92,7.01 41.28,8.36 41.63,8.36 41.77,8.51 48.11,8.51 48.44,8.83 70.5,8.83 70.78,9.11 80.53,9.11 81.25,8.4 93.76,8.4 94.42,7.74 101.86,7.74 102.6,8.48 105.51,8.48 107.09,10.05 122.82,10.05 122.87,10.1 136,10.1 136.51,10.61 140.97,10.61 141.24,10.33 165.62,10.33 168.01,12.72 170.86,12.72 172.63,14.49 176.8,14.49 177.46,13.84 179.88,13.84 180.02,13.98 183.11,13.98 183.53,14.41 183.53,15.18 183.81,15.46 184.14,15.46 184.34,15.66 184.34,17.08 v3(183.93,17.49)
  BOTTOM w0.069: v4(28.08,43.77) 24.77,43.77 v1(24.04,43.05) 24.04,42.28 RPD17.2
UPD_R_SMBCLK: length 2.3
  BOTTOM w0.069: UM2.18 277.63,56.83 277.52,56.73 277.22,56.73 276.59,56.09 276.29,56.09 RM21.1
UPD_R_SMBDAT: length 2.3
  BOTTOM w0.069: RM22.1 276.28,55.9 276.67,55.9 v7(276.98,56.2) 277.3,56.53 277.51,56.53 277.61,56.43 UM2.17
UPD_R_SMBINT#: length 120.2
  TOP w0.069: UE1.F5 179.93,18.48 180.12,18.28 183.17,18.28 183.61,17.85 183.61,17.59 183.9,17.3 188.01,17.3 188.18,17.47 189.57,17.47 v2(190.34,16.71) ; v2(266.07,44.33) 266.68,44.33 v1(267.04,44.7)
  IN1 w0.061: v2(190.34,16.71) 190.64,17.01 190.64,18.53 v3(191.02,18.92) ; v3(258.84,44.54) 259.89,43.49 260.4,43.49 260.63,43.72 261.02,43.72 261.37,44.06 265.8,44.06 v2(266.07,44.33)
  IN2 w0.051: v3(191.02,18.92) 191.12,18.92 191.23,19.02 195.63,19.02 202.47,12.18 210.9,12.18 211.62,11.46 216.88,11.46 217.36,10.98 220.55,10.98 221.35,11.78 223.14,11.78 223.39,12.03 232.74,12.03 234.67,13.95 239.15,13.95 240.07,14.88 243.34,14.88 248.27,19.81 248.27,22.76 249.66,24.15 249.66,26.28 249.69,26.31 250.74,26.31 252.35,27.92 252.35,28.55 252.8,29 255.94,29 257.93,30.98 257.93,33.84 256.48,35.29 256.48,41.93 258.84,44.29 v3(258.84,44.54)
UPD_SMBCLK: length 13.1
  TOP w0.069: v2(179.11,21.39) 178.73,21.39 UE1.C3 ; Q30.1 183.2,29.26 v2(182.94,29) ; RE445.1 182.94,28.71 v2(182.94,29) ; RE462.1 182.5,29.44 v2(182.94,29)
  IN1 w0.061: v2(182.94,29) 182.87,29 182.69,28.82 181.23,28.82 180.76,28.36 180.76,23.61 180.47,23.32 180.47,22.42 179.53,21.48 179.2,21.48 v2(179.11,21.39)
UPD_SMBCLK_Q: length 418.1
  TOP w0.069: RW1236.2 268.11,12.68 268.45,12.68 268.97,13.2 268.97,17.08 268.16,17.89 268.16,21.43 267.96,21.63 264.88,21.63 264.03,20.78 262.03,20.78 257.32,25.49 257.32,27.75 v3(257.21,27.86) ; RM19.2 34.72,66.32 35.12,66.32 35.73,65.72 v7(35.73,64.89) 35.73,63.59 33.76,61.62 31.35,61.62 v2(31.26,61.53) ; Q30.6 182.66,30.34 181.92,29.6 RE462.2 181.92,29.44 182.39,28.97 182.39,28.62 v2(182.61,28.39)
  IN1 w0.061: v3(106.14,7.05) 105.64,6.56 97.29,6.56 96.07,7.78 94.6,7.78 92.33,10.06 80.65,10.06 79.81,9.21 71.09,9.21 70.26,8.38 64.6,8.38 63.92,7.7 46.43,7.7 43.28,10.85 43.28,11.51 35.95,18.84 34.21,18.84 30.72,22.32 30.72,24.06 28.57,26.22 24.94,26.22 21.17,29.98 21.17,31.55 20.81,31.92 20.81,33.22 21.02,33.43 21.36,33.43 v3(21.53,33.6) ; v3(21.91,62.81) 22.12,62.6 22.12,62.33 22.82,61.63 31.16,61.63 v2(31.26,61.53) ; v3(257.21,27.86) 257.21,27.83 257.24,27.81 257.24,27.78 257.34,27.68 259.34,27.68 260.6,28.94 260.6,29.39 261.33,30.12 263.17,30.12 264.7,31.64 265.46,31.64 265.88,32.06 265.88,33.1 267.43,34.65 267.43,37.24 268.68,38.5 268.68,39.5 268.9,39.72 268.9,40.54 268.09,41.36 v3(268.09,41.41) ; v2(182.61,28.39) 182.77,28.24 184.7,28.24 185.55,27.38 185.55,26.64 185.35,26.44 185.35,26.11 184.92,25.68 184.51,25.68 184.04,25.21 184.04,23.79 v3(183.85,23.61)
  IN2 w0.051: v3(257.21,27.86) 257.04,28.03 256.65,28.03 256.04,27.42 255.89,27.42 251.02,22.56 251.02,19.78 248.53,17.29 248.53,15.12 246.88,13.48 244.69,13.48 241.18,9.97 233.99,9.97 233.69,9.67 224.76,9.67 223.95,8.86 222.7,8.86 222.48,8.64 216.39,8.64 215.91,9.12 210.7,9.12 210.18,8.61 205.69,8.61 204.6,9.7 201.43,9.7 198.66,12.46 195.95,12.46 195.4,13.02 193.04,13.02 v3(192.43,13.63) 192.3,13.76 191.96,13.76 191.95,13.78 187.97,13.78 187.46,14.29 186.26,14.29 184.18,12.21 172,12.21 171.32,11.52 169.47,11.52 168.62,11.52 165.98,8.88 140.22,8.88 139.72,9.39 137.37,9.39 136.87,8.88 111.82,8.88 111.31,8.37 107.07,8.37 105.98,7.28 105.98,7.21 v3(106.14,7.05)
  IN3 w0.061: v3(268.09,41.41) 268.72,41.41 269.04,41.72 271.93,41.72 274.98,44.77 274.98,48.43 275.81,49.26 275.81,55.99 v4(275.51,56.28) ; v3(21.91,62.81) 21.06,62.81 20.3,62.05 20.3,44.28 19.85,43.83 19.85,43.3 20.36,42.79 20.36,40.59 20.57,40.38 v4(21.12,40.38) 21.12,39.6 20.68,39.16 20.68,37.25 21.42,36.52 21.42,34.76 21.92,34.26 21.92,33.55 21.83,33.45 21.68,33.45 v3(21.53,33.6) ; v3(192.43,13.63) 192.35,13.71 191.94,13.71 190.05,15.6 190.05,16.68 188.64,18.08 188.64,20.36 185.98,23.03 184.2,23.03 184.04,23.2 184.04,23.42 v3(183.85,23.61)
  BOTTOM w0.069: RPD163.2 22.1,39.61 21.89,39.61 v4(21.12,40.38)
UPD_SMBDAT: length 15.4
  TOP w0.069: v2(181.12,29.15) 181.12,29.33 v1(183.1,31.31) 183.48,31.69 184.24,31.69 RE446.1 184.62,30.08 RE463.1 184.24,30.05 183.96,30.34 Q30.4
  IN1 w0.061: v2(181.12,29.15) 181.12,28.98 180.57,28.43 180.57,23.69 180.28,23.4 180.28,22.5 179.45,21.67 179.25,21.67 v2(179.13,21.79)
UPD_SMBDAT_Q: length 416
  TOP w0.069: v2(185.46,28.47) 185.05,28.47 184.93,28.59 184.93,29.28 184.74,29.47 RE463.2 184.58,29.49 Q30.3 ; v2(31.26,61.91) 31.35,61.82 v7(32.2,61.82) 33.68,61.82 35.53,63.67 35.53,65.64 35.04,66.13 34.72,66.13 RM20.2 ; v3(257.64,28.2) 257.52,28.08 257.52,25.57 262.11,20.97 263.95,20.97 264.8,21.83 268.04,21.83 268.36,21.51 268.36,17.98 269.17,17.16 269.17,13.12 268.53,12.48 268.1,12.48 RW1235.2
  IN1 w0.061: v2(185.46,28.47) 185.26,28.26 185.26,27.94 185.74,27.46 185.74,26.56 185.54,26.36 185.54,26.03 185,25.49 184.59,25.49 184.22,25.13 184.22,23.77 v3(184.39,23.61) ; v2(31.26,61.91) 31.16,61.82 22.9,61.82 22.31,62.41 22.31,62.6 v3(22.52,62.81) ; v3(268.09,41.99) 267.75,41.66 267.75,41.25 267.93,41.06 268.11,41.06 268.71,40.47 268.71,39.8 268.49,39.58 268.49,38.57 267.24,37.32 267.24,34.73 265.69,33.18 265.69,32.14 265.38,31.83 264.62,31.83 263.09,30.3 261.25,30.3 260.41,29.46 260.41,29.02 259.26,27.87 257.97,27.87 v3(257.64,28.2) ; v3(105.5,7.05) 105.2,6.75 97.37,6.75 96.15,7.97 94.68,7.97 92.4,10.24 80.57,10.24 79.73,9.4 71.01,9.4 70.18,8.57 64.52,8.57 63.84,7.89 46.51,7.89 43.47,10.93 43.47,11.59 36.03,19.03 34.28,19.03 30.91,22.4 30.91,24.14 28.64,26.4 25.02,26.4 21.36,30.06 21.36,31.63 20.99,32 20.99,33.14 21.1,33.24 21.36,33.24 v3(21.53,33.07)
  IN2 w0.051: v3(105.5,7.05) 107,8.55 111.24,8.55 111.75,9.06 136.79,9.06 137.3,9.57 139.79,9.57 140.3,9.06 165.9,9.06 168.54,11.7 169.4,11.7 171.25,11.7 171.93,12.39 184.11,12.39 186.19,14.47 187.53,14.47 188.05,13.95 191.92,13.95 v3(192.05,14.09) 192.44,14.09 192.8,13.73 192.8,13.52 193.12,13.2 195.47,13.2 196.02,12.64 198.74,12.64 201.51,9.87 204.68,9.87 205.77,8.79 210.11,8.79 210.62,9.3 215.99,9.3 216.47,8.82 222.41,8.82 222.62,9.03 223.88,9.03 224.69,9.85 233.61,9.85 233.92,10.15 241.11,10.15 244.62,13.66 246.81,13.66 248.35,15.2 248.35,17.37 250.84,19.86 250.84,22.63 255.81,27.6 255.97,27.6 256.57,28.2 v3(257.64,28.2)
  IN3 w0.061: v3(268.09,41.99) 268.31,41.77 268.82,41.77 268.96,41.91 271.85,41.91 274.79,44.85 274.79,48.51 275.62,49.34 275.62,55.35 275.55,55.42 275.07,55.42 274.99,55.49 274.99,55.62 275.09,55.71 v4(275.51,55.71) ; v3(21.53,33.07) 21.73,33.27 21.91,33.27 22.11,33.47 22.11,34.33 21.6,34.84 21.6,36.6 20.87,37.33 20.87,39.08 21.4,39.62 21.4,40.53 v4(21.13,40.8) 21.13,41 21.05,41.09 20.92,41.09 20.84,41.01 20.84,40.61 20.8,40.57 20.65,40.57 20.55,40.67 20.55,42.87 20.04,43.38 20.04,43.75 20.49,44.2 20.49,61.97 20.98,62.47 21.07,62.47 21.16,62.37 22.09,62.37 v3(22.52,62.81) ; v3(192.05,14.09) 191.82,14.09 191.78,14.13 190.23,15.68 190.23,16.76 188.83,18.16 188.83,20.44 186.06,23.22 184.28,23.22 184.22,23.27 184.22,23.44 v3(184.39,23.61)
  BOTTOM w0.069: RPD164.2 22.1,39.81 21.97,39.81 21.42,40.35 21.42,40.51 v4(21.13,40.8)
USB2_COMP: length 4.4
  BOTTOM w0.152: 166.97,60.39 167.11,60.25 167.11,57.38 UC1.DN5
  BOTTOM w0.305: 166.97,60.39 166.46,60.9 RH10.1
USB2_ID: length 5.4
  BOTTOM w0.069: UC1.DL6 166.7,56.4 165.93,57.17 165.93,59.23 165.72,59.43 165.47,59.43 165.27,59.63 165.27,59.89 165.19,59.96 RH8.1
USB2_VBUSSENSE: length 1.9
  TOP w0.069: v4(166.86,54.19) 166.89,54.19 166.95,54.13 RH9.1 167.22,53.41 v1(167.37,53.26)
  BOTTOM w0.069: UC1.DL11 166.84,53.76 166.84,54.17 v4(166.86,54.19)
USB3_CRX_DTX_N2: length 39.8
  TOP w0.081: JDEBUG1.10 193.02,49.18 192.87,49.03 190.35,49.03 v7(189.34,48.03) 188.81,47.49 v2(188.68,47.49)
  IN1 w0.076: v3(165.21,57.4) 165.21,57.65 165.16,57.7 164.99,57.7 164.88,57.81 164.88,58.38 165.17,58.67 171.56,58.67 172.1,58.13 174.44,58.13 175.56,57.01 178.46,57.01 180.72,54.75 183.48,54.75 187.12,51.12 187.12,50.35 188.39,49.08 188.39,48.14 188.87,47.66 188.87,47.55 188.82,47.49 v2(188.68,47.49)
  IN3 w0.076: v3(165.21,57.4) 165.01,57.19 165.01,57.11 164.83,56.94 164.83,56.56 165.37,56.02 165.37,55.59 165.06,55.29 164.87,55.29 v4(164.62,55.04)
USB3_CRX_DTX_P2: length 39.8
  TOP w0.081: JDEBUG1.9 193.03,48.68 192.88,48.83 v7(191.5,48.83) 190.43,48.83 188.95,47.35 v2(188.95,47.22)
  IN1 w0.076: v2(188.95,47.22) 188.95,47.35 189.07,47.46 189.07,47.74 188.58,48.23 188.58,49.17 187.31,50.44 187.31,51.2 183.56,54.95 180.8,54.95 178.54,57.21 175.64,57.21 174.52,58.33 172.18,58.33 171.64,58.87 165.09,58.87 164.68,58.46 v3(164.68,57.4)
  IN3 w0.076: v4(164.62,55.69) 164.82,55.49 164.98,55.49 165.17,55.68 165.17,55.94 164.64,56.48 164.64,57.02 164.81,57.19 164.81,57.27 v3(164.68,57.4)
USB3_CTX_C_DRX_N2: length 1.6
  TOP w0.081: JDEBUG1.7 193.02,47.68 192.87,47.53 192.17,47.53 CH45.2
USB3_CTX_C_DRX_P2: length 1.6
  TOP w0.081: CH44.2 192.14,47.33 192.93,47.33 193.08,47.18 JDEBUG1.6
USB3_CTX_DRX_N2: length 32.8
  TOP w0.081: CH45.1 191.23,47.57 v7(190.54,47.57) 190.09,47.57 189.5,46.99 v2(189.32,46.99)
  IN1 w0.076: v2(189.32,46.99) 189.32,46.88 189.26,46.82 188.82,46.82 188,47.64 188,48.91 186.7,50.21 186.7,50.98 183.3,54.37 180.56,54.37 178.3,56.63 175.35,56.63 174.39,57.59 171.98,57.59 171.28,58.29 166.36,58.29 166.06,57.99 166.06,57.6 165.94,57.49 165.87,57.49 v4(165.64,57.71)
USB3_CTX_DRX_P2: length 32.8
  TOP w0.081: v2(189.59,46.72) 189.59,46.78 190.17,47.37 191.18,47.37 CH44.1
  IN1 w0.076: v2(189.59,46.72) 189.44,46.72 189.35,46.63 188.73,46.63 187.8,47.56 187.8,48.83 186.5,50.13 186.5,50.89 183.22,54.18 180.48,54.18 178.22,56.43 175.27,56.43 174.31,57.4 171.89,57.4 171.2,58.09 166.44,58.09 166.26,57.9 166.26,57.52 166.03,57.29 165.87,57.29 v4(165.64,57.06)
USB20_N1: length 33
  TOP w0.081: v2(189.88,45.55) 189.97,45.46 190.13,45.46 190.7,46.03 v7(192.19,46.03) 192.92,46.03 193.07,46.18 JDEBUG1.4
  IN1 w0.076: v4(167.38,55.48) 167.8,55.9 167.8,56.07 168.03,56.3 169.87,56.3 170.48,55.69 172.93,55.69 175.51,53.11 182.66,53.11 183.73,52.04 183.73,51.38 184.27,50.84 185,50.84 185.4,50.44 185.4,49.69 186.28,48.81 186.28,47.56 188.47,45.37 189.7,45.37 v2(189.88,45.55)
USB20_N4: length 177.1
  IN1 w0.076: v3(281.37,56.37) 281.21,56.53 281.09,56.53 280.66,56.1 280.66,37.81 274.13,31.28 274.13,29.58 273.15,28.61 271.37,28.61 269.38,26.61 266,26.61 265.61,26.22 264.79,25.39 263.97,25.39 261.81,23.23 259.96,23.23 259.04,22.32 256.96,22.32 254.89,20.25 254.89,19.59 254.1,18.79 253.23,18.79 249.12,14.69 244.11,14.69 242.64,13.22 234.12,13.22 233.48,12.58 226.98,12.58 226.66,12.89 223.02,12.89 222.81,13.11 213.63,13.11 212.85,13.88 211.48,13.88 210.37,14.98 206.66,14.98 203.67,17.98 202.99,17.98 200.62,20.34 200.62,29.51 201.13,30.02 201.13,34.41 200.78,34.76 200.78,36.59 198.41,38.96 196.56,38.96 194.99,40.53 194.65,40.53 192.14,43.05 191.07,43.05 189.54,44.57 188.15,44.57 185.51,47.21 185.51,48.41 182.95,50.96 182.95,51.71 182.33,52.34 175.18,52.34 172.65,54.87 165.91,54.87 165.69,54.64 165.69,54.54 165.77,54.45 166.08,54.45 166.16,54.37 166.16,54.22 v3(166.02,54.09)
  IN3 w0.076: v3(166.02,54.09) 165.85,54.25 165.85,54.5 165.92,54.57 v4(166.08,54.57) ; v3(281.37,56.37) 281.31,56.43 v4(280.87,56.43)
USB20_N5: length 152.2
  IN1 w0.076: v4(166.77,57.06) 166.77,57.07 166.77,57.27 166.89,57.39 167.1,57.39 167.11,57.41 169.32,57.41 169.43,57.29 170.45,57.29 171.03,56.71 173.55,56.71 174.51,55.74 174.51,54.65 175.66,53.49 182.91,53.49 185.8,50.6 185.8,49.84 187.12,48.53 187.12,47.28 188.45,45.95 190.64,45.95 195.19,41.4 195.94,41.4 197.62,39.72 198.46,39.72 201.36,36.82 201.36,35.04 201.72,34.69 201.72,29.78 201.21,29.28 201.21,21.28 206.89,15.59 210.62,15.59 211.71,14.51 213.12,14.51 213.93,13.69 223.52,13.69 223.73,13.47 226.99,13.47 227.31,13.15 233.12,13.15 233.76,13.8 239.17,13.8 239.63,14.26 241.13,14.26 241.18,14.21 241.18,14.01 241.12,13.94 v3(241,13.94)
  IN3 w0.076: v3(241,13.94) 241.26,14.2 241.26,16.37 243.08,18.19 244.31,18.19 245.67,19.55 247.23,19.55 249.81,22.13 250.55,22.13 251.55,23.13 252.03,23.13 252.77,23.87 252.77,24.36 253.25,24.83 253.78,24.83 254.19,25.24 256.73,25.24 257,25.51 258.35,25.51 267.07,34.22 267.07,38.25 266.74,38.57 266.74,39.71 266.97,39.93 267.2,39.93 267.25,39.98 267.28,39.98 267.37,40.08 v4(267.37,40.11)
  BOTTOM w0.081: ML18.4 267.96,42.58 267.98,42.6 268.25,42.6 268.52,42.87 268.59,42.87 268.72,42.74 268.72,41.2 v7(268.21,40.69) 267.55,40.02 267.46,40.02 267.46,40.02 267.4,40.02 267.37,40.05 v4(267.37,40.11)
USB20_N5_R: length 14.2
  IN3 w0.076: v4(264.95,41.45) 264.81,41.3 264.81,40.76 264.25,40.2 260.75,40.2 260.62,40.07 260.62,39.96 v4(260.76,39.82)
  BOTTOM w0.081: v4(260.76,39.82) 260.61,39.96 260.61,40.13 260.31,40.43 258.92,40.43 257.77,39.29 257.59,39.29 257.45,39.44 JFP1.6 ; v4(264.95,41.45) 264.81,41.59 264.81,42.03 265.06,42.28 D14.1 264.82,42.68 264.82,42.87 265.05,43.1 265.94,43.1 266.01,43.03 266.01,42.91 266.2,42.72 266.4,42.72 266.55,42.57 ML18.3
USB20_N8: length 236.7
  TOP w0.081: UM1.9 29.09,66.12 28.99,66.21 27.21,66.21 26.4,67.02 24.92,67.02 v2(24.83,66.93)
  IN1 w0.076: v2(24.83,66.93) 24.66,66.77 24.55,66.77 24.5,66.82 24.5,67.05 24.43,67.12 23.35,67.12 19.8,63.57 19.8,47.97 22.51,45.26 26.08,45.26 29.19,42.14 29.7,42.14 30.5,41.35 30.5,40.09 33.24,37.34 33.24,31.49 31.92,30.17 31.92,27.65 33,26.57 33,24.06 34.53,22.53 34.53,22.17 35.83,20.87 38.6,20.87 48.03,11.44 68.99,11.44 70.09,12.53 75.17,12.53 91.53,28.9 91.53,45.82 arc(91.77,47.05) 92.47,48.09 96.22,51.83 102.93,51.83 107.47,56.37 arc(108.01,56.73) 108.64,56.86 119.11,56.86 122.34,60.09 130.06,60.09 131.36,58.79 133.88,58.79 136.01,56.66 136.34,56.66 137.89,55.11 141.47,55.11 141.69,55.34 147.82,55.34 149.06,56.58 151.49,56.58 153.33,58.41 162.35,58.41 162.83,57.92 163.49,57.92 165.45,55.97 166.3,55.97 166.45,56.12 166.96,56.12 167.05,56.22 167.05,56.32 166.99,56.38 166.69,56.38 166.61,56.46 166.61,56.61 166.69,56.68 v4(167.15,56.68)
  BOTTOM w0.081: v4(167.15,56.68) UC1.DN6
USB20_N9: length 16.2
  TOP w0.081: v2(163.02,59.16) 162.93,59.25 162.93,59.71 162.24,60.39 161.33,60.39 160.62,61.1 160.62,61.77 160.43,61.96 160.43,62.09 160.25,62.26 160.12,62.26 158.81,63.57 158.81,64.81 D485.1 158.81,65.37 158.81,65.45 v5(159.02,65.65)
  IN1 w0.076: v4(166.12,59.91) 166.31,59.72 166.31,59.66 166.2,59.55 164.8,59.55 163.97,58.72 163.08,58.72 162.92,58.88 162.92,59.07 v2(163.02,59.16)
  BOTTOM w0.081: UC1.DL2 166.31,58.82 166.31,59.72 v4(166.12,59.91) ; JUFC1.38 158.9,66.04 158.83,65.97 158.83,65.84 v5(159.02,65.65)
USB20_N10: length 122.7
  TOP w0.081: v2(255.75,20.08) 255.66,20 255.66,19.88 255.87,19.68 256.31,19.68 256.46,19.83 ML1.1
  IN1 w0.076: v2(255.75,20.08) 255.75,20.07 255.69,20.01 255.69,19.52 254.34,18.18 253.51,18.18 249.44,14.11 244.35,14.11 242.88,12.64 234.45,12.64 233.81,12 225.51,12 225.42,11.92 221.18,11.92 220.57,12.53 213.39,12.53 212.63,13.28 211.25,13.28 210.13,14.4 205.36,14.4 200.01,19.75 200.01,29.72 200.53,30.24 200.53,34.14 200.2,34.48 200.2,36.35 198.2,38.35 196.35,38.35 194.75,39.95 194.19,39.95 191.71,42.44 190.84,42.44 189.34,43.94 187.94,43.94 184.93,46.96 184.93,48.15 181.32,51.76 174.94,51.76 172.41,54.29 168.08,54.29 v3(167.93,54.15)
  IN3 w0.076: v4(168.03,54.57) 168.2,54.57 168.37,54.4 168.37,54.25 168.26,54.15 v3(167.93,54.15)
USB20_N10_R: length 15.5
  TOP w0.081: v3(261.51,19.02) 261.51,18.94 261.43,18.86 260.04,18.86 259.23,19.68 258.8,19.68 258.66,19.83 ML1.2
  IN3 w0.076: v3(261.51,19.02) 261.58,19.02 261.77,18.83 262.2,18.83 262.44,18.59 262.44,17.04 263.86,15.62 263.86,11.16 263.16,10.46 262.55,10.46 262.47,10.38 262.47,10.01 262.58,9.89 262.73,9.89 262.81,9.98 v4(262.81,10.01)
USB20_P1: length 32.9
  TOP w0.081: v2(189.88,45.17) 189.97,45.26 190.21,45.26 v7(190.5,45.55) 190.78,45.83 192.91,45.83 193.06,45.68 JDEBUG1.3
  IN1 w0.076: v4(168.03,55.48) 168.29,55.48 168.34,55.54 168.34,55.74 168.26,55.82 168.03,55.82 168,55.86 168,55.99 168.11,56.1 169.79,56.1 170.4,55.49 172.85,55.49 175.42,52.92 182.57,52.92 183.53,51.95 183.53,51.29 184.18,50.65 184.92,50.65 185.21,50.36 185.21,49.6 186.08,48.72 186.08,47.47 188.39,45.17 v2(189.88,45.17)
USB20_P4: length 177
  IN1 w0.076: v3(281.37,56.9) 281.2,56.73 281.01,56.73 280.46,56.18 280.46,37.89 273.93,31.37 273.93,29.67 273.07,28.8 271.29,28.8 269.3,26.81 265.92,26.81 265.66,26.55 264.7,25.59 263.89,25.59 261.73,23.43 259.88,23.43 258.96,22.52 256.88,22.52 254.69,20.33 254.69,19.67 254.01,18.99 253.15,18.99 249.04,14.88 244.03,14.88 242.56,13.42 234.04,13.42 233.39,12.77 227.06,12.77 226.74,13.09 223.1,13.09 222.89,13.3 213.71,13.3 212.94,14.08 211.56,14.08 210.45,15.18 206.74,15.18 203.75,18.17 203.07,18.17 200.82,20.42 200.82,29.43 201.33,29.94 201.33,34.49 200.98,34.84 200.98,36.67 198.49,39.15 196.64,39.15 195.07,40.73 194.74,40.73 192.22,43.24 191.16,43.24 189.63,44.77 188.23,44.77 185.7,47.3 185.7,48.49 183.15,51.04 183.15,51.8 182.41,52.53 175.27,52.53 172.73,55.07 165.83,55.07 165.49,54.72 v3(165.49,54.09)
  IN3 w0.076: v4(165.43,54.57) 165.6,54.57 165.66,54.52 165.66,54.25 v3(165.49,54.09) ; v3(281.37,56.9) 281.29,56.83 v4(280.87,56.83)
USB20_P5: length 152.2
  IN1 w0.076: v3(241.53,13.94) 241.52,13.94 241.38,14.08 241.38,14.3 241.33,14.35 241.33,14.35 241.32,14.35 241.21,14.46 239.55,14.46 239.09,14 233.68,14 233.03,13.35 227.39,13.35 227.08,13.67 223.81,13.67 223.6,13.89 214.02,13.89 213.2,14.7 211.79,14.7 210.71,15.79 206.97,15.79 201.41,21.36 201.41,29.19 201.91,29.7 201.91,34.77 201.56,35.12 201.56,36.9 198.54,39.92 197.7,39.92 196.03,41.6 195.27,41.6 190.72,46.14 188.53,46.14 187.31,47.36 187.31,48.61 186,49.93 186,50.68 182.99,53.69 175.75,53.69 174.71,54.73 174.71,55.83 173.63,56.91 171.11,56.91 170.53,57.49 169.51,57.49 169.4,57.61 166.87,57.61 v4(166.77,57.71)
  IN3 w0.076: v3(241.53,13.94) 241.53,14.13 241.46,14.2 241.46,16.29 243.16,17.99 244.39,17.99 245.75,19.35 247.31,19.35 249.89,21.94 250.63,21.94 251.63,22.93 252.11,22.93 252.97,23.79 252.97,24.27 253.33,24.63 253.86,24.63 254.28,25.04 256.82,25.04 257.08,25.31 258.44,25.31 267.27,34.14 267.27,38.33 266.94,38.65 266.94,39.63 267.05,39.73 v4(267.37,39.73)
  BOTTOM w0.081: ML18.1 268.68,43.07 268.93,42.82 v7(268.93,41.87) 268.93,41.11 267.63,39.82 267.46,39.82 v4(267.37,39.73)
USB20_P5_R: length 14.2
  IN3 w0.076: v4(260.22,39.82) 260.42,40.01 260.42,40.15 260.66,40.4 264.17,40.4 264.61,40.84 264.61,41.26 v4(264.42,41.45)
  BOTTOM w0.081: ML18.2 266.51,43.07 266.36,42.92 266.29,42.92 266.21,43 266.21,43.12 266.03,43.3 v7(265.7,43.3) 264.96,43.3 264.62,42.96 264.62,42.68 D13.1 264.38,42.26 264.61,42.03 264.61,41.64 v4(264.42,41.45) ; v4(260.22,39.82) 260.41,40.01 260.41,40.04 260.23,40.23 259,40.23 257.86,39.08 257.6,39.08 257.45,38.94 JFP1.5
USB20_P8: length 236.7
  TOP w0.081: UM1.8 29.07,66.52 28.97,66.42 v7(28.36,66.42) 27.3,66.42 26.49,67.23 24.92,67.23 v2(24.83,67.32)
  IN1 w0.076: v2(24.83,67.32) 23.27,67.32 19.6,63.65 19.6,47.89 22.43,45.06 26,45.06 29.11,41.95 29.62,41.95 30.3,41.27 30.3,40 33.04,37.26 33.04,31.57 31.72,30.25 31.72,27.57 32.81,26.48 32.81,23.98 34.33,22.45 34.33,22.09 35.75,20.67 38.52,20.67 47.95,11.24 69.08,11.24 70.17,12.34 75.25,12.34 91.73,28.82 91.73,37.36 91.73,45.82 arc(91.96,46.97) 92.61,47.95 96.3,51.64 103.01,51.64 107.61,56.23 arc(108.08,56.55) 108.64,56.66 119.19,56.66 122.42,59.89 129.98,59.89 131.28,58.59 133.8,58.59 135.92,56.46 136.25,56.46 137.8,54.91 141.55,54.91 141.78,55.14 147.9,55.14 149.14,56.38 151.58,56.38 153.41,58.21 162.26,58.21 162.75,57.73 163.41,57.73 165.36,55.77 166.38,55.77 166.54,55.92 167.04,55.92 v4(167.8,56.68)
  BOTTOM w0.081: v4(167.8,56.68) UC1.DP6
USB20_P9: length 16.1
  TOP w0.081: v5(158.43,65.65) 158.61,65.47 158.61,65.37 D484.1 158.61,64.81 158.61,63.48 v1(160.13,61.96) 160.41,61.68 160.41,61.02 161.25,60.19 162.16,60.19 162.73,59.62 162.73,59.25 v2(162.64,59.16)
  IN1 w0.076: v4(166.71,59.91) 166.51,59.7 166.51,59.57 166.28,59.35 164.89,59.35 164.05,58.52 163,58.52 162.73,58.79 162.73,59.07 v2(162.64,59.16)
  BOTTOM w0.081: v4(166.71,59.91) 166.51,59.71 166.51,59.12 166.62,59.01 UC1.DL1 ; v5(158.43,65.65) 158.62,65.84 158.62,66 158.55,66.07 JUFC1.40
USB20_P10: length 122.8
  TOP w0.081: v2(255.37,20.08) 255.46,19.99 255.46,19.8 255.78,19.48 256.31,19.48 256.46,19.33 ML1.4
  IN1 w0.076: v2(255.37,20.08) 255.37,20.07 255.49,19.96 255.49,19.6 254.26,18.38 253.42,18.38 249.35,14.31 244.27,14.31 242.8,12.84 234.37,12.84 233.73,12.19 225.42,12.19 225.34,12.11 221.27,12.11 220.65,12.73 213.47,12.73 212.71,13.48 211.34,13.48 210.21,14.6 205.44,14.6 200.21,19.83 200.21,29.64 200.73,30.16 200.73,34.23 200.39,34.56 200.39,36.43 198.28,38.54 196.43,38.54 194.83,40.15 194.27,40.15 191.79,42.63 190.93,42.63 189.42,44.14 188.02,44.14 185.12,47.04 185.12,48.23 181.4,51.96 175.03,51.96 172.49,54.49 167.74,54.49 v3(167.4,54.15)
  IN3 w0.076: v3(167.4,54.15) 167.4,54.55 v4(167.38,54.57)
USB20_P10_R: length 15.6
  TOP w0.081: v3(261.51,18.46) 261.3,18.66 259.96,18.66 v7(259.63,18.99) 259.14,19.48 258.8,19.48 258.66,19.33 ML1.3
  IN3 w0.076: v3(261.51,18.46) 261.56,18.46 261.74,18.64 262.12,18.64 262.24,18.51 262.24,16.96 263.67,15.54 263.67,11.25 263.08,10.66 262.47,10.66 262.27,10.46 262.27,9.92 262.5,9.7 262.73,9.7 262.81,9.61 v4(262.81,9.51)
USB_OC0#: length 2.9
  BOTTOM w0.069: UC1.DW14 170.94,52.67 172.68,52.67 173.22,52.14 RH604.1
USB_OC1#: length 1.4
  TOP w0.069: RH742.1 v2(158.58,39.65)
  IN1 w0.061: v2(158.58,39.65) 158.74,39.49 v4(158.74,39.34)
  BOTTOM w0.069: UC1.CR41 v4(158.74,39.34)
USB_OC2#: length 0.7
  IN1 w0.061: v2(159.47,39.65) 159.64,39.47 v4(159.64,39.35)
  BOTTOM w0.069: UC1.CT41 v4(159.64,39.35)
USB_OC3#: length 1.2
  IN1 w0.061: v2(159.47,37.59) 159.76,37.59 v3(159.81,37.64)
  IN3 w0.061: v4(159.38,38.31) 159.81,37.89 v3(159.81,37.64)
VCI_IN3#: length 6.4
  TOP w0.069: UE1.E4 179.53,19.79 180,19.79 180.24,20.03 180.24,23.02 180.68,23.46 180.68,24.05 180.93,24.29 180.94,24.29 181.03,24.39 RE244.1
VFB: length 4.1
  BOTTOM w0.203: PR1120.2 98.79,66.2 98.82,66.17 PC1103.1 98.59,65.45 98.59,65.02 PR1117.1 98.7,64.72 PU1100.5
VRACPU_VTEMP: length 32.8
  TOP w0.254: v2(94.32,38.14) 93.56,38.14 89.47,42.23 v1(89.47,44.42) 89.47,45.54 91.03,47.11 93.06,47.11 93.16,47.01 94.02,47.01 94.36,47.35 v4(94.45,47.35) 94.45,59.76 v2(94.58,59.89)
  IN1 w0.254: v4(94.45,37.7) 94.45,38.02 v2(94.32,38.14) ; v2(94.58,59.89) 94.2,59.89 v3(93.99,60.09)
  IN3 w0.254: v4(94.4,60.5) v3(93.99,60.09)
  BOTTOM w0.203: PU1100.26 95.41,61.31 95.38,61.35 PR1101.1 v4(94.4,60.5)
VRALERT#: length 20
  BOTTOM w0.069: RC688.1 174.82,40.76 174.76,40.7 v1(174.21,40.7) 173.84,40.7 173.57,40.96 171.29,40.96 171.13,41.11 168.21,41.11 167.93,41.39 167.27,41.39 167.04,41.62 167.04,41.95 166.92,42.08 166.54,42.08 166.38,41.93 166.38,41.62 166.13,41.37 164.35,41.37 164.2,41.22 157.86,41.22 UC1.CN38
VRALERT#_R: length 223.9
  TOP w0.069: v2(37.53,4.28) 37.38,4.44 35.09,4.44 34.94,4.28 34.66,4.28 34.21,3.84 32.59,3.84 32.35,4.08 PR217.1 ; v2(192.41,31.26) 192.81,30.86 194.94,30.86 195.72,30.09 195.72,27.66 197.74,25.64 197.74,22.34 195.12,19.72 195.12,17.12 v1(195.11,17.11) 194.65,16.65 194.65,13.58 195.24,13 195.24,11.68 194.93,11.37 194.93,11.12 193.59,9.77 v3(192.93,9.77)
  IN1 w0.061: v2(192.41,31.26) 192.24,31.43 192.24,32.06 190.38,33.92 190.38,34.66 189.8,35.23 189.18,35.23 188.45,35.96 186.1,35.96 185.76,35.63 183.02,35.63 182.39,36.26 182.39,36.97 v3(182.54,37.13) ; v2(37.53,4.28) 38.11,4.86 38.57,4.86 39.05,5.34 39.61,5.34 40.15,5.89 40.39,5.89 41.86,7.36 45.33,7.36 45.97,6.71 74.18,6.71 74.72,7.25 80.27,7.25 80.75,6.76 92.97,6.76 95.66,4.08 99.89,4.08 100.22,4.41 103.01,4.41 103.44,3.98 104.93,3.98 106.53,5.58 114.22,5.58 115.37,4.43 118.71,4.43 119.77,5.49 120.75,5.49 121.14,5.88 128.78,5.88 129.8,6.91 145.78,6.91 146.41,7.54 157.96,7.54 159.87,5.63 162.77,5.63 163.52,4.89 169,4.89 170.57,6.45 172.79,6.45 173.34,7.01 v3(173.34,7.13)
  IN2 w0.051: v3(173.34,7.13) 177.08,7.13 178.03,8.08 180.37,8.08 181.39,9.09 184.89,9.09 186.76,10.97 188.51,10.97 188.63,11.09 189.61,11.09 191.46,9.24 192.85,9.24 192.93,9.31 v3(192.93,9.77)
  IN3 w0.061: v4(179.26,40.58) 179.37,40.47 180.19,40.47 180.41,40.25 v4(180.49,40.25) ; v4(182.86,38.05) 182.54,37.73 v3(182.54,37.13)
  BOTTOM w0.069: v4(180.49,40.25) 180.61,40.25 180.89,39.97 181.19,39.97 181.54,39.62 182.1,39.62 ; 182.1,39.62 182.1,39.03 182.86,38.27 v4(182.86,38.05) ; 182.1,39.62 RC744.1 182.1,40.1 181.88,40.33 181.88,40.51 181.8,40.59 D21.1 ; RC688.2 176.7,40.76 176.67,40.73 176.67,40.73 176.74,40.66 177.41,40.66 177.48,40.58 v4(179.26,40.58)
VSET_5105: length 6.8
  TOP w0.069: RE199.1 188.55,22.69 CE79.2 187.69,22.64 186.52,21.48 185.34,21.48 185.17,21.3 183.44,21.3 UE1.C9
VTT_1.1V_MEM: length 6.1
  IN3 w0.061: v4(95.67,14.65) 95.67,13.94 v4(96.97,12.65)
  BOTTOM w0.069: PU700.8 96.07,14.15 95.84,14.38 95.84,14.43 95.67,14.6 v4(95.67,14.65) 95.67,15.05 95.05,15.67 v1(94.35,15.67)
WAKE#: length 7
  BOTTOM w0.069: UC1.DL45 166.92,37.53 167.91,37.53 168.49,38.12 168.49,38.17 168.82,38.5 170.63,38.5 171.18,39.06 RH207.1
WAKE_BT: length 113.3
  IN3 w0.061: v4(173.97,45.92) 174.1,45.79 177.37,45.79 177.8,45.36 180.28,45.36 180.87,45.94 182.9,45.94 183.66,45.18 184.75,45.18 185.06,44.88 187.06,44.88 188.28,43.66 188.28,42.86 188.68,42.47 189.49,42.47 190.89,41.06 191.73,41.06 195.11,37.69 195.11,37.43 197.09,35.46 197.09,34.93 198.29,33.73 198.29,31.95 197.81,31.47 197.81,23.95 194.57,20.7 194.57,14.74 196.15,13.16 204.47,13.16 206.79,15.49 223.56,15.49 224.28,16.2 236.95,16.2 v4(237.07,16.07)
  BOTTOM w0.069: v4(237.07,16.07) 237.07,15.74 237.43,15.38 243.68,15.38 244.79,14.27 244.79,12.41 245.35,11.85 DR13.1 ; v4(173.97,45.92) 173.44,46.45 173.2,46.45 172.89,46.76 RW53.2 172.76,46.96 170.65,46.96 170.3,47.31 UC1.DV24
WIFI_UART_RX: length 16.9
  TOP w0.069: QW2.1 259.91,16.12 259.75,15.97 259.07,15.97 258.56,15.46 v1(258.43,15.46) 258.1,15.79 v2(257.61,15.79)
  IN1 w0.061: v3(247.99,11.37) 250.42,11.37 253.94,14.9 254.82,14.9 256.3,16.38 257.02,16.38 v2(257.61,15.79)
  IN3 w0.061: v3(247.99,11.37) 247.99,10.61 247.82,10.43 v4(247.82,10)
  BOTTOM w0.069: DR1.1 247.87,9.95 v4(247.82,10)
WIFI_UART_RX_R: length 5.7
  TOP w0.069: UW1.16 263.73,14.96 263.31,15.38 DR10.2 263.31,15.87 263.73,16.28 263.73,17.03 263.08,17.67 RW54.1 263.9,18.99 v1(264.07,18.99)
WIFI_UART_TX: length 14.3
  TOP w0.069: QW2.4 258.31,17.02 258.14,17.2 RW43.1 256.8,17.2 v1(256.6,17.01) 256.4,16.81 v2(256.4,16.05)
  IN1 w0.061: v3(253.38,13.71) 254.27,14.6 254.95,14.6 v2(256.4,16.05)
  IN3 w0.061: v3(253.38,13.71) 253.07,13.4 250.89,13.4 v4(250.71,13.23)
  BOTTOM w0.069: v4(250.71,13.23) 250.71,12.41 249.55,11.25 248.92,11.25 248.43,10.76 DR2.1
WIFI_UART_TX_R: length 2.3
  TOP w0.069: UW1.17 263.23,14.97 262.57,15.63 DR11.2 261.85,15.63 RW45.1
WLAN_PWR_EN: length 121.1
  TOP w0.069: v2(164.38,5.99) 164.25,6.11 R534.2
  IN1 w0.061: v3(241.91,9.54) 242.4,9.54 242.99,8.96 243.9,8.96 244.02,9.08 246.83,9.08 246.9,9 247.42,9 248.25,9.83 258.53,9.83 259.78,8.58 v3(259.78,6.93) ; v2(164.38,5.99) 164.43,5.94 168.81,5.94 170.24,7.36 171.32,7.36 172.38,8.43 173.41,8.43 175,10.01 175.49,10.01 v3(175.68,10.2)
  IN2 w0.051: v3(241.91,9.54) 241.25,8.88 240.07,8.88 239.59,9.36 234.25,9.36 233.94,9.06 228.71,9.06 227.82,8.17 222.87,8.17 222.74,8.03 216.14,8.03 215.66,8.51 210.95,8.51 210.43,8 202.39,8 v4(202.22,8.16) 202.22,8.7 201.84,9.09 201.18,9.09 198.84,11.42 194.5,11.42 193.66,12.26 193.66,12.41 193.52,12.56 192.39,12.56 191.64,13.3 186.13,13.3 184.43,11.6 177.08,11.6 v3(175.68,10.2) ; v4(266.82,5.25) 261.46,5.25 v3(259.78,6.93)
  BOTTOM w0.069: R533.2 202.6,13.8 202.6,11.62 201.74,10.76 201.74,9.11 202.22,8.63 v4(202.22,8.16)
WLAN_PWR_EN_EC: length 7.7
  BOTTOM w0.069: RE321.2 RE322.2 200.68,12.41 200.94,12.68 200.94,13.78 ; R533.1 202.18,14.49 201.92,14.75 R6137.2 201.32,15.16 201.04,14.89 D23.1 200.94,13.78 ; 200.94,13.78 200.89,13.73 v1(199.02,13.73)
WLAN_PWR_EN_PCH: length 1.8
  TOP w0.069: Q350.1 163.26,6.7 163.31,6.65 R532.2 163.82,7.1 163.67,7.25 R534.1
WLAN_WIGIG60GHZ_DIS#: length 66
  TOP w0.069: v2(188.64,12.61) 188.31,12.61 UE1.L13
  IN1 w0.061: v2(188.64,12.61) 188.9,12.35 188.9,11.36 188.79,11.24 188.79,10.53 189.01,10.31 v3(189.01,9.09)
  IN3 w0.061: v3(189.01,9.09) 190.72,7.38 190.9,7.38 191.38,6.9 195.5,6.9 195.89,6.51 196.33,6.51 196.73,6.9 197.26,6.9 197.84,7.48 198.85,7.48 199.21,7.12 203.49,7.12 203.71,7.34 204.5,7.34 204.74,7.1 206.62,7.1 206.82,7.29 225.21,7.29 225.6,7.68 240.72,7.68 v4(243.04,10)
  BOTTOM w0.069: DZ4.1 244.13,11.07 243.9,10.84 243.9,10.54 243.36,10 v4(243.04,10)
WLAN_WIGIG60GHZ_DIS#_R: length 13.8
  BOTTOM w0.069: DZ4.2 246.61,11.52 247.14,11.52 RW56.2 248.01,11.52 249.54,11.52 250.17,12.15 v1(250.17,12.59) 250.17,19.42 250.76,20.01 UWL1.28
WOV_DMIC_CLK0: length 4.2
  TOP w0.069: v2(165.49,42.21) 165.8,42.51 167.53,42.51 v1(167.58,42.46) 167.88,42.46 RH705.1
  IN1 w0.061: v2(165.49,42.21) v4(165.02,42.21)
  BOTTOM w0.069: UC1.DG36 v4(165.02,42.21)
WOV_DMIC_DATA0: length 5.1
  TOP w0.069: RH706.1 168.19,41.34 167.35,42.18 v1(166.31,42.18) v2(165.9,42.18)
  IN1 w0.061: v4(164.5,42.23) 164.89,42.61 165.47,42.61 v2(165.9,42.18)
  BOTTOM w0.069: UC1.DG34 v4(164.5,42.23)
XRES_MCU: length 29.4
  TOP w0.069: v5(258.36,3.45) 258.84,3.93 260.72,3.93 v1(262.4,5.61) 262.47,5.61 265.94,9.07 RW52.1 267.32,9.4 CW228.2 267,9.82 266.74,10.08 266.74,10.81 266.47,11.09 UW1.7
  BOTTOM w0.069: RW128.2 245.35,1.72 251.91,1.72 254.27,4.08 257.72,4.08 v5(258.36,3.45)
XTAL_38P4M_IN: length 3.7
  BOTTOM w0.069: YH1.3 176.72,55.21 175.73,55.21 175.44,55.5 CH11.2 175.18,55.49 175.15,55.46 RH17.2 174.59,55.46 RH14.2
XTAL_38P4M_IN_CPU: length 3.1
  BOTTOM w0.069: RH14.1 173.18,55.24 172.78,55.24 172.56,55.46 172.16,55.46 171.95,55.24 171.69,55.24 171.47,55.46 171.11,55.46 UC1.DW8
XTAL_38P4M_OUT: length 2.4
  BOTTOM w0.069: YH1.1 175.91,54.42 175.46,54.88 CH10.2 RH17.1 174.58,54.87 RH15.2
XTAL_38P4M_OUT_CPU: length 4.1
  BOTTOM w0.069: RH15.1 172.63,54.87 172.58,54.92 v1(172.53,54.92) 172.48,54.87 169.81,54.87 UC1.DU8
N04830: length 5.2
  TOP w0.127: v1(32.83,12.46) 32.48,12.11 PR218.1
  TOP w0.254: PR218.1 31.75,11.67 v2(31.76,11.65)
  IN1 w0.203: v2(31.76,11.65) 32.09,11.98 v3(32.42,11.98)
  IN3 w0.254: v3(32.42,11.98) 32.42,11.64 v4(32.27,11.48)
  BOTTOM w0.203: v4(32.27,11.48) 32.6,11.48 32.99,11.08 PU200.3
N19757307: length 2.3
  TOP w0.069: RA57.2 257.86,57.51 258.32,57.51 258.81,58 UA1.2
N20151644: length 49.7
  IN3 w0.254: v4(77.43,12.49) 76.06,11.12 62.93,11.12 62.53,10.71 57.86,10.71 57.65,10.5 v4(57.67,10.48)
  BOTTOM w0.254: PR200.2 v4(77.43,12.49) ; v4(57.67,10.48) 57.67,9.43 55.67,7.43 41.7,7.43 v1(40.1,5.83) 40.1,3.17 38.32,1.39 35.95,1.39 35.42,1.92 PR202.1
N20151664: length 49.6
  IN3 w0.254: v4(77.46,13) 77.22,13 75.85,11.62 62.72,11.62 62.32,11.22 57.65,11.22 v4(56.91,10.48)
  BOTTOM w0.254: v4(77.46,13) 77.43,13.02 PR200.3 ; v4(56.91,10.48) 57.04,10.48 57.16,10.36 57.16,9.64 55.46,7.94 41.48,7.94 39.59,6.04 39.59,3.38 38.11,1.9 v1(37.76,1.9) 37.61,2.05 37.61,2.21 37.46,2.35 37.25,2.35 37.1,2.21 37.1,2.05 36.96,1.9 36.31,1.9 PR203.1
N27076067: length 0.9
  BOTTOM w0.254: PR231.2 29.48,7.59 PC243.1
N30248348: length 52
  IN3 w0.203: v4(40.76,22.9) 40.83,22.9 47.16,16.58 73.09,16.58 76.09,19.58 v4(76.09,20.67)
  BOTTOM w0.203: PR221.1 34.51,19.97 35.8,21.27 35.8,23.97 36.41,24.58 37.38,24.58 39.05,22.9 v1(40.07,22.9) v4(40.76,22.9)
  BOTTOM w0.254: PR211.2 76.09,20.77 v4(76.09,20.67)
N30253802: length 6.1
  TOP w0.203: PR230.2 31.03,8.2 31.86,9.03 PR233.1 31.85,9.15 PR234.1 31.85,10.27 31.59,10.53 30.14,10.53 v1(30,10.39) v2(29.71,10.1)
  IN1 w0.254: v3(29.21,10.01) 29.62,10.01 v2(29.71,10.1)
  IN3 w0.254: v4(28.7,9.82) 29.01,9.82 v3(29.21,10.01)
N30256954: length 2.9
  TOP w0.069: v2(32.02,5.68) 31.57,5.23 PR220.2
  IN1 w0.061: v2(32.02,5.68) 32.05,5.71 v3(32.35,5.71)
  IN3 w0.061: v3(32.35,5.71) 32.35,5.56 32.2,5.4 v4(32.2,5.25)
  BOTTOM w0.069: v1(32.2,4.51) v4(32.2,5.25) 32.2,5.66 32.19,5.66 PU200.24
N30277718: length 1.1
  TOP w0.069: v1(38.16,4.21) 38.16,3.62 38.49,3.29
N35975325: length 2.9
  BOTTOM w0.069: v1(29.36,4.96) 30.32,5.91 PR224.2
  BOTTOM w0.254: PU200.25 31.12,6.46 30.65,5.99 PR224.2
N39629096: length 1.3
  BOTTOM w0.069: LED1.2 253.04,23.93 R530.2
N39629103: length 2
  BOTTOM w0.069: v1(251.47,25.77) 251.35,25.65 R531.2 251.35,24.21 LED2.2
N41228936: length 1.5
  BOTTOM w0.254: PR226.1 30.52,6.95 30.93,6.95 31.23,7.26 PU200.27
N49696201: length 3.7
  BOTTOM w0.069: PR1200.2 96.18,38.22 96.79,38.83 v1(97.25,38.83)
  BOTTOM w0.203: PU1200.14 96.14,37.24 PC1206.1 PR1200.2
N49776653: length 1.5
  TOP w0.069: CE65.1 RE172.2 170.02,24.17 v1(169.81,24.38)
N51014739: length 1.5
  BOTTOM w0.254: PR901.2 196.19,65.43 PU900.7
N52032474: length 1.3
  TOP w0.069: PC501.1 201.62,63.77 v1(202.53,64.69)
  vias: v5(200.69,63.76) v5(201.13,64.2)
N52343314: length 2.3
  TOP w0.069: UD2.A5 146.85,26.58 RD21.2
N52343316: length 2.1
  TOP w0.069: UD2.A8 149.25,26.72 RD22.2
N52343354: length 2.2
  TOP w0.069: RD2.2 160.43,26.76 UD1.A5
N52343360: length 2.1
  TOP w0.069: RD1.2 162.81,24.7 UD1.A8
N52360782: length 2.1
  TOP w0.069: RD4.2 128.43,26.72 UD3.A5
N52360800: length 2.3
  TOP w0.069: RD3.2 131.44,25.37 130.83,24.76 UD3.A8
N52360829: length 2.1
  TOP w0.069: UD4.A8 117.24,26.74 RD24.2
N52416800: length 1.8
  TOP w0.203: PR223.2 33.76,1.89 PR227.1 32.76,1.89 32.67,1.98 PQ205.2
N52576195: length 1.9
  TOP w0.069: UM1.11 30.11,63.88 RM10.1
N52576366: length 3.1
  TOP w0.069: RM9.1 33.54,64.64 v1(33.01,64.1) 32.75,64.36 31.89,64.36 31.71,64.54 UM1.15
N52676089: length 1.7
  BOTTOM w0.069: UCR1.28 12.32,39 12.76,38.55 RR10.2
N52692386: length 1
  BOTTOM w0.203: PR1120.1 99.48,66.51 99.48,66.11 PC1105.2
N52692507: length 5.1
  BOTTOM w0.069: v1(94.22,58.31) 94.35,58.44 PC1101.1
  BOTTOM w0.203: PU1100.25 95.22,60.91 94.93,60.62 94.93,60.13 94.35,59.54 PC1101.1 94.53,59.15 95.01,59.15 95.11,59.05 PR1102.2
N52692519: length 5.8
  BOTTOM w0.203: PR1104.2 92.67,64.25 93.13,64.71 93.89,64.71 PR1106.1 PC1104.1 94.76,63.31 v1(95.34,62.73) 95.34,62.3 95.53,62.11 PU1100.28
N52692565: length 2
  BOTTOM w0.203: PU1100.10 102.22,61.31 PR1134.1
N52692863: length 3.1
  BOTTOM w0.203: PU1100.15 99.5,58.65 100.06,58.08 100.06,57.93 v1(100.07,57.92) 100.07,57.89 100.04,57.85 100.04,57.33 PR1114.2 100.85,57.02 PR1125.1
N52692927: length 5.5
  BOTTOM w0.203: PR1103.2 91.99,61.49 92.67,62.17 PR1100.1 92.67,62.3 93.18,62.81 93.82,62.81 PC1102.1 94.78,62.23 95.29,61.71 PU1100.27

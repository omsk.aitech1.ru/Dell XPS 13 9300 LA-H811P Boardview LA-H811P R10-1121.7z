# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PRIM_EN: length 170.8
  TOP w0.069: v5(160.01,4.34) 160.4,4.72 163.65,4.72 164.64,5.72 164.64,7.07 165.23,7.66 166.24,7.66 166.82,8.24 166.82,9.58 167.43,10.18 168.67,10.18 169.46,10.97 169.46,15.38 169.3,15.55 169.3,19.57 169.43,19.7 169.43,24.4 169.69,24.66 170,24.66 v3(170.18,24.49)
  IN1 w0.061: v4(114.19,7.49) 114.16,7.51 114.16,7.83 113.44,8.55 110.21,8.55 109.64,9.13 108.14,9.13 107.5,9.77 105.27,9.77 103.52,11.52 102.05,11.52 97.45,16.12 v2(97.37,16.12)
  IN2 w0.051: v4(197.42,35.07) 197.3,35.07 197.22,35.15 197.22,37.84 198.74,39.36 v3(198.74,46.96)
  IN3 w0.061: v4(186.97,28.62) 186.93,28.62 186.54,29.01 185.1,29.01 184.53,29.58 184.4,29.58 184.24,29.75 182.7,29.75 181.5,28.55 181.13,28.55 180.58,28.01 178.48,28.01 178.01,28.47 176.3,28.47 175.88,28.06 175.49,28.06 174.92,28.63 174.34,28.63 174.21,28.77 171.71,28.77 v4(171.55,28.61) ; v3(170.18,24.49) 170.18,24.64 v4(168.72,26.1) ; v3(198.74,46.96) 199.3,46.96 199.92,47.58 199.92,48.14 201.54,49.76 201.54,51.44 200.32,52.67 200.32,60.55 200.62,60.85 200.62,61.99 v4(199.73,62.89)
  BOTTOM w0.069: v5(160.01,4.34) 160.01,4.41 157.18,7.24 114.43,7.24 v4(114.19,7.49) ; v4(168.72,26.1) 169.01,26.38 169.07,26.38 171.3,28.61 v4(171.55,28.61) 171.74,28.8 CC511.1 172.2,29.41 172.37,29.57 RC508.1 173.33,29.57 RC505.2 ; v4(197.42,35.07) 196.2,35.07 195.61,34.47 195.61,31.93 193.21,29.53 193.03,29.53 192.63,29.13 v1(192.63,28.69) 192.63,27.38 191.99,26.74 190.49,26.74 190.14,27.09 190.14,27.58 189.78,27.94 189.78,28.18 189.55,28.4 187.12,28.4 186.97,28.56 v4(186.97,28.62)
PCH_PRIM_EN_R: length 1.7
  BOTTOM w0.069: RC699.2 173.67,30.38 RC698.2 174.28,29.76 RC505.1
PCH_PWROK: length 12
  TOP w0.069: v2(172.48,29.29) RH625.2 172.69,28.69 UH6.4 ; v3(167.83,35.96) 167.89,35.9 169.66,35.9 v6(170.42,35.15) 170.52,35.04 v2(170.52,34)
  IN1 w0.061: v2(170.52,34) 170.52,33.17 172.74,30.95 172.74,29.55 v2(172.48,29.29)
  IN3 w0.061: v4(167.55,36.31) 167.55,36.24 v3(167.83,35.96)
  BOTTOM w0.069: v4(167.55,36.31) 167.75,36.52 UC1.DN47
PCH_PWROK_P: length 119.6
  TOP w0.069: v2(170.81,33.67) 170.81,34.44 v1(172.02,35.65) 172.9,36.53 172.9,37.85 v5(172.91,37.86) ; UH6.1 174.28,26.74 173.39,27.63 173.39,28.59 RH733.1 v2(173.06,28.9)
  IN1 w0.061: v2(170.81,33.67) 170.81,33.11 172.9,31.02 172.9,29.06 v2(173.06,28.9)
  IN2 w0.051: v4(110.55,60.98) 110.66,61.08 112.17,61.08 112.88,60.37 115.6,60.37 120.17,64.94 125.11,64.94 125.96,64.09 129.65,64.09 130.09,63.64 134.42,63.64 134.82,64.05 135.2,64.05 135.74,63.52 140.11,63.52 141,64.41 148.21,64.41 148.77,63.85 159.06,63.85 159.17,63.73 166.7,63.73 173.57,56.86 173.57,51.49 173.73,51.33 173.73,48.56 173.39,48.23 173.39,42.12 173.14,41.86 173.14,38.09 v5(172.91,37.86)
  BOTTOM w0.069: v4(110.55,60.98) 111.24,60.29 111.24,55.82 110.73,55.31 109.23,55.31 108.73,55.82 101.46,55.82 PR1125.2
PCH_RSMRST#: length 173.2
  TOP w0.069: v5(107.56,66.01) 107.56,65.07 108.17,64.45 108.17,60.64 111.09,57.73 v3(111.09,55.67) ; UE1.M5 179.93,13.55 180.28,13.2 180.28,11.8 181.26,10.82 v2(181.26,10.74)
  IN1 w0.061: v3(180.48,14.95) 180.81,14.62 180.81,11.19 v2(181.26,10.74)
  IN2 w0.051: v3(111.09,55.67) 110.76,55.34 110.42,55.34 110.17,55.58 110.17,56.15 109.72,56.61 97.91,56.61 97.42,57.09 95.39,57.09 94.02,55.73 94.02,53.62 89.35,48.94 89.35,33.05 96.4,26 100.24,26 101.09,25.15 107.25,25.15 107.72,25.62 110.58,25.62 110.91,25.95 114.27,25.95 115.72,27.4 160.28,27.4 161.1,26.57 166.5,26.57 169.56,23.51 169.56,20.17 171.33,18.41 174.28,18.41 174.82,17.87 179.56,17.87 180.77,16.67 180.77,15.86 180.77,15.86 180.77,15.24 v3(180.48,14.95)
  BOTTOM w0.069: v1(107.94,65.52) 107.94,65.63 v5(107.56,66.01) 107.56,66.18 107.13,66.62 RC644.1 106.26,65.85 105.07,65.85 104.81,66.11 UC2.1 104.32,66.61 103.86,66.15 R466.2
PCH_RSMRST#_AND: length 181.5
  IN2 w0.051: v4(109.13,65.02) 108.83,64.71 108.83,61.84 110.02,60.65 112.38,60.65 112.82,60.22 115.66,60.22 120.23,64.79 125.04,64.79 125.89,63.94 129.58,63.94 130.03,63.49 134.52,63.49 134.65,63.37 140.17,63.37 141.06,64.25 148.14,64.25 148.7,63.7 158.99,63.7 159.11,63.58 166.61,63.58 169.66,60.53 169.66,59.44 173.26,55.84 173.26,51.37 173.43,51.2 173.43,48.69 172.84,48.1 172.84,46.51 170.65,44.33 170.65,44.29 169.43,43.07 169.43,39.11 v4(169.46,39.08) 173.24,35.3 175.17,35.3 177.41,33.06 181.18,33.06 181.79,32.46 186.25,32.46 187.13,31.57 188.68,31.57 189.43,30.82 191.94,30.82 193.46,29.29 193.46,28.21 193.97,27.7 196.63,27.7 198.44,25.9 198.44,21.31 201.59,18.15 204.12,18.15 205.21,17.06 211.28,17.06 212.38,15.96 225.32,15.96 v3(226.23,15.05)
  IN3 w0.061: v4(227.19,15.31) 226.49,15.31 v3(226.23,15.05)
  BOTTOM w0.069: R272.1 226.71,15.79 v4(227.19,15.31) ; RC644.2 RC247.1 ; RC247.1 107.41,65.35 107.74,65.02 v4(109.13,65.02) 109.13,64.79 v1(109.51,64.41) ; RC247.1 106.52,65.35 106.11,64.94 UC2.4 ; v4(169.46,39.08) 168.64,39.08 168.22,38.66 167.46,38.66 167.2,38.4 165.27,38.4 165.11,38.24 165.11,37.86 165.01,37.76 165.01,36.03 164.74,35.76 UC1.DG49 164.66,35.56 164.66,33.93 164.48,33.75 164.48,33.55 164.46,33.52 RH592.1
  BOTTOM w0.081: RH592.1 RH591.1
PCH_RTCRST#: length 41.8
  TOP w0.069: JAPS1.9 194.82,25.35 v3(195.03,25.14) ; RH573.2 CH47.2 169.36,34.14 168.72,34.78 v6(168.72,35.04) 168.71,35.06 v4(168.71,35.52)
  IN1 w0.061: v4(168.71,35.52) 168.72,35.52 168.73,35.51 171,35.51 174.84,31.67 175.27,31.67 v3(176.24,30.69)
  IN2 w0.051: v3(176.24,30.69) 176.36,30.57 180.15,30.57 180.75,29.97 184.6,29.97 185.75,28.82 186.89,28.82 188.37,27.35 190.78,27.35 192.99,25.14 v3(195.03,25.14)
  IN3 w0.061: v3(195.03,25.14) 195.04,25.13 195.04,23.62 193.28,21.87 193.28,20.39 v4(193.43,20.24)
  BOTTOM w0.069: v4(168.71,35.52) 168.71,35.97 UC1.DT47 ; v4(193.43,20.24) 193.61,20.06 194.68,20.06 R271.1
PCH_RTCX1: length 6.6
  BOTTOM w0.069: YC1.1 167.77,30.17 CH12.1 167.76,31.32 RH16.1 167.76,32.2 167.38,32.58 167.38,34 166.9,34.48 166.9,35.66 UC1.DL48
PCH_RTCX2: length 4.2
  BOTTOM w0.069: UC1.DL49 166.63,34.22 166.84,34 v1(166.84,33.11) 166.84,32.45 167.18,32.12 RH16.2 167.18,31.35 RH637.2
PCH_RTCX2_R: length 2.2
  BOTTOM w0.069: RH637.1 CH13.1 165.89,30.95 165.54,30.6 YC1.2
PCH_TBT_PERST#: length 359.6
  TOP w0.069: v1(168.14,49.37) 168.14,49.13 v2(168.29,48.98) 168.31,49.01 RH300.2 RH713.2 RH646.2
  IN1 w0.061: v3(185.1,41.11) 184.03,42.19 183.16,42.19 181.8,43.55 181.53,43.55 181.02,44.06 180.09,44.06 178.29,45.86 174.43,45.86 173.42,46.87 171.97,46.87 170.99,47.85 169.94,47.85 169.61,48.18 168.25,48.18 167.98,48.44 167.98,48.68 v2(168.29,48.98) 168.02,49.25 v3(168.02,49.42) ; v3(271.59,48.96) 271.87,48.68 v2(271.87,48.38)
  IN2 w0.051: v3(185.1,41.11) 185.46,41.11 186.81,39.77 187.92,39.77 188.53,39.16 188.53,38.42 190.44,36.52 193.59,36.52 195.39,34.71 196.58,34.71 198.82,32.48 198.82,30.57 201.7,27.69 201.7,24.53 207.24,18.99 212.08,18.99 212.69,18.38 226.89,18.38 228.24,17.03 236.86,17.03 238.42,18.58 239.86,18.58 241.39,20.1 242.59,20.1 243.53,21.04 v3(244.91,21.04) ; v3(168.02,49.42) 167.63,49.82 166.06,49.82 163.13,52.75 162.51,52.75 160.43,54.83 156.26,54.83 154.18,56.91 148.77,56.91 146.87,55.01 141.7,55.01 140.6,56.1 140.6,56.98 139.5,58.08 127.33,58.08 125.83,59.58 121.71,59.58 119.55,57.42 111.38,57.42 110.97,57.83 106.6,57.83 104.92,59.5 101.2,59.5 100.48,60.22 98.88,60.22 97.77,59.1 95.26,59.1 92.42,56.25 92.42,53.81 88.08,49.47 88.08,29.87 73.77,15.56 67.77,15.56 67.49,15.28 44.18,15.28 40.17,19.3 38.35,19.3 36.72,20.92 35.41,20.92 34.73,21.61 32.98,21.61 32.17,22.42 32.17,26.46 36.56,30.85 36.56,47.8 35.65,48.71 35.65,49.65 v4(34.91,50.39)
  IN3 w0.061: v3(271.59,48.96) 271.34,48.96 270.47,48.1 265.7,48.1 263.8,46.2 259.08,46.2 258.2,45.33 258.2,44.34 257.44,43.58 257.44,38.19 258.1,37.54 258.1,35.57 259.43,34.24 259.43,32.61 259.96,32.09 259.96,30.92 257.7,28.66 257.45,28.66 255.38,26.6 252.3,26.6 251.63,25.93 249.85,25.93 244.97,21.04 v3(244.91,21.04) ; v4(168.03,49.08) 168.03,49.4 168.01,49.42 v3(168.02,49.42)
  BOTTOM w0.069: v4(34.91,50.39) 34.56,50.03 RT59.2
PCH_TOUCHPAD_INTR#: length 70.8
  TOP w0.069: RH631.2 176.67,41.45 v3(176.37,41.14)
  IN2 w0.051: v3(176.37,41.14) 176.37,39.31 175.25,38.19 175.25,35.65 177.53,33.37 180.19,33.37 180.52,33.7 181.83,33.7 182.57,32.96 185.12,32.96 185.29,32.79 186.65,32.79 187.36,32.08 188.82,32.08 189.68,31.21 193.59,31.21 198.74,26.06 198.74,22.88 202.99,18.63 v3(203.37,18.63)
  IN3 w0.061: v3(203.37,18.63) 203.19,18.46 203.19,16.84 203.66,16.37 203.66,15.73 v4(204.08,15.31) ; v4(158.47,40.91) 158.79,40.58 160.47,40.58 160.69,40.81 161.3,40.81 161.81,41.31 166.09,41.31 166.41,40.99 168.68,40.99 168.92,40.75 170.73,40.75 170.79,40.82 171.33,40.82 171.51,40.63 172.7,40.63 173.05,40.28 175.41,40.28 175.83,40.7 175.88,40.7 176.19,41.01 176.23,41.01 v3(176.37,41.14)
  BOTTOM w0.069: v1(204.46,15.63) 204.4,15.63 v4(204.08,15.31) 203.9,15.31 203.34,14.76 203.34,13.28 204.04,12.58 Q351.6
PCIE_CRX_C_DTX_N3: length 1.4
  BOTTOM w0.081: DR18.2 256.11,21.67 256.11,21.38 255.96,21.23 UWL1.36
PCIE_CRX_C_DTX_N16: length 2.3
  BOTTOM w0.081: UCR1.8 9.58,43.29 9.48,43.19 9.35,43.19 9.26,43.29 9.26,43.65 8.95,43.96 8.73,43.96 CR4.2
PCIE_CRX_C_DTX_P3: length 1.3
  BOTTOM w0.081: DR19.2 256.31,21.82 256.31,21.38 256.46,21.23 UWL1.37
PCIE_CRX_C_DTX_P16: length 2.3
  BOTTOM w0.081: CR3.2 8.71,43.76 8.87,43.76 9.06,43.57 9.06,43.2 9.27,42.99 9.5,42.99 9.59,42.89 UCR1.7
PCIE_CRX_DTX_N3: length 137.2
  IN1 w0.076: v3(259.09,20.58) 259.09,20.58 258.92,20.74 258.81,20.74 254.82,16.74 254.06,16.74 250.09,12.78 244.88,12.78 243.43,11.33 241.1,11.33 239.53,9.76 237.58,9.76 236.88,10.46 225.98,10.46 225.97,10.46 222.09,10.46 221.72,10.09 217.71,10.09 217.12,10.67 213.26,10.67 212.09,11.84 205.89,11.84 198.66,19.07 198.66,28.49 198.4,28.76 198.4,31.27 198.66,31.54 198.66,34.49 196.85,36.3 196.27,36.3 194.73,37.84 193.28,37.84 188.96,42.16 186.77,42.16 185.3,43.63 185.3,44.72 184.52,45.5 183.73,45.5 183.41,45.82 183.41,47.79 181.85,49.34 179.64,49.34 179.55,49.43 177.42,49.43 177.3,49.55 175.53,49.55 175.22,49.86 174.84,49.86 172.78,51.91 166.92,51.91 166.38,52.45 164.8,52.45 163.4,53.85 v4(163.4,55.43)
  IN3 w0.076: v4(255.74,22.95) 255.97,22.73 255.97,21.15 256.38,20.74 258.93,20.74 v3(259.09,20.58)
  BOTTOM w0.081: UC1.DE7 163.68,55.69 v4(163.4,55.43)
PCIE_CRX_DTX_N9: length 86.7
  IN3 w0.076: v4(196.81,14.33) 196.72,14.42 196.53,14.42 196.28,14.67 196.28,15.61 195.88,16.01 195.88,20.5 199.27,23.89 199.27,29 198.82,29.45 198.82,31.09 199.27,31.54 199.27,34.71 196.34,37.64 196.34,37.85 194.12,40.06 194.12,41.4 192.86,42.66 191.45,42.66 187.54,46.58 186.77,46.58 184.95,48.4 184.65,48.4 180.65,52.4 174.99,52.4 169.33,58.06 163.62,58.06 161.49,55.93 158.45,55.93 v4(158.21,55.69)
  BOTTOM w0.081: JNGFF1.5 189.72,8.9 189.87,9.05 191.12,9.05 192.7,10.63 192.7,12.57 194.55,14.42 v7(195.72,14.42) 196.72,14.42 v4(196.81,14.33)
PCIE_CRX_DTX_N10: length 97
  IN3 w0.076: v4(157.3,55.69) 157.59,55.69 157.67,55.77 157.67,55.85 157.49,56.02 157.49,56.13 157.98,56.61 158.99,56.61 159.77,57.39 159.77,59.4 160.77,60.39 161.99,60.39 163.06,61.46 165.5,61.46 165.76,61.72 170.4,61.72 174.47,57.66 178.72,57.66 180.18,56.2 182.04,56.2 191.63,46.61 193.19,46.61 199.21,40.59 199.21,40.34 202.5,37.05 202.5,35.3 203.22,34.58 203.22,28.35 202.6,27.74 202.6,22.83 200.12,20.35 200.12,15.82 199.1,14.81 199.1,14.41 v4(199.01,14.32)
  BOTTOM w0.081: JNGFF1.17 189.49,11.9 189.64,12.05 190.48,12.05 194.07,15.64 v7(196.43,15.64) 197.41,15.64 198.48,14.57 199.04,14.57 199.1,14.51 199.1,14.41 v4(199.01,14.32)
PCIE_CRX_DTX_N11: length 100.3
  IN3 w0.076: v4(156.38,55.69) 156.2,55.87 156.2,56 156.25,56.05 156.5,56.05 157.6,57.15 158.06,57.15 159.17,58.26 159.17,59.73 160.27,60.83 160.27,61.87 160.5,62.1 162.68,62.1 163.14,62.56 170.38,62.56 174.69,58.25 179.09,58.25 180.35,57 182.07,57 191.87,47.19 193.43,47.19 199.79,40.83 199.79,40.58 203.08,37.29 203.08,35.91 203.88,35.11 203.88,28.2 203.19,27.5 203.19,22.5 200.94,20.25 200.94,15.8 199.97,14.84 199.97,14.43 v4(199.88,14.34)
  BOTTOM w0.081: v4(199.88,14.34) 199.95,14.41 199.95,14.91 199.68,15.18 198.71,15.18 v7(198.51,15.38) 197.06,16.83 193.23,16.83 191.96,15.56 190.78,15.56 190.26,15.05 189.87,15.05 189.72,14.9 JNGFF1.29
PCIE_CRX_DTX_N12: length 102.1
  IN3 w0.076: v4(155.2,56.6) 155.28,56.53 155.91,56.53 157.21,57.83 157.72,57.83 158.33,58.44 158.33,61.03 160.28,62.98 162.41,62.98 162.77,63.34 170.83,63.34 175.12,59.05 179.44,59.05 180.69,57.8 182.36,57.8 192.19,47.97 193.75,47.97 200.57,41.15 200.57,40.9 203.86,37.61 203.86,36.3 204.66,35.5 204.66,27.88 203.97,27.18 203.97,22.18 201.94,20.16 201.94,15.81 v4(202.03,15.72)
  BOTTOM w0.081: JNGFF1.43 189.72,18.4 189.87,18.25 v7(192.34,18.25) 197.6,18.25 198.79,17.06 199.51,17.06 200.27,16.3 201.75,16.3 201.94,16.1 201.94,15.81 v4(202.03,15.72) ; UC1.CJ6 v4(155.2,56.6)
PCIE_CRX_DTX_N16: length 222
  IN3 w0.076: v4(7.51,44.31) 7.41,44.2 7.41,43.99 6.11,42.69 6.11,41.92 12.94,35.09 18.66,35.09 19.37,34.38 19.37,32.05 19.78,31.64 19.78,30.6 22.4,27.98 27.12,27.98 27.63,27.47 31.14,27.47 31.61,26.99 34.69,26.99 35.37,26.31 35.37,24.79 35.95,24.2 35.95,23.9 37.48,22.37 38.32,22.37 46.07,14.61 74.45,14.61 81.34,21.51 82.08,21.51 89.84,29.27 89.84,48.85 94.13,53.14 94.13,57.31 91.78,59.65 91.78,67.35 94.6,70.17 103.57,70.17 104.42,69.32 105.97,69.32 106.72,68.57 109.11,68.57 109.58,68.1 113.92,68.1 115.38,66.64 116.53,66.21 136.44,66.21 137.55,65.09 139.44,65.09 140.19,64.34 142.7,64.34 143.3,63.74 145.09,63.74 146.06,64.71 148.69,64.71 149.92,63.47 149.92,61.39 151.07,60.24 152.44,60.24 153.15,59.53 153.15,57.12 152.6,56.56 152.32,56.56 v4(152.24,56.48)
  BOTTOM w0.081: CR4.1 7.77,43.97 7.52,43.97 7.43,44.06 7.43,44.23 v4(7.51,44.31) ; UC1.CA6 151.81,56.51 151.84,56.54 152.17,56.54 v4(152.24,56.48)
PCIE_CRX_DTX_P3: length 137.2
  IN1 w0.076: v4(164.06,55.04) 164.06,55.14 163.99,55.22 163.91,55.22 163.87,55.26 163.74,55.26 163.6,55.12 163.6,53.93 164.89,52.65 166.46,52.65 167,52.11 172.87,52.11 174.92,50.06 175.3,50.06 175.61,49.75 177.38,49.75 177.5,49.63 179.64,49.63 179.73,49.54 181.93,49.54 183.61,47.87 183.61,45.9 183.81,45.7 184.61,45.7 185.5,44.8 185.5,43.71 186.85,42.36 189.04,42.36 193.36,38.04 194.81,38.04 196.35,36.5 196.93,36.5 198.86,34.57 198.86,31.45 198.59,31.18 198.59,28.84 198.86,28.57 198.86,19.15 205.98,12.04 212.18,12.04 213.35,10.87 217.21,10.87 217.79,10.28 221.64,10.28 222.01,10.66 225.89,10.66 225.9,10.66 236.96,10.66 237.67,9.96 239.45,9.96 241.02,11.53 243.35,11.53 244.8,12.98 250.01,12.98 253.97,16.94 254.73,16.94 258.73,20.94 258.92,20.94 v3(259.09,21.11)
  IN3 w0.076: v3(259.09,21.11) 258.93,20.94 256.46,20.94 256.17,21.23 256.17,22.81 256.1,22.87 256.1,22.91 256.17,22.98 256.5,22.98 v4(256.53,22.95)
  BOTTOM w0.081: v4(164.06,55.04) UC1.DE9
PCIE_CRX_DTX_P9: length 86.7
  IN3 w0.076: v4(158.21,56.34) 158.43,56.13 161.4,56.13 163.53,58.26 169.41,58.26 175.07,52.6 180.73,52.6 184.73,48.59 185.03,48.59 186.85,46.77 187.62,46.77 191.53,42.86 192.94,42.86 194.32,41.48 194.32,40.14 196.54,37.93 196.54,37.72 199.47,34.79 199.47,31.46 199.02,31.01 199.02,29.53 199.47,29.08 199.47,23.8 196.08,20.42 196.08,16.09 196.48,15.69 196.48,14.75 196.61,14.62 196.72,14.62 v4(196.81,14.71)
  BOTTOM w0.081: v4(196.81,14.71) 196.72,14.62 194.47,14.62 192.5,12.65 v7(192.5,11.68) 192.5,10.71 191.04,9.25 189.87,9.25 189.72,9.4 JNGFF1.7
PCIE_CRX_DTX_P10: length 97
  IN3 w0.076: v4(199.39,14.32) 199.3,14.41 199.3,14.72 200.32,15.74 200.32,20.27 202.8,22.75 202.8,27.65 203.42,28.27 203.42,34.66 202.7,35.38 202.7,37.13 199.41,40.42 199.41,40.67 193.27,46.81 191.71,46.81 182.13,56.4 180.26,56.4 178.8,57.85 174.55,57.85 170.49,61.92 165.67,61.92 165.41,61.66 162.98,61.66 161.91,60.59 160.69,60.59 159.58,59.48 159.58,57.47 158.91,56.81 157.89,56.81 157.43,56.34 v4(157.3,56.34)
  BOTTOM w0.081: JNGFF1.19 189.56,12.4 189.71,12.25 190.4,12.25 v7(190.79,12.65) 193.99,15.84 197.5,15.84 198.57,14.78 199.12,14.78 199.3,14.6 199.3,14.41 v4(199.39,14.32)
PCIE_CRX_DTX_P11: length 100.4
  IN3 w0.076: v4(200.26,14.34) 200.17,14.43 200.17,14.75 201.13,15.72 201.13,20.17 203.38,22.42 203.38,27.42 204.08,28.12 204.08,35.19 203.28,35.99 203.28,37.37 199.99,40.66 199.99,40.91 193.51,47.39 191.95,47.39 182.15,57.19 180.43,57.19 179.17,58.45 174.77,58.45 170.46,62.76 163.06,62.76 162.6,62.3 160.42,62.3 160.07,61.95 160.07,60.91 158.97,59.81 158.97,58.34 157.98,57.35 157.52,57.35 156.51,56.34 v4(156.38,56.34)
  BOTTOM w0.081: v4(200.26,14.34) 200.16,14.45 200.16,15 199.77,15.38 198.79,15.38 197.14,17.04 v7(195.62,17.04) 193.15,17.04 191.88,15.77 190.69,15.77 190.18,15.25 189.87,15.25 189.72,15.4 JNGFF1.31
PCIE_CRX_DTX_P12: length 102
  IN3 w0.076: v4(155.2,55.96) 155,56.15 155,56.25 155.08,56.33 156,56.33 157.3,57.63 157.8,57.63 158.53,58.36 158.53,60.95 160.36,62.78 162.49,62.78 162.85,63.14 170.75,63.14 175.04,58.85 179.36,58.85 180.6,57.6 182.28,57.6 192.11,47.77 193.67,47.77 200.37,41.07 200.37,40.82 203.66,37.53 203.66,36.22 204.46,35.42 204.46,27.96 203.77,27.26 203.77,22.26 201.75,20.24 201.75,15.81 v4(201.65,15.72)
  BOTTOM w0.081: UC1.CJ7 v4(155.2,55.96) ; v4(201.65,15.72) 201.74,15.81 201.74,16.02 201.66,16.1 v7(200.62,16.1) 200.18,16.1 199.42,16.86 198.71,16.86 197.52,18.05 189.87,18.05 189.72,17.9 JNGFF1.41
PCIE_CRX_DTX_P16: length 222
  IN3 w0.076: v4(7.13,44.31) 7.21,44.23 7.21,44.07 5.91,42.77 5.91,41.84 12.85,34.89 18.58,34.89 19.17,34.3 19.17,31.96 19.58,31.56 19.58,30.52 22.32,27.78 27.04,27.78 27.55,27.27 31.05,27.27 31.53,26.79 34.6,26.79 35.17,26.23 35.17,24.71 35.75,24.12 35.75,23.82 37.4,22.17 38.24,22.17 45.99,14.42 74.53,14.42 81.43,21.31 82.16,21.31 90.04,29.19 90.04,48.77 94.32,53.05 94.32,57.39 91.98,59.73 91.98,67.27 94.69,69.97 103.49,69.97 104.34,69.13 105.89,69.13 106.64,68.37 109.02,68.37 109.5,67.9 113.84,67.9 115.27,66.47 116.49,66.01 136.36,66.01 137.47,64.89 139.35,64.89 140.11,64.14 142.62,64.14 143.21,63.54 145.17,63.54 146.14,64.51 148.6,64.51 149.73,63.39 149.73,61.3 150.99,60.04 152.36,60.04 152.95,59.45 152.95,57.2 152.51,56.76 152.34,56.76 v4(152.24,56.86)
  BOTTOM w0.081: UC1.CA5 151.81,56.83 151.9,56.75 152.12,56.75 v4(152.24,56.86) ; CR3.1 7.77,43.77 7.44,43.77 7.23,43.98 7.23,44.21 v4(7.13,44.31)
PCIE_CTX_C_DRX_N3: length 1.5
  BOTTOM w0.081: UWL1.39 257.46,21.04 257.61,21.19 257.61,21.4 257.8,21.59 257.8,21.71 CH3.2
PCIE_CTX_C_DRX_N9: length 1.9
  BOTTOM w0.081: JNGFF1.11 189.72,10.4 189.87,10.55 190.36,10.55 CS26.2
PCIE_CTX_C_DRX_N10: length 2.8
  BOTTOM w0.081: JNGFF1.23 189.72,13.4 189.87,13.55 190.11,13.55 190.39,13.83 190.39,14.19 190.5,14.29 190.73,14.29 CS25.2
PCIE_CTX_C_DRX_N11: length 2.3
  BOTTOM w0.081: JNGFF1.35 189.72,16.4 189.87,16.55 190.71,16.55 CS98.2
PCIE_CTX_C_DRX_N12: length 2.4
  BOTTOM w0.081: CS96.2 190.7,19.17 190.35,19.17 189.97,19.55 189.87,19.55 189.72,19.4 JNGFF1.47
PCIE_CTX_C_DRX_N16: length 4.2
  BOTTOM w0.081: UCR1.4 9.71,41.69 9.61,41.59 9.31,41.59 8.93,41.22 8.93,39.85 9.35,39.43 9.35,39.03 9.41,38.97 CR2.2
PCIE_CTX_C_DRX_P3: length 1.5
  BOTTOM w0.081: UWL1.40 257.96,21.06 257.81,21.21 257.81,21.32 258,21.51 258,21.71 CH4.2
PCIE_CTX_C_DRX_P9: length 1.9
  BOTTOM w0.081: CS27.2 190.31,10.75 189.87,10.75 189.72,10.9 JNGFF1.13
PCIE_CTX_C_DRX_P10: length 2.8
  BOTTOM w0.081: JNGFF1.25 189.72,13.9 189.87,13.75 190.02,13.75 190.19,13.92 190.19,14.27 190.41,14.5 190.7,14.5 CS24.2
PCIE_CTX_C_DRX_P11: length 2.3
  BOTTOM w0.081: JNGFF1.37 189.72,16.9 189.87,16.75 190.73,16.75 CS99.2
PCIE_CTX_C_DRX_P12: length 2.4
  BOTTOM w0.081: CS97.2 190.73,19.37 190.44,19.37 190.06,19.75 189.87,19.75 189.72,19.9 JNGFF1.49
PCIE_CTX_C_DRX_P16: length 4.2
  BOTTOM w0.081: CR1.2 9.82,38.82 9.82,39.07 9.79,39.11 9.72,39.11 9.64,39.03 9.59,39.03 9.53,39.09 9.53,39.53 9.13,39.93 9.13,41.13 9.39,41.39 9.62,41.39 9.72,41.29 UCR1.3
PCIE_CTX_DRX_N3: length 135.8
  IN1 w0.076: v3(162.72,56.57) 162.94,56.57 163.2,56.83 163.55,56.83 164.73,55.65 164.73,53.82 165.32,53.23 166.77,53.23 167.27,52.72 167.88,52.72 168.26,53.1 172.71,53.1 175.17,50.64 175.54,50.64 175.85,50.33 177.63,50.33 177.74,50.21 179.95,50.21 180,50.15 182.16,50.15 184.21,48.1 184.21,46.91 186.08,45.04 186.08,43.95 187.09,42.94 189.28,42.94 193.16,39.05 194.76,39.05 196.38,37.43 196.82,37.43 199.44,34.81 199.44,31.18 199.17,30.91 199.17,29.08 199.44,28.81 199.44,19.39 206.22,12.62 212.43,12.62 213.58,11.47 217.44,11.47 218.05,10.86 220.96,10.86 221.34,11.24 225.41,11.24 225.41,11.24 237.2,11.24 237.84,10.6 239.27,10.6 240.77,12.11 243.11,12.11 244.56,13.56 249.77,13.56 253.74,17.52 254.49,17.52 257.93,20.96 257.93,21.23 v3(257.63,21.53)
  IN3 w0.076: v3(257.63,21.53) 257.8,21.7 257.8,23.01 257.72,23.09 257.5,23.09 257.44,23.03 v4(257.44,22.98) ; v4(164.29,57.71) 163.87,57.71 v3(162.72,56.57)
PCIE_CTX_DRX_N9: length 84.1
  IN3 w0.076: v4(197.28,14.62) 197.4,14.74 197.4,15.92 198.9,17.42 198.9,20.78 201.01,22.89 201.01,29.44 201.34,29.78 201.34,36.57 198.01,39.91 198.01,40.15 192.7,45.46 191.15,45.46 182.47,54.14 180.24,54.14 177.91,56.46 174.02,56.46 170.01,60.47 166.14,60.47 165.97,60.29 163.75,60.29 162.2,58.74 161.7,58.74 161.61,58.65 161.61,58.58 v4(161.82,58.37)
  BOTTOM w0.081: CS26.1 191.35,10.57 191.6,10.57 192.06,11.03 192.06,12.79 v7(194.04,14.78) 194.3,15.03 197.18,15.03 197.37,14.84 197.37,14.71 v4(197.28,14.62)
PCIE_CTX_DRX_N10: length 78.8
  IN3 w0.076: v4(161.26,58.04) 161.97,58.04 163.35,59.41 170.28,59.41 174.89,54.81 174.89,54.45 175.59,53.75 182.19,53.75 183.73,52.21 183.73,51.45 184.04,51.14 184.93,51.14 190.99,45.07 192.55,45.07 197.63,40 197.63,39.75 200.96,36.41 200.96,29.94 200.63,29.6 200.63,23.07 197.72,20.16 197.72,17.11 196.86,16.25 196.62,16.25 v4(196.53,16.15)
  BOTTOM w0.081: v4(196.53,16.15) 196.44,16.24 v7(194.15,16.24) 193.84,16.24 191.91,14.32 191.74,14.32 CS25.1
PCIE_CTX_DRX_N11: length 85.2
  IN3 w0.076: v4(161.02,58.37) 160.67,58.37 160.57,58.46 160.57,58.64 160.67,58.74 161.14,58.74 161.33,58.93 161.33,59.43 161.74,59.84 162.4,59.84 163.44,60.88 165.73,60.88 165.96,61.1 170.2,61.1 174.26,57.04 178.32,57.04 180.65,54.71 182.71,54.71 191.39,46.03 192.94,46.03 198.63,40.35 198.63,40.1 201.92,36.81 201.92,29.54 201.59,29.2 201.59,22.65 199.49,20.55 199.49,16.76 199.25,16.53 199.25,15.79 v4(199.16,15.69)
  BOTTOM w0.081: CS98.1 191.73,16.54 191.96,16.54 192.86,17.44 v7(196.89,17.44) 197.29,17.44 198.56,16.17 198.96,16.17 199.25,15.88 199.25,15.78 v4(199.16,15.69) ; UC1.CW2 v4(161.02,58.36)
PCIE_CTX_DRX_N12: length 76.2
  IN3 w0.076: v4(160.69,57.06) 160.69,56.82 160.76,56.75 160.87,56.75 161.04,56.92 161.79,56.92 163.51,58.64 169.59,58.64 175.25,52.98 181.78,52.98 182.95,51.8 182.95,50.98 184.64,49.3 185.67,49.3 188.09,46.87 188.09,46.84 191.69,43.24 193.1,43.24 194.7,41.64 194.7,40.3 197.29,37.72 198.56,37.72 200.19,36.09 200.19,30.26 199.85,29.92 199.85,23.48 196.46,20.1 196.46,18.86 196.65,18.67 196.82,18.67 v4(196.91,18.57)
  BOTTOM w0.081: CS96.1 191.75,19.17 191.93,19.17 192.44,18.66 v7(193.59,18.66) 196.83,18.66 v4(196.91,18.57)
PCIE_CTX_DRX_N16: length 216.1
  IN3 w0.076: v4(157.9,58.84) 157.8,58.74 157.65,58.74 157.24,58.34 156.94,58.34 156.6,58.67 156.6,60.24 150.54,66.31 149.04,66.31 148.79,66.07 143.77,66.07 143.39,65.7 141.93,65.7 140.53,67.1 137.89,67.1 137.4,67.58 116.92,67.58 116.07,67.9 115.97,67.98 114.49,69.46 110.25,69.46 109.73,69.98 107.24,69.98 106.53,70.69 104.98,70.69 104.14,71.53 93.67,71.53 90.39,68.26 90.39,59.12 92.75,56.76 92.75,53.69 88.48,49.42 88.48,30.6 73.85,15.98 46.67,15.98 36.97,25.67 36.97,27.4 33.95,30.42 32.27,30.42 31.23,29.38 23.13,29.38 21.4,31.11 21.4,32.02 20.74,32.68 20.74,35.38 19.24,36.87 13.88,36.87 13.65,36.64 13.65,36.42 13.5,36.26 v4(13.46,36.26)
  BOTTOM w0.081: UC1.CP1 158.07,59.01 v4(157.9,58.84) ; CR2.1 9.64,37.85 9.64,37.69 v7(10.2,37.13) 10.76,36.57 13.57,36.57 13.63,36.51 13.63,36.43 v4(13.46,36.26)
PCIE_CTX_DRX_P3: length 135.9
  IN1 w0.076: v3(258.17,21.53) 258.17,20.91 254.58,17.33 253.82,17.33 249.85,13.36 244.64,13.36 243.19,11.91 240.86,11.91 239.36,10.41 237.76,10.41 237.12,11.04 225.49,11.04 225.49,11.04 221.42,11.04 221.05,10.67 217.97,10.67 217.36,11.27 213.5,11.27 212.35,12.42 206.13,12.42 199.24,19.31 199.24,28.73 198.97,29 198.97,30.99 199.24,31.26 199.24,34.73 196.74,37.23 196.3,37.23 194.68,38.85 193.08,38.85 189.2,42.74 187.01,42.74 185.88,43.87 185.88,44.96 184.02,46.83 184.02,48.02 182.08,49.95 179.92,49.95 179.86,50.01 177.66,50.01 177.54,50.13 175.77,50.13 175.46,50.44 175.09,50.44 172.63,52.91 168.35,52.91 167.96,52.52 167.19,52.52 166.68,53.03 165.24,53.03 164.53,53.73 164.53,55.57 163.47,56.63 163.29,56.63 163.1,56.44 v3(163.1,56.19)
  IN3 w0.076: v4(164.29,57.06) 164.29,57.33 164.1,57.52 163.95,57.52 163.1,56.66 v3(163.1,56.19) ; v3(258.17,21.53) 258,21.7 258,22.68 258.3,22.98 v4(258.36,22.98)
PCIE_CTX_DRX_P9: length 84.1
  IN3 w0.076: v4(161.82,59.02) 161.9,58.94 162.11,58.94 163.66,60.49 165.88,60.49 166.06,60.67 170.1,60.67 174.11,56.66 177.99,56.66 180.32,54.33 182.55,54.33 191.23,45.65 192.79,45.65 198.21,40.24 198.21,39.99 201.54,36.65 201.54,29.7 201.2,29.36 201.2,22.81 199.09,20.7 199.09,17.34 197.6,15.84 197.6,14.69 v4(197.66,14.62)
  BOTTOM w0.081: CS27.1 191.35,10.77 191.52,10.77 191.86,11.12 191.86,12.88 v7(192.52,13.53) 194.21,15.23 197.27,15.23 197.58,14.92 197.58,14.71 v4(197.66,14.62)
PCIE_CTX_DRX_P10: length 78.7
  IN3 w0.076: v4(196.53,16.53) 196.62,16.44 196.78,16.44 197.52,17.19 197.52,20.25 200.43,23.15 200.43,29.68 200.77,30.02 200.77,36.33 197.43,39.67 197.43,39.91 192.46,44.88 190.91,44.88 184.84,50.94 183.96,50.94 183.53,51.37 183.53,52.13 182.11,53.56 175.51,53.56 174.69,54.37 174.69,54.72 170.2,59.22 163.43,59.22 162.06,57.84 161.5,57.84 161.44,57.78 161.44,57.69 161.58,57.55 161.58,57.45 161.53,57.39 v4(161.26,57.39)
  BOTTOM w0.081: CS24.1 191.72,14.52 191.83,14.52 v7(192.66,15.35) 193.75,16.45 196.44,16.45 v4(196.53,16.53)
PCIE_CTX_DRX_P11: length 85.1
  IN3 w0.076: v4(199.54,15.69) 199.45,15.78 199.45,16.45 199.68,16.68 199.68,20.47 201.78,22.57 201.78,29.12 202.12,29.46 202.12,36.89 198.83,40.18 198.83,40.43 193.03,46.23 191.47,46.23 182.79,54.91 180.73,54.91 178.4,57.24 174.35,57.24 170.28,61.3 165.88,61.3 165.65,61.07 163.36,61.07 162.32,60.04 161.66,60.04 161.13,59.51 161.13,59.12 v4(161.02,59.02)
  BOTTOM w0.081: CS99.1 191.73,16.74 191.88,16.74 192.78,17.65 197.37,17.65 v7(198.26,16.76) 198.64,16.38 199.04,16.38 199.45,15.97 199.45,15.78 v4(199.54,15.69) ; v4(161.02,59.02) 161.13,58.91 161.13,58.85 161.02,58.75 160.86,58.75 160.69,58.92 UC1.CW1
PCIE_CTX_DRX_P12: length 76.3
  IN3 w0.076: v4(160.69,57.71) 160.95,57.46 160.95,57.24 161.07,57.12 161.71,57.12 163.43,58.84 169.67,58.84 175.33,53.17 181.86,53.17 183.15,51.88 183.15,51.06 184.72,49.5 185.75,49.5 188.29,46.96 188.29,46.92 191.77,43.44 193.18,43.44 194.9,41.72 194.9,40.38 197.37,37.91 198.64,37.91 200.38,36.17 200.38,30.18 200.05,29.84 200.05,23.4 196.66,20.02 196.66,18.94 196.74,18.86 196.83,18.86 v4(196.91,18.95)
  BOTTOM w0.081: CS97.1 191.72,19.37 192.01,19.37 192.52,18.86 v7(194.93,18.86) 196.83,18.86 v4(196.91,18.95)
PCIE_CTX_DRX_P16: length 216
  IN3 w0.076: v4(157.9,58.46) 157.82,58.54 157.73,58.54 157.32,58.14 156.85,58.14 156.41,58.59 156.41,60.16 150.45,66.11 149.12,66.11 148.88,65.87 143.85,65.87 143.47,65.5 141.85,65.5 140.44,66.9 137.8,66.9 137.32,67.38 116.88,67.38 115.97,67.73 115.84,67.84 114.41,69.26 110.17,69.26 109.65,69.78 107.16,69.78 106.45,70.49 104.9,70.49 104.05,71.34 93.75,71.34 90.59,68.18 90.59,59.2 92.95,56.84 92.95,53.61 88.68,49.34 88.68,30.52 73.94,15.78 46.58,15.78 36.77,25.59 36.77,27.32 33.87,30.22 32.35,30.22 31.31,29.18 23.05,29.18 21.2,31.02 21.2,31.94 20.54,32.6 20.54,35.29 19.16,36.68 13.96,36.68 13.85,36.56 13.85,36.41 v4(14,36.26)
  BOTTOM w0.081: v4(157.9,58.46) 157.9,58.56 157.94,58.6 158.2,58.6 158.3,58.51 158.3,58.44 UC1.CP2 ; CR1.1 9.84,37.94 9.84,37.78 10.84,36.77 13.65,36.77 13.83,36.59 13.83,36.43 v4(14,36.26)
PCIE_RCOMPN: length 2.5
  BOTTOM w0.081: RH1.1 167.1,60.9 167.44,60.56 UC1.DN1
PCIE_RCOMPP: length 3.2
  BOTTOM w0.081: RH1.2 167.64,60.99 167.64,58.95 167.79,58.81 167.79,58.39 UC1.DN3
PCIE_WAKE#: length 97.7
  TOP w0.069: v1(190.11,10.89) 189.98,10.76 v3(189.22,10.76)
  IN1 w0.061: v4(177.93,7.26) 177.93,7.75 177.69,7.99 v2(177.46,7.99)
  IN2 w0.051: v4(177.93,7.26) 178.24,7.57 180.58,7.57 181.6,8.59 185.1,8.59 186.66,10.14 188.61,10.14 v3(189.22,10.76) 191.25,8.73 194.53,8.73 195.62,9.82 198.11,9.82 200.25,7.68 210.55,7.68 211.01,8.15 215.56,8.15 215.99,7.71 222.84,7.71 223,7.87 227.84,7.87 228.09,7.61 241.52,7.61 242.92,9.01 244.14,9.01 246.02,10.89 246.02,11.58 246.57,12.13 247.26,12.13 250.04,14.92 250.04,17.11 252.29,19.35 252.29,19.93 v4(252.31,19.96)
  IN3 w0.061: v3(174.03,14.01) v4(174.03,14.34)
  BOTTOM w0.069: v4(174.03,14.34) 175.48,12.9 175.48,9.77 177.93,7.32 v4(177.93,7.26) ; UWL1.29 252.46,20.29 252.31,20.14 v4(252.31,19.96)
PCIE_WAKE#_R: length 3.6
  TOP w0.069: UE1.N13 187.98,11.34 RE481.1 RE185.1
PCM_CLK: length 121.8
  TOP w0.069: DR15.1 266.69,20.49 266.54,20.64 265.65,20.64 264.94,19.93 261.25,19.93 257.84,23.33 v1(256.81,23.33) v3(253.56,23.33)
  IN1 w0.061: v3(168.95,41.95) 168.77,41.95 168.49,41.67 168.49,40.58 168.85,40.23 169.84,40.23 170.93,39.13 171.51,39.13 171.67,38.98 173.65,38.98 174.87,37.76 v3(174.87,37.48)
  IN2 w0.051: v3(243.51,17.35) 243.51,17.35 243.04,16.88 242.16,16.88 241.76,16.48 239.26,16.48 238.34,15.55 226.77,15.55 226.21,16.11 212.45,16.11 211.34,17.21 205.27,17.21 204.18,18.3 201.66,18.3 198.59,21.37 198.59,25.96 196.7,27.86 195.11,27.86 192,30.97 189.5,30.97 188.74,31.73 187.2,31.73 186.31,32.61 182.7,32.61 182.01,33.29 180.87,33.29 180.8,33.22 177.47,33.22 177.29,33.4 177.29,33.4 174.87,35.82 v3(174.87,37.48)
  IN3 w0.061: v3(243.51,17.35) 243.68,17.52 244.59,17.52 245.93,18.86 247.49,18.86 249.97,21.34 250.73,21.34 251.8,22.42 252.59,22.42 253.51,23.33 v3(253.56,23.33) ; v4(168.49,42.02) 168.88,42.02 v3(168.95,41.95)
  BOTTOM w0.069: UC1.DP33 168.03,43.27 168.47,42.82 168.47,42.04 v4(168.49,42.02)
PCM_CLK_R: length 7.9
  BOTTOM w0.069: UWL1.61 263.44,14.01 264.17,14.73 265.51,14.73 265.84,15.06 265.84,18.09 266.31,18.56 266.31,18.79 v4(266.69,19.17)
PCM_IN: length 122.7
  TOP w0.069: DR16.1 258.79,15.33 258.51,15.05 258.51,14.21 v2(258.46,14.17)
  IN1 w0.061: v3(244.96,10.57) 245,10.53 247.64,10.53 247.74,10.64 256.9,10.64 258.36,12.1 258.36,14.07 v2(258.46,14.17)
  IN2 w0.051: v3(175.3,29.43) 175.35,29.38 179.65,29.38 180.8,28.23 184,28.23 184.96,27.27 186.46,27.27 187.58,26.15 188.16,26.15 189.71,24.6 190.16,24.6 192.13,22.64 194.08,22.64 195.41,23.97 195.8,23.97 195.92,23.84 195.92,20.26 202.18,14 205.94,14 206.48,14.55 210.23,14.55 211.34,13.44 220.42,13.44 v3(221.39,12.47)
  IN3 w0.061: v3(221.39,12.47) 221.39,12.46 221.7,12.15 223.42,12.15 224.07,11.5 235.24,11.5 236.93,13.19 243.74,13.19 244.18,12.74 244.18,11.36 244.84,10.7 244.84,10.69 v3(244.96,10.57) ; v3(175.3,29.43) 175.21,29.52 174.76,29.52 174.62,29.65 171.76,29.65 168.98,32.43 167.24,32.43 165.83,33.84 164.32,33.84 163.58,34.57 163.12,34.57 162.83,34.87 161.25,34.87 160.08,36.03 160.08,36.7 160.25,36.86 160.43,36.86 160.77,37.2 161.38,37.2 v4(161.84,37.66)
  BOTTOM w0.069: v4(161.84,37.66) 161.84,37.61 161.61,37.38 UC1.DA45
PCM_OUT: length 128.9
  TOP w0.069: v2(255.64,22.45) 255.69,22.5 v1(258.1,22.5) 258.4,22.5 261.22,19.68 265.44,19.68 DR14.1
  IN1 w0.061: v2(255.64,22.45) 255.36,22.17 255.36,21.77 255.1,21.51 253.79,21.51 252.68,20.4 252.14,20.4 251.96,20.22 251.96,19.51 249.12,16.68 248.48,16.68 248.08,17.09 246.93,17.09 245.74,15.9 243.64,15.9 243.11,15.37 v3(242.86,15.37)
  IN2 w0.051: v3(166.56,32.63) 169.22,32.63 171.77,30.08 174.08,30.08 174.45,30.45 175.23,30.45 175.99,29.68 179.78,29.68 180.93,28.53 184.12,28.53 185.08,27.58 186.59,27.58 187.71,26.46 189.18,26.46 189.57,26.06 189.57,25.39 189.78,25.19 190.11,25.19 190.23,25.32 190.54,25.32 191.89,23.97 191.89,23.26 192.36,22.79 194.01,22.79 195.11,23.89 195.11,24.53 195.42,24.83 195.9,24.83 196.08,24.66 196.08,20.32 202.24,14.16 205.88,14.16 206.42,14.7 210.3,14.7 211.4,13.59 220.75,13.59 221.72,12.62 221.72,12.24 221.81,12.16 223.09,12.16 223.26,12.33 223.58,12.33 224.09,12.84 225.07,12.84 225.5,12.41 232.91,12.41 234.6,14.11 239.09,14.11 240.01,15.03 242.66,15.03 242.86,15.23 v3(242.86,15.37)
  IN3 w0.061: v4(161.3,34.59) 161.51,34.59 161.79,34.31 163.44,34.31 164.07,33.67 165.61,33.67 166.56,32.72 v3(166.56,32.63)
  BOTTOM w0.069: UC1.DA48 161.61,35.87 161.38,35.64 161.38,35.41 161.3,35.33 v4(161.3,34.59)
PCM_OUT_R: length 7.4
  BOTTOM w0.069: v4(265.85,19.17) 266.1,18.92 266.1,18.64 265.67,18.2 265.67,15.13 265.44,14.9 264.1,14.9 263.7,14.51 UWL1.60
PCM_SYNC: length 123.8
  TOP w0.069: DR17.1 258.61,11.65 258.46,11.5 v2(258.46,10.15) 258.46,8.96 v1(258.26,8.76)
  IN1 w0.061: v2(258.46,10.15) 258.3,9.99 248.19,9.99 247.36,9.16 246.97,9.16 246.89,9.24 245.35,9.24 245.25,9.34 v3(243.47,9.34) ; v3(169.4,29) 168.93,29.47 168.93,30.75 167.76,31.92 165.25,31.92 163.66,33.51 163.66,34.18 163.48,34.36 161.61,34.36 161.38,34.13 v4(161.38,33.9)
  IN2 w0.051: v3(169.4,29) 170.48,29 171.09,28.39 173.1,28.39 v3(173.28,28.21) ; v3(243.47,9.34) 243.03,9.34 241.46,7.76 228.21,7.76 227.95,8.02 222.94,8.02 222.8,7.88 216.08,7.88 215.6,8.36 211.01,8.36 210.48,7.83 202.02,7.83 201.89,7.96 201.89,8.65 201.61,8.93 201.12,8.93 198.78,11.27 193.56,11.27 193.36,11.07 192.7,11.07 192.11,11.66 v3(191.6,11.66)
  IN3 w0.061: v3(191.6,11.66) 191.6,11.81 189.83,13.58 188.4,13.58 187.23,14.75 187.23,17.23 186.71,17.74 186.71,18.47 185.63,19.55 185.63,20.01 185.07,20.58 184.49,20.58 184.37,20.7 184.37,21.68 184.24,21.81 183.09,21.81 182.87,21.59 182.87,21.23 182.67,21.03 182.4,21.03 181.53,20.15 180.74,20.15 180.21,20.68 176.5,20.68 175.7,21.48 175.7,22.42 174.8,23.32 174.8,26.25 173.28,27.77 v3(173.28,28.21)
  BOTTOM w0.069: UC1.DA49 161.61,34.36 161.38,34.13 v4(161.38,33.9)
PD_EE_CLK_L: length 39.3
  TOP w0.069: v2(29.05,40.81) 31.41,40.81 v1(31.53,40.69) 32.1,40.12 34.12,40.12 35.6,38.63 35.6,35.05 34.81,34.26 JDB1.2
  IN1 w0.061: v2(29.05,40.81) v4(29.03,40.82)
  IN3 w0.061: v4(29.03,40.82) 30.4,40.82 32.53,42.95 34.97,42.95 36.61,44.59 36.61,48.74 36.08,49.26 36.08,59.65 v4(36.18,59.76)
  BOTTOM w0.069: v4(36.18,59.76) 36.19,59.75 UPD3.6 ; UPD1.38 29.01,40.77 29.03,40.8 v4(29.03,40.82)
PD_EE_CLK_R: length 57.9
  TOP w0.069: v2(276.44,46.68) 276.54,46.58 JDB2.2 ; UPD2.38 261.4,42.92 261.42,42.94 261.42,43.13 261.46,43.17 v2(261.46,43.25)
  IN1 w0.061: v3(261.46,42.87) v2(261.46,43.25) ; v2(276.44,46.68) 274.41,46.68 v3(274.28,46.8)
  IN3 w0.061: v4(258.35,28.34) 258.35,28.34 258.67,28.66 258.67,28.8 260.45,30.58 260.45,32.29 259.92,32.82 259.92,35.86 259.14,36.64 259.14,41.85 260.36,43.07 260.54,43.07 260.69,43.22 261.1,43.22 v3(261.46,42.87) 262.31,42.01 265.06,42.01 265.54,42.49 269.15,42.49 269.3,42.34 271.68,42.34 274,44.67 274,46.53 v3(274.28,46.8)
  BOTTOM w0.069: UPD4.6 v1(246.81,24.2) 246.81,24.39 250.49,28.07 257.73,28.07 258,28.34 v4(258.35,28.34)
PD_EE_CS#_L: length 30.1
  TOP w0.069: JDB1.5 34.84,35.76 35.09,36.01 35.09,38.42 34.46,39.06 v1(32.42,39.06) 31.96,39.06 31.09,39.92 v2(29.43,39.92)
  IN1 w0.061: v2(29.43,39.92) 29.43,40.36 v4(29.35,40.43)
  IN3 w0.061: v4(37.71,51.2) 37.43,50.91 37.43,45.18 35.04,42.79 32.6,42.79 30.29,40.48 29.41,40.48 v4(29.35,40.43)
  BOTTOM w0.069: v4(29.35,40.43) 29.41,40.38 UPD1.39 ; UPD3.1 38.73,52.33 38.73,51.36 RPD11.2 38.07,51.2 v4(37.71,51.2)
PD_EE_CS#_R: length 64.4
  TOP w0.069: UPD2.39 261,43.2 v2(260.95,43.25) ; JDB2.5 v2(276.9,48.08)
  IN1 w0.061: v2(276.9,48.08) 276.9,46.6 276.54,46.25 v3(274.44,46.25) ; v3(260.95,42.87) v2(260.95,43.25)
  IN3 w0.061: v4(250.72,24.74) 251.1,24.74 252.63,26.27 257.75,26.27 258.83,27.35 258.83,28.73 260.61,30.51 260.61,32.36 260.08,32.88 260.08,35.93 259.31,36.7 259.31,41.79 260.39,42.87 v3(260.95,42.87) 261.97,41.85 265.13,41.85 265.61,42.33 269.08,42.33 269.23,42.18 271.74,42.18 274.44,44.87 v3(274.44,46.25)
  BOTTOM w0.069: v4(250.72,24.74) v1(250.18,24.2) 249.99,24.01 249.99,15.65 249.35,15.01 UPD4.1 249.35,12.63 RPD59.2
PD_EE_MISO_L: length 35.2
  TOP w0.069: JDB1.4 34.58,35.26 35.26,35.94 35.26,38.49 34.22,39.54 32.03,39.54 31.34,40.23 v1(29.02,40.23) v2(28.21,40.23)
  IN1 w0.061: v2(28.21,40.23) v4(28.21,40.86)
  IN3 w0.061: v4(37.74,50.84) 37.59,50.7 37.59,45.11 35.11,42.63 32.8,42.63 30.19,40.02 28.54,40.02 28.21,40.35 v4(28.21,40.86)
  BOTTOM w0.069: UPD1.36 v4(28.21,40.86) 28.37,40.86 RPD181.2 ; v4(37.74,50.84) 37.15,50.84 RPD12.2 37.05,51.25 37.46,51.67 UPD3.2
PD_EE_MISO_R: length 69.3
  TOP w0.069: v1(261.53,45.56) 261.18,45.2 261.18,43.91 261.35,43.73 RPD182.2 261.71,43.73 262.19,43.25 v2(262.22,43.25) 262.22,42.92 262.2,42.9 UPD2.36 ; JDB2.4 v2(276.44,47.58)
  IN1 w0.061: v2(276.44,47.58) 274.52,47.58 v3(274.28,47.82) ; v2(262.22,43.25) 262.32,43.25 v3(262.55,43.02)
  IN3 w0.061: v4(250.33,24.91) 250.45,25.04 251.12,25.04 252.52,26.44 257.12,26.44 257.98,27.3 257.98,28.71 260.12,30.85 260.12,32.16 259.6,32.68 259.6,34.31 258.26,35.64 258.26,40.03 258.82,40.59 258.82,41.99 260.22,43.39 260.4,43.39 260.56,43.55 261.23,43.55 261.42,43.37 261.66,43.37 261.81,43.22 262.35,43.22 v3(262.55,43.02) 263.23,42.33 264.93,42.33 265.41,42.81 269.28,42.81 269.43,42.66 271.54,42.66 273.61,44.74 273.61,46.85 273.9,47.14 273.9,47.44 v3(274.28,47.82)
  BOTTOM w0.069: v4(250.33,24.91) 249.82,24.4 249.82,19.72 249.77,19.68 249.77,15.79 249.62,15.64 248.58,15.64 248.08,15.14 UPD4.2 248.08,12.63 RPD60.2
PD_EE_MOSI_L: length 39.5
  TOP w0.069: JDB1.3 34.71,34.76 35.43,35.49 35.43,38.56 34.17,39.83 v1(33.75,39.83) 31.98,39.83 31.28,40.53 v4(28.61,40.53)
  IN3 w0.061: v4(34.91,59.75) 35.91,58.75 35.91,49.2 36.44,48.67 36.44,44.65 34.91,43.12 32.32,43.12 30.52,41.32 28.89,41.32 28.59,41.01 28.59,40.61 28.61,40.58 v4(28.61,40.53)
  BOTTOM w0.069: UPD3.5 34.92,59.74 v4(34.91,59.75) ; UPD1.37 28.61,40.52 v4(28.61,40.53)
PD_EE_MOSI_R: length 59
  TOP w0.069: v2(261.81,43.25) 261.81,42.77 261.8,42.75 UPD2.37 ; JDB2.3 v2(276.46,47.08)
  IN1 w0.061: v2(276.46,47.08) 274.52,47.08 v3(274.28,47.31) ; v3(261.96,42.87) 261.81,43.02 v2(261.81,43.25)
  IN3 w0.061: v4(258.41,28.77) 258.41,28.91 260.28,30.78 260.28,32.23 259.76,32.75 259.76,35.79 258.98,36.57 258.98,41.92 260.29,43.23 260.47,43.23 260.63,43.39 261.16,43.39 261.35,43.2 261.6,43.2 261.93,42.87 v3(261.96,42.87) 262.66,42.17 264.99,42.17 265.47,42.65 269.21,42.65 269.36,42.5 271.61,42.5 273.78,44.67 273.78,46.78 274.28,47.29 v3(274.28,47.31)
  BOTTOM w0.069: UPD4.5 v1(245.54,23.4) 250.38,28.24 257.6,28.24 258.13,28.77 v4(258.41,28.77)
PD_EE_WP#_L: length 3.3
  BOTTOM w0.069: UPD3.3 36.19,51.36 RPD14.2 35.65,50.82 34.84,50.82 v1(34.79,50.76)
PD_EE_WP#_R: length 3
  BOTTOM w0.069: v1(245.89,12.54) 246.75,12.54 RPD62.2 246.81,12.6 UPD4.3
PD_HOLD#_L: length 3.6
  BOTTOM w0.069: UPD3.7 37.46,60.27 37.08,60.65 37.08,60.92 RPD13.2 37.22,61.28 v1(37.22,62.2)
PD_HOLD#_R: length 3.7
  BOTTOM w0.069: RPD61.2 247.69,23.31 v1(247.26,22.88) 247.26,22.57 248.08,21.75 UPD4.7
PD_ID: length 13.3
  IN1 w0.061: v2(174.03,20.49) 174.03,20.36 v3(173.77,20.09) ; v2(183.93,16.19) v3(183.93,15.86)
  IN2 w0.051: v3(173.77,20.09) 173.84,20.16 177.61,20.16 178.45,19.32 180.86,19.32 182.59,17.59 182.59,16.78 183.51,15.86 v3(183.93,15.86)
PD_L_DDM_MUX1_EN: length 52.2
  IN1 w0.061: v4(27.12,42.44) 25.82,43.73 24.96,43.73 24.44,44.25 22.49,44.25 18.94,47.81 18.94,64.41 22.8,68.27 28.54,68.27 29.25,67.56 32.22,67.56 v2(34.5,65.27)
  BOTTOM w0.069: RPD123.1 33.16,42.13 32.38,42.91 v1(31.56,42.91) 27.59,42.91 v4(27.12,42.44)
PD_L_DDM_MUX1_EN_R: length 6
  BOTTOM w0.069: UPD1.42 30.61,40.28 30.86,40.53 31.51,40.53 31.84,40.2 32.5,40.2 33.16,40.85 RPD123.2 RPD191.1 34.41,41.34 v1(34.69,41.06)
PD_L_DRAIN1: length 0.7
  TOP w0.069: v1(24.7,34.31) 24.72,34.3 25.43,34.3
  vias: v5(25.49,34.89) v5(25.49,33.6) v5(26.53,34.89) v5(26.53,33.6) v5(27.57,34.89) v5(27.57,33.6)
PD_L_DRAIN2: length 0.7
  TOP w0.069: 30.53,34.21 v1(31.26,34.21)
  vias: v5(28.39,34.89) v5(28.39,33.6) v5(29.46,34.89) v5(29.46,33.6) v5(30.52,34.89) v5(30.52,33.6)
PD_L_GPIO2: length 13.3
  IN3 w0.061: v4(23.74,34.92) 23.74,35.43 25.01,36.7 33.09,36.7 v4(33.63,36.16)
  BOTTOM w0.069: v4(33.63,36.16) 33.87,36.39 v1(34.68,36.39) ; UPD1.18 23.94,34.72 v4(23.74,34.92)
PD_L_GPIO4: length 7
  IN3 w0.061: v4(33.05,40.03) 31.49,40.03 31.18,39.72 v4(26.21,39.72)
PD_L_GPIO16: length 5.5
  BOTTOM w0.069: RPD141.2 34,39.66 34,37.66 v1(33.81,37.47) 33.06,36.72 UPD1.48
PD_L_GPIO17: length 1.7
  BOTTOM w0.069: RPD139.1 32.88,36.32 UPD1.49
PD_L_GPIO18: length 1.8
  BOTTOM w0.069: UPD1.50 32.13,35.92 32.46,35.6 RPD204.1
PD_L_GPIO19: length 3.8
  BOTTOM w0.069: v1(34.61,35.1) 34.11,35.6 RPD204.2 33.31,35.27 32.68,35.27 32.13,34.72 UPD1.53
PD_L_PROCHOT#: length 5.2
  BOTTOM w0.069: UPD1.40 29.78,39.54 29.78,40.53 v1(29.73,40.58) 29.73,40.68 29.67,40.74 RPD185.2 30.07,42.38 31.56,42.38 RPD183.1
PD_L_R_PROCHOT#: length 326.2
  TOP w0.069: v2(103.6,9.21) PR104.1
  IN1 w0.061: v3(104.1,9.47) 103.85,9.21 v2(103.6,9.21)
  IN2 w0.051: v3(260.74,44.9) 260.92,44.71 260.92,43.53 260.14,42.74 260.14,41.33 259.94,41.14 258.99,41.14 257.6,39.75 257.6,35.8 259.23,34.16 259.23,28.86 258.48,28.1 258.48,27.86 255.21,24.59 255.21,23.94 253.15,21.89 253.15,19.21 250.71,16.76 250.71,14.64 248.52,12.46 248.52,11.38 247.78,10.63 246.7,10.63 246.25,10.18 246.25,9.44 245.16,8.35 243.19,8.35 241.8,6.95 227.72,6.95 227.5,7.18 225.79,7.18 225.13,6.52 198.7,6.52 198.49,6.32 197.75,6.32 197.21,6.85 195.95,6.85 195.72,7.08 193.99,7.08 193.54,6.62 185.02,6.62 184.69,6.29 181.14,6.29 180.68,5.83 179.9,5.83 179.85,5.78 178.5,5.78 177.89,5.17 171.89,5.17 170.7,6.37 150.87,6.37 150.42,5.91 129.58,5.91 125.41,1.74 114.77,1.74 112.1,4.41 v3(110.99,4.41) 110.99,3.9 109.18,2.1 95.96,2.1 92.6,5.45 43.18,5.45 42.98,5.25 42.25,5.25 40.81,3.8 39.69,3.8 38.07,2.18 30.23,2.18 28.87,3.54 28.87,12.41 30,13.54 30,18.46 29.17,19.28 29.17,21.58 29.71,22.12 29.71,28.58 32.75,31.63 32.75,37.79 30.95,39.59 30.95,40.91 v4(29.27,42.59)
  IN3 w0.061: v3(110.99,4.41) 110.99,5.12 110.33,5.78 108.04,5.78 104.36,9.47 v3(104.1,9.47)
  BOTTOM w0.069: v4(29.27,42.59) 29.31,42.56 RPD185.1
PD_L_SINK_ARB_MASTER_OUT: length 1.9
  BOTTOM w0.069: RPD174.2 32.42,34.32 UPD1.54
PD_L_SINK_ARB_SLAVE_IN: length 2.4
  BOTTOM w0.069: UPD1.55 32.66,33.92 32.9,33.68 RPD189.1 RPD172.2
PD_L_SLAVE_IN: length 298.6
  IN1 w0.061: v3(259.56,28.85) 259.9,29.18 259.9,32.08 259.28,32.7 259.28,34.11 257.1,36.29 257.1,36.96 v2(256.77,37.29)
  IN2 w0.051: v3(259.56,28.85) 259.56,28.25 259.29,27.98 259.04,27.98 255.51,24.46 255.51,23.82 254.04,22.34 254.04,20.49 254.14,20.39 254.14,19.24 251.04,16.13 251.04,14.54 248.82,12.33 248.82,11.25 247.9,10.33 246.83,10.33 246.55,10.06 246.55,9.31 245.28,8.04 243.32,8.04 241.92,6.65 227.6,6.65 227.37,6.88 225.92,6.88 225.26,6.22 198.82,6.22 198.62,6.01 197.62,6.01 197.19,6.44 195.86,6.44 195.61,6.7 194.11,6.7 193.55,6.14 188.88,6.14 187.96,5.22 184.54,5.22 184.15,4.83 171.81,4.83 170.57,6.06 151,6.06 150.54,5.61 129.71,5.61 125.39,1.29 96.34,1.29 92.48,5.15 43.3,5.15 43.1,4.95 42.38,4.95 41.11,3.68 41.11,3.36 40.69,2.94 39.43,2.94 38.37,1.87 29.17,1.87 28.51,2.53 28.51,12.49 29.68,13.66 29.68,18.15 28.84,18.99 28.84,21.7 29.4,22.26 29.4,28.71 32.07,31.37 v3(32.07,33.67)
  IN3 w0.061: v3(32.07,33.67) 32.99,33.67 v4(33.63,34.31)
  BOTTOM w0.069: v4(33.63,34.31) 33.63,34.29 34.2,33.72 v1(34.61,33.72)
PD_L_USB_MUX1_EN: length 43.9
  TOP w0.069: v2(29,62.82) 28.42,62.82 28.18,63.06 v1(28,63.06)
  IN1 w0.061: v2(29,62.82) 28.66,63.16 23.46,63.16 v3(23.08,62.78)
  IN3 w0.061: v3(23.08,62.78) 22.26,61.97 21.93,61.97 20.75,60.78 20.75,47.11 22.49,45.37 22.49,39.41 21.89,38.81 21.89,35.01 22.53,34.37 22.53,33.41 22.11,32.99 22.11,31.31 23.18,30.24 23.61,30.24 v4(24.01,30.64)
PD_L_USB_MUX1_EN_R: length 5.2
  BOTTOM w0.069: UPD1.16 23.8,33.92 23.56,33.68 23.56,31.41 RPD190.1 RPD187.2 23.43,30.22 v1(23.84,29.81)
PD_R_DDM_MUX1_EN: length 27.2
  TOP w0.069: v3(258.54,43.05) 258.33,43.05 257.59,43.79 257.59,43.92 RPD157.1
  IN3 w0.061: v4(275.2,53.26) 274.97,53.03 274.97,51.39 272.54,48.97 272.54,48.53 271.49,47.48 271.49,46.6 270.89,45.99 269.34,45.99 268.68,45.33 262.09,45.33 261.3,44.54 260.11,44.54 259.88,44.32 259.88,43.58 259.27,42.97 258.61,42.97 v3(258.54,43.05)
  BOTTOM w0.069: RM18.1 v1(276.52,53.26) v4(275.2,53.26)
PD_R_DDM_MUX1_EN_R: length 5.2
  TOP w0.069: UPD2.42 259.8,42.29 259.35,42.74 258,42.74 257.24,43.5 RPD157.2 RPD192.1 v1(255.74,43.68)
PD_R_DRAIN1: length 3.3
  BOTTOM w0.069: v1(267.93,37.94) 265.62,37.94 v5(264.91,37.24)
  vias: v5(262.83,37.24) v5(262.83,35.94) v5(263.87,37.24) v5(263.87,35.94) v5(264.91,35.94)
PD_R_DRAIN2: length 1.3
  BOTTOM w0.127: v5(260.95,35.94) 260.95,35.05 v1(260.63,34.74)
  vias: v5(259.88,37.24) v5(260.95,37.24) v5(262.01,37.24) v5(262.01,35.94)
PD_R_GPIO2: length 17
  TOP w0.069: v3(257.93,38.98) 257.91,39.01 257.28,39.01 RPD144.2 255.89,39.37 v1(255.89,39.72) ; UPD2.18 v2(266.59,37.06)
  IN1 w0.061: v2(266.59,37.06) 265.94,37.06 v3(265.57,36.7)
  IN2 w0.051: v3(257.93,38.98) 257.93,38.88 258,38.8 258,35.61 258.34,35.27 258.97,35.27 259.27,35.58 265.16,35.58 265.57,35.98 v3(265.57,36.7)
PD_R_GPIO4: length 15
  TOP w0.069: v2(258.81,42.21) 258.51,42.51 257.72,42.51 257.24,42.99 256.15,42.99 255.38,42.23 v1(255.38,40.91) 255.38,40.88 RPD147.1 ; UPD2.31 264.2,42.56 264.4,42.77 v2(264.4,42.97)
  IN1 w0.061: v2(264.4,42.97) 263.77,42.97 263.18,43.55 260.69,43.55 259.98,42.84 259.45,42.84 v2(258.81,42.21)
PD_R_GPIO16: length 1.8
  TOP w0.069: UPD2.48 258.29,39.06 257.86,39.49 RPD147.2
PD_R_GPIO17: length 1.7
  TOP w0.069: UPD2.49 257.52,38.66 RPD144.1
PD_R_GPIO18: length 1.8
  TOP w0.069: UPD2.50 257.87,38.26 257.55,37.94 RPD205.1
PD_R_GPIO19: length 3.6
  TOP w0.069: UPD2.53 258.15,37.06 257.6,37.62 257.09,37.62 RPD205.2 256.4,37.94 v1(255.92,38.42)
PD_R_PROCHOT#: length 5.2
  TOP w0.069: RPD184.1 258.82,44.7 260.35,44.7 RPD186.2 260.74,43.75 260.6,43.61 v1(260.6,42.92) UPD2.40
PD_R_SINK_ARB_MASTER_OUT: length 1.9
  TOP w0.069: RPD171.2 257.98,36.66 UPD2.54
PD_R_SINK_ARB_SLAVE_IN: length 4.1
  TOP w0.069: RPD177.1 257.51,36.02 257.75,36.26 UPD2.55 ; RPD177.1 256.92,35.59 256.59,35.59 256.3,35.88 255.97,35.88 v1(255.92,35.93) ; RPD177.1 RPD173.2
PD_R_SLAVE_IN: length 297.5
  TOP w0.069: v2(256.77,36.66) 256.16,36.66 v1(255.64,37.18)
  IN1 w0.061: v3(259.19,28.34) 259.19,28.48 259.12,28.54 259.12,34.04 256.77,36.39 v2(256.77,36.66)
  IN2 w0.051: v3(259.19,28.34) 259.18,28.34 255.36,24.52 255.36,23.88 253.3,21.82 253.3,19.09 250.86,16.65 250.86,14.58 248.67,12.39 248.67,11.32 247.84,10.48 246.76,10.48 246.4,10.12 246.4,9.38 245.22,8.2 243.26,8.2 241.86,6.8 227.66,6.8 227.43,7.03 225.86,7.03 225.2,6.37 198.76,6.37 198.56,6.16 197.68,6.16 197.25,6.6 195.92,6.6 195.67,6.85 194.04,6.85 193.49,6.29 188.8,6.29 187.89,5.38 184.48,5.38 184.13,5.02 171.83,5.02 170.64,6.22 150.94,6.22 150.48,5.76 129.64,5.76 125.32,1.44 96.4,1.44 92.54,5.3 43.24,5.3 43.04,5.1 42.32,5.1 40.87,3.65 39.76,3.65 38.13,2.02 29.24,2.02 28.67,2.6 28.67,12.43 29.83,13.59 29.83,18.22 29,19.05 29,21.63 29.55,22.19 29.55,28.64 32.4,31.49 32.4,33.95 v3(32.04,34.31)
  IN3 w0.061: v3(32.04,34.31) 32.99,34.31 v4(33.63,34.95)
PD_R_USB_MUX1_EN: length 36.6
  TOP w0.069: v2(266.36,32.58) 266.39,32.61 RPD188.1
  IN1 w0.061: v3(268.67,37.97) 267.94,37.24 267.94,34.57 266.36,32.98 v2(266.36,32.58)
  IN3 w0.061: v3(268.67,37.97) 268.62,38.02 268.62,39.46 269,39.84 271.83,39.84 273.25,41.26 274.46,41.26 277.19,44 277.19,49.61 276.17,50.63 276.17,55.3 276.44,55.57 278.89,55.57 v4(281.2,53.26)
PD_R_USB_MUX1_EN_R: length 4.2
  TOP w0.069: UPD2.16 266.6,36.26 266.84,36.03 266.84,33.75 RPD193.1 RPD188.2
PD_TCP0_LS_EN: length 8.9
  IN3 w0.061: v4(23.13,49) 23.13,48.23 22.59,47.69 22.59,46.19 24.19,44.59 24.19,43.34 v4(24.97,42.56)
  BOTTOM w0.069: RPD126.1 v4(24.97,42.56) 24.97,42.68 v1(25.35,43.05)
PD_TCP0_LS_EN_R: length 2.2
  BOTTOM w0.069: RPD126.2 24.97,41.07 25.81,40.24 UPD1.30
PD_TCP2_LS_EN: length 15.9
  TOP w0.069: v2(263.46,45.59) 261.89,47.16 261.89,49.09 260.69,50.28 v1(260.69,51.27) 260.69,51.76 259.42,53.03 255.87,53.03 RT94.1
  IN1 w0.061: v2(265.43,44.33) 264.18,45.59 v2(263.46,45.59)
PD_TCP2_LS_EN_R: length 2.2
  TOP w0.069: UPD2.30 264.6,42.76 264.86,43.02 264.86,43.17 RPD134.2
PE: length 4.4
  BOTTOM w0.069: PR1115.1 v1(94.65,56.88)
  BOTTOM w0.203: PU1100.20 97.5,58 97.1,57.6 96.66,57.6 96.17,57.1 96.17,56.94 PR1111.2 PR1115.1
PECI_EC: length 84.5
  TOP w0.069: v2(188.51,14.6) 188.72,14.38 188.9,14.38 189.34,13.94 RE153.2
  IN1 w0.061: v2(188.51,14.6) 188.74,14.83 188.74,15.39 187.84,16.29 187.84,22.5 v3(188.11,22.78)
  IN3 w0.061: v4(194.23,33.76) 193.97,33.49 193.97,33.23 193.84,33.1 193.84,31.54 194.42,30.96 194.42,28.6 193.82,28.01 193.59,28.01 193.29,27.7 193.12,27.7 191.98,26.56 191.17,26.56 190.93,26.32 190.93,25.98 188.11,23.16 v3(188.11,22.78) ; v4(190.87,42.33) 190.87,42.46 187.48,45.85 186.74,45.85 184.72,47.87 184.31,47.87 183.47,48.71 180.94,48.71 180.76,48.89 177.64,48.89 176.59,49.93 174.28,49.93 173.88,50.34 171.72,50.34 169.94,52.12 168.19,52.12 166.8,53.5 165.52,53.5 164.6,54.42 162.07,54.42 161.64,54.85 155.88,54.85 155.6,55.13 153.77,55.13 153.51,55.38 152.04,55.38 151.4,56.02 v4(151.4,57.19)
  BOTTOM w0.069: UC1.CD5 152.99,57.35 151.55,57.35 v4(151.4,57.19) ; v4(194.23,33.76) 194.74,34.27 194.74,36.03 193.49,37.28 193.22,37.28 v1(193.04,37.46) 192.41,38.09 191.38,38.09 190.72,38.75 190.72,42.18 v4(190.87,42.33)
PECI_EC_R: length 2.9
  TOP w0.069: RE153.1 188.53,13.87 188.14,13.87 186.62,15.39 UE1.K13
PM_RSMRST_PWRGD_MIPI60: length 12.1
  TOP w0.069: v2(106.37,66.8) 106.3,66.8 105.29,67.81 104.97,67.81 103.32,69.46 101.31,69.46 100.88,69.89 JMIPI60.42
  IN1 w0.061: v3(106.26,64.86) 106.37,64.97 v2(106.37,66.8)
  IN3 w0.061: v4(106.54,64.61) 106.52,64.61 v3(106.26,64.86)
  BOTTOM w0.069: RC647.2 107.2,64.58 RC247.2 106.69,64.76 v4(106.54,64.61)
POWER_SW_IN#: length 66.5
  TOP w0.069: RE184.2 RE187.2 172.02,20.1 171.95,20.04 171.95,19.53 v3(171.94,19.52)
  IN1 w0.061: v2(179.93,20.19) v3(179.93,19.75)
  IN2 w0.051: v3(179.93,19.75) 179.26,20.42 172.64,20.42 171.94,19.72 v3(171.94,19.52)
  IN3 w0.061: v4(223.26,10.15) 223.09,9.98 216.74,9.98 216.34,10.38 196.91,10.38 196.45,9.91 193.52,9.91 193.14,10.29 192.13,10.29 189.23,13.19 188.33,13.19 186.88,14.64 186.88,15.5 186.35,16.03 186.35,18.37 185.27,19.46 185.27,19.89 184.91,20.25 184.48,20.25 183.92,19.69 182.68,19.69 182.46,19.47 180.21,19.47 v3(179.93,19.75)
  BOTTOM w0.069: v4(223.26,10.15) 223.56,10.45 223.56,11.7 224.02,12.16 224.02,14.18 224.38,14.54 224.4,14.54 224.74,14.88 224.84,14.88 QE25.3

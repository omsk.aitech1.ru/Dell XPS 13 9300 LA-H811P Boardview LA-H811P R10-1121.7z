# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_VCCST: length 222.6
  TOP w0.254: v2(197.78,9.36) 197.78,9.87 v1(198.66,10.75) 199.99,12.08 199.99,30.37 199.76,30.6 v3(199.69,30.6) ; v2(191.28,53.94) 191.28,53.92 189.68,52.32 184.27,52.32 183.35,53.23 182.77,53.23 176.84,59.16 171.58,59.16 170.25,60.49 168.38,60.49 168.11,60.22 v5(168.11,59.89)
  TOP w0.381: v5(155.72,62.04) 155.73,62.06 155.73,62.62 RC592.2
  IN1 w0.254: v3(200.52,46.27) 200.52,46.91 199.48,47.95 195.16,47.95 194.45,48.66 194.45,50.77 192.75,52.47 192.75,53.54 192.34,53.94 v2(191.28,53.94) ; v2(187.14,8.91) 187.14,9.15 v3(187.35,9.36) ; v3(197.28,9.34) 197.31,9.32 197.73,9.32 v2(197.78,9.36)
  IN2 w0.254: v3(199.69,30.6) 199.76,30.6 199.81,30.65 199.81,33.19 201.66,35.04 201.66,41.67 200.52,42.82 v3(200.52,46.27) ; v3(187.35,9.36) 188.24,8.48 194.81,8.48 195.9,9.57 197.06,9.57 v3(197.28,9.34) ; v5(155.72,62.04) 156.07,61.69 159.25,61.69 159.6,62.04 162.27,62.04 163.16,61.16 166.98,61.16 168.11,60.03 v5(168.11,59.89)
  IN2 w0.381: v5(155.72,62.04) 155.22,61.55 149.89,61.55 149.21,62.22 v3(148.96,62.22)
  IN3 w0.254: v3(148.96,62.22) 148.96,63.17 148.24,63.89 146.59,63.89 145.48,62.78 143.09,62.78 142.53,63.34 136.89,63.34 136.55,63 134.15,63 134,63.15 129.79,63.15 129.16,63.77 125.21,63.77 v4(123.92,62.48) ; v3(187.35,9.36) 186.38,9.36 184.33,11.41 183.14,11.41 181.04,13.51 v4(176.72,13.51) ; v4(107.48,60.62) 107.72,60.86 107.98,60.86 109.72,59.12 v4(111.72,59.12) 111.88,58.96 v4(117.56,58.96) ; v4(105.65,60.28) v4(105.65,59.43) v4(105.65,58.51) v4(105.65,57.57)
  BOTTOM w0.152: v4(111.72,59.12) 111.57,59.27 111.57,60.37 111.15,60.79 110.63,61.56 110.31,62.33 109.58,63.06 RH588.2
  BOTTOM w0.254: PR1128.1 105.63,58.49 v4(105.65,58.51) ; v4(105.65,59.43) 104.89,59.43 PR1129.1 ; v4(105.65,57.57) 105.55,57.47 PR1127.1 ; v4(117.56,58.96) 117.92,59.33 118.2,59.33 RH95.2 118.21,59.67 118.21,60.67 120.02,62.48 v4(123.92,62.48) 124.68,62.48 124.9,62.25 124.9,62 125.24,61.66 RH80.2 ; RE477.1 158.84,29.18 162.65,25.37 169.25,25.37 171.15,27.27 173.75,27.27 176.34,24.68 176.34,13.89 v4(176.72,13.51) ; v4(105.65,60.28) 106.23,60.86 107.25,60.86 v4(107.48,60.62)
+1.05V_VCCSTG: length 57.3
  TOP w0.254: RH96.2 120.66,57.4 120.87,57.6 123,57.6 124.4,56.2 125.39,56.2 RC146.2 125.39,57.02 125.62,57.24 125.62,58.51 125.87,58.77 125.87,61.41 125.41,61.87 v5(125.41,62.22) ; RH96.2 PR1109.1 ; RH96.2 119.62,57.09 RC659.2 v1(118.07,57.04) 116.96,57.04 116.6,57.4 112.92,57.4 109.01,61.31 109.01,65.19 v2(108.6,65.6)
  IN1 w0.254: v2(91.05,74.4) 91.05,72.89 91.71,72.23 94.35,72.23 96.94,69.64 98.18,69.64 98.74,69.09 102.29,69.09 103.03,68.35 104.89,68.35 105.21,68.03 105.7,68.03 106.24,67.49 107.1,67.49 108.6,65.98 v2(108.6,65.6)
  IN3 w0.254: v4(127.53,61.64) v4(125.81,61.64)
  BOTTOM w0.254: v4(127.53,61.64) RC150.2 128.14,61.69 128.61,61.69 RC203.2 128.71,61.69 129.19,61.69 RC181.2 ; v4(125.81,61.64) 125.81,61.93 125.52,62.22 v5(125.41,62.22)
+1.8V_3.3V_ALW_VTR3: length 11
  IN1 w0.254: v2(178.16,3.89) 180.07,5.8 180.07,8.22 v2(181.32,9.47) 181.32,10.1 179.93,11.49 v2(179.93,12.99)
+1.8V_MEM: length 65.3
  TOP w0.127: v5(168.37,9.34) 168.39,9.34 168.39,9.39 v6(169.05,10.05)
  TOP w0.254: v5(110.2,22.07) 110.85,21.42 UD4.F1 ; UD2.F1 143.21,20.99 v5(142.95,20.99) ; UD2.U1 143.07,14.27 ; 153.42,23.34 152.92,22.83 152.92,21.69 152.65,21.42 UD2.F12 ; v2(122.52,13.62) 122.33,13.82 121.74,13.82 121.28,14.27 UD4.U12 ; CD52.1 136.24,21.89 136.44,22.09 136.85,22.09 v5(136.88,22.06) ; CD319.1 109.39,22.88 CD68.1 ; CD13.1 168.22,21.42 UD1.F12 ; UD4.F12 120.59,21.42 120.84,21.68 v5(120.84,22.4) 121.15,22.4 121.41,22.13 CD51.1 CD69.1 122.52,23.29 CD303.1 ; UD4.U1 111.52,14.16 v5(110.4,14.16) ; UD1.U12 166.52,14.27
  TOP w0.305: CD52.1 136.17,21.42 UD3.F12
  TOP w0.356: CD310.1 167.96,22.4 v5(167.96,22.06) 167.96,21.99 168.24,21.71 CD13.1 ; CD313.1 141.4,20.94 CD29.1 142.44,21.5 v5(142.95,20.99) ; CD10.1 141.21,13.85 CD31.1 ; CD30.1 CD14.1 154.53,13.19 154.82,12.9 CD9.1 ; 166.52,14.27 167.42,14.27 v5(167.55,14.14) ; v5(110.2,22.07) 110.01,22.26 CD68.1 ; v5(110.4,14.16) 109.99,13.75 CD70.1 109.46,14.09 109.37,14.18 CD305.1 ; 153.42,23.34 153.49,23.4 v5(153.68,23.4) 154.9,24.63 CD32.1 CD15.1 153.63,26.87 CD11.1 ; UD3.U12 134.14,14.39 CD53.1 136.24,13.84 136.15,13.75 ; CD12.1 123.11,12.34 v2(123.11,12.99) 123.58,12.99 124.21,13.62 124.21,13.88 124.61,14.27 v2(125.23,14.27)
  TOP w0.381: CD12.1 122.12,12.05 121.85,12.32 121.85,13.14 122.33,13.62 v2(122.52,13.62) ; CD53.1 136.23,14.39 CD316.1
  TOP w0.508: v5(154.06,12.35) 154.26,12.56 CD9.1 ; 143.07,14.27 142.33,14.27 141.93,13.88 v5(141.8,13.88) CD10.1 ; 136.15,13.75 v5(135.58,13.18)
  IN1 w0.254: v2(146.04,14.92) 146.14,14.92 v4(146.51,15.3) ; v2(118.04,20.77) v3(117.71,20.77) ; v4(113.65,20.97) 113.68,21 113.82,21 v2(114.04,20.77) ; v2(163.63,14.92) 163.61,14.92 163.38,14.69 v3(163.3,14.69) ; v10(157.23,21.42) 157.14,21.33 v3(156.83,21.33) ; v4(118.43,15.14) 118.36,15.14 118.14,14.92 v2(118.04,14.92) 117.85,14.92 v4(117.59,15.18) ; v2(159.63,20.77) 159.8,20.94 v3(160.04,20.94) ; v3(127.95,15.16) 127.86,15.16 v2(127.63,14.92) ; v4(131.99,20.59) 131.81,20.59 v2(131.63,20.77) ; v4(152.45,14.27) v3(152.78,14.27) ; v3(149.68,15.15) 149.9,14.92 v2(150.05,14.92) ; v2(127.63,20.77) 127.68,20.77 v3(127.98,20.47) ; v3(159.27,15.2) 159.27,15.2 159.55,14.92 v2(159.63,14.92) ; v2(125.23,21.42) 125.41,21.42 v4(125.67,21.69) ; v3(163.93,20.49) 163.93,20.53 163.88,20.53 v2(163.63,20.77) ; v2(125.23,14.27) v4(124.78,14.27) ; v2(114.04,14.92) 114.04,14.89 114.32,14.61 v3(114.46,14.61) ; v2(157.23,14.27) v3(156.85,14.27)
  IN3 w0.254: v3(163.93,20.49) 163.93,20.53 163.99,20.53 164.04,20.48 v4(164.37,20.48) ; v4(156.85,13.88) v3(156.85,14.27) ; v3(163.3,14.69) 163.19,14.58 v4(162.94,14.58) ; v4(117.38,20.77) v3(117.71,20.77) ; v3(159.27,15.2) 159.27,14.89 v4(159.2,14.81) ; v4(160.25,21.25) 160.04,21.04 160.04,20.94 v3(160.04,20.94) ; v4(114.68,14.37) 114.68,14.37 114.68,14.38 114.66,14.39 114.66,14.42 114.65,14.42 v3(114.46,14.61) ; v3(150.06,20.8) 150.09,20.77 150.4,20.77 v4(150.46,20.72) ; v4(128.2,15.4) v3(127.95,15.16) ; v3(149.68,15.15) v4(149.35,15.15) ; v3(127.98,20.47) v4(127.98,20.8) ; v3(152.78,14.27) v4(152.45,14.27)
  IN3 w0.305: v3(156.83,21.33) v4(156.83,21)
  vias: v2(146.04,20.77) v3(122.82,12.39) v3(131.63,14.92) v3(146.04,20.77) v4(122.82,12.39) v4(131.63,14.92) v4(146.04,20.77) v5(167.76,9.34) v10(131.63,14.92)
+1.8V_MEM_R: length 0.9
  TOP w0.069: 170.55,8.2 170.55,8.76 v1(170.8,9.01)
+1.8V_PRIM: length 222.5
  TOP w0.254: v2(175.96,48.2) 175.96,47.67 175.1,46.8 174.14,46.8 RC582.1 174.2,46.35 RH613.1 RH615.1 ; v2(178.06,44.77) RH614.1 178.06,46.03 RH612.1
  TOP w0.508: 253.4,12.49 252.57,11.65 252.57,6.52 251.96,5.91 248.86,5.91 244.03,10.74 230.08,10.74 226.88,7.54 225.64,7.54 225.44,7.33 199.96,7.33 199.29,8.01 ; v5(184.13,51.63) 183.06,52.7 182.16,52.7 176.49,58.36 170.24,58.36 v5(168.72,59.89)
  TOP w1.524: 199.29,8.01 199.29,8.18
  TOP w2.032: 199.29,8.18 199.29,9.43 201.23,11.37 201.23,36.29 198.34,39.18
  IN1 w0.254: v2(180.64,7.48) 180.87,7.25 180.95,7.25 181.14,7.05 181.14,3.45 v2(180.53,2.84) ; v4(177.32,44.89) 177.74,44.89 177.86,44.77 v2(178.06,44.77)
  IN2 w0.508: v5(168.72,59.89) 168.72,60.1 166.08,62.74 158.76,62.74 158.65,62.86 148.35,62.86 147.81,63.4 143.38,63.4 143.09,63.11 ; v3(256.95,12.49) 256.95,12.69 262.07,17.8 262.07,22.29 266.31,26.54 266.31,32.54 267.44,33.67 268.54,33.67 269.74,34.87 269.74,36.49 268.87,37.36 268.06,37.36 266.33,39.08 266.33,40.68 266.21,40.81 266.21,42.54 266.97,43.3 v3(269.1,43.3)
  BOTTOM w0.254: v4(185.28,3.5) 185.43,3.5 185.89,3.95 185.89,11.45 185.51,11.83 185.51,16.99 184.9,17.6 184.9,22.29 186.4,23.79 190.78,23.79 RS383.1 ; RC610.1 v4(180.3,42.05)
  vias: v2(183.87,3.61) v2(184.13,3.61) v2(184.38,3.61) v2(184.63,3.61) v2(184.89,3.61) v2(195.47,41.04) v2(195.79,40.76) v2(196.07,40.45) v2(196.35,40.12) v2(196.64,39.84) v2(197.27,6.98) v2(197.37,6.67) v2(197.52,6.98) v2(197.63,6.67) v2(197.78,6.98) v2(197.88,6.67) v3(141.95,62.81) v3(142.46,62.81) v3(176.34,48.18) v3(176.8,48.18) v3(195.47,41.04) v3(195.79,40.76) v3(196.07,40.45) v3(196.35,40.12) v3(196.64,39.84) v4(141.95,62.81) v4(142.46,62.81) v4(176.37,48.84) v4(176.37,48.58) v4(176.62,48.84) v4(176.62,48.58) v4(176.87,48.58) v4(195.47,41.04) v4(195.79,40.76) v4(196.07,40.45) v4(196.35,40.12) v4(196.64,39.84) v6(199.15,40.25)
+1.8V_PRIMP: length 27.4
  TOP w0.127: v5(196.97,66.06) 198.9,66.06 v1(199.28,66.44)
  IN1 w0.254: v5(198.46,63.72) 198.46,64.56 v5(196.97,66.06)
  IN3 w0.254: v4(197.75,47.52) 197.87,47.52 199.09,48.73 199.38,48.73 199.49,48.85 199.51,48.85 199.99,49.33 199.99,60.88 200.34,61.23 200.34,61.56 199.43,62.48 199.12,62.48 198.46,63.14 v5(198.46,63.72) ; v4(197.98,66.13) 198.2,66.13 v4(199.63,64.7)
  BOTTOM w0.254: v5(196.97,66.06) 197.24,66.06 PC505.2 197.63,65.78 v4(197.98,66.13)
+1.8VS: length 198.4
  TOP w0.254: v2(178.48,40.63) 178.53,40.63 178.98,41.09 179.16,41.09 179.92,41.85 180.18,41.85 180.58,42.26 180.58,44.87 v2(180.76,45.05) ; v2(173.75,41.11) 173.19,41.67 171.57,41.67 170.09,40.2 168.77,40.2 164.94,36.37 162.19,36.37 161.81,36.75 159.46,36.75 RC667.1 RC668.1
  TOP w0.508: v5(191.66,41.9) 193.51,43.76 194.78,43.76 195.29,44.26 196.18,44.26 v2(200.15,48.24) ; v2(195.04,48.84) 194.5,49.37 194.5,50.69 192.85,52.34 192.85,54.02 192.42,54.45 190.84,54.45 189.42,53.03 184.52,53.03 183.73,53.81 182.92,53.81 v3(181.24,55.49) 177.03,59.71 v1(172.81,59.71) 172,59.71 170.74,60.97 168.18,60.97 167.8,60.58 167.6,60.58 ; RW1.2 256.88,15.79 256.03,14.93 254.96,14.93 252.59,12.57 248.46,12.57 v4(246.99,11.09) 245.52,12.57 233.54,12.57 233.44,12.46 v3(224.98,12.46) 224.66,12.15 C640.1 C4180.1 222.76,12.15 222.32,12.59 208.37,12.59 206.44,14.52 206.44,35.27 205.2,36.52 205.2,40.56 v2(205.21,40.57) ; 167.6,60.58 167.6,60.39 167.35,60.14 v3(167.35,59.94) ; 167.6,60.58 R6224.1
  IN1 w0.254: v2(173.75,41.11) 175.12,41.11 175.6,41.6 176.59,41.6 177.56,40.63 v2(178.48,40.63) ; v4(182.77,44.42) 182.56,44.62 182.56,44.77 181.83,45.51 181.22,45.51 v2(180.76,45.05)
  IN1 w0.508: v2(195.04,48.84) 195.16,48.71 199.68,48.71 v2(200.15,48.24) 201.94,46.45 201.94,44.59 205.21,41.33 v2(205.21,40.57)
  IN2 w0.381: v4(182.77,44.42) 182.77,45.61 183.1,45.94 183.1,49.95 181.94,51.11 181.94,54.79 v3(181.24,55.49) ; v4(160.8,61.51) 160.8,61.03 161.09,60.74 166.81,60.74 167.35,60.2 v3(167.35,59.94)
  BOTTOM w0.254: RC742.2 RC741.2 182.74,44.39 v4(182.77,44.42)
  BOTTOM w0.381: R6157.2 v4(160.8,61.51) ; v4(246.99,11.09) RW55.1
  vias: v4(225.26,11.96) v4(225.54,11.96)
+1.8VS_AUDIO: length 375.2
  TOP w0.203: UA1.20 264.4,62.04
  TOP w0.254: 264.4,62.04 264.57,62.21 264.8,62.21 264.89,62.3 CA24.1 265.09,62.12 265.93,61.28 CA29.1 267.27,61.28 268.44,60.11 268.44,58.49 267.91,57.96 CA86.1 267.63,57.83 267.3,57.5 RA41.1 266.54,57.5 266.31,57.73 266.31,58.13 v3(266.16,58.29) ; RA80.1 RA72.1 RA71.1 275.65,35.07 v5(275.02,35.7)
  TOP w0.508: R211.2 274.09,42.16 C276.1 ; v5(29.78,4.72) 29.15,5.35 29.15,8.13 28.6,8.68 v6(28.6,11.24) 27.37,12.48 27.37,17.94 27.87,18.43 v2(27.87,19.5) ; v5(275.02,35.7) 275.02,36.11 275.88,36.97 275.88,41.93 275.65,42.16 C276.1 ; v2(197.22,3.18) 197.19,3.21 197.19,3.52 199.08,5.41 232.17,5.41 233.26,4.31 234.43,4.31 236.59,2.15 251.63,2.15 v5(252.82,3.35) ; C276.1 275.1,42.92 275.5,43.32 276.87,43.32 277.31,43.76 277.31,44.49 276.8,45 275.86,45 274.21,46.65 274.21,56.08 273.57,56.71 269.03,56.71 CA86.1 ; CA105.1 22.14,21.15 v2(22.29,21.3) ; v2(186.32,2.19) 186.32,3.27 v4(186.15,3.45)
  IN1 w0.254: v2(257.24,54.78) 257.52,54.5 v3(257.52,54.42) ; v2(271.62,28.14) 271.62,28.03 v3(271.39,27.81)
  IN1 w0.508: v2(186.32,2.19) 196.24,2.19 v2(197.22,3.18) ; v2(22.29,21.3) 24.09,19.5 v2(27.87,19.5)
  IN2 w0.254: v3(257.52,54.42) 257.52,55.19 259.09,56.76 261.2,56.76 262.73,58.29 v3(266.16,58.29)
  IN2 w0.508: v5(110.3,4.77) 110.2,4.67 110.2,3.93 108.9,2.63 95.96,2.63 92.76,5.83 62.3,5.83 61.84,6.3 43.48,6.3 42.82,5.63 42.1,5.63 40.65,4.18 39.54,4.18 37.91,2.56 30.39,2.56 29.99,2.96 29.99,4.51 v5(29.78,4.72) ; v5(252.82,3.35) 258.69,9.21 261.99,9.21 268.01,15.23 268.01,24.05 271.36,27.4 271.36,27.78 v3(271.39,27.81) 271.64,28.06 271.64,32.89 274.45,35.7 v5(275.02,35.7)
  IN3 w0.508: v4(159.12,2.58) 160.24,1.47 173.62,1.47 v4(174.46,2.3)
  BOTTOM w0.203: Q352.2 Q352.5 192.02,8.32 191.89,8.45 191.4,8.45 190.23,7.28 190.23,5.26 188.42,3.45 v4(186.15,3.45)
  BOTTOM w0.508: v4(186.15,3.45) 186.15,2.96 185.48,2.3 v4(174.46,2.3) ; v5(110.3,4.77) 110.3,5.89 110.66,6.24 156.77,6.24 158.79,4.22 158.79,2.91 v4(159.12,2.58)
+1.8VS_AUDIO_R: length 0.9
  TOP w0.069: 272.91,44.16 v1(272.91,45.03)
+1.8VS_R: length 2.1
  BOTTOM w0.069: R441.1 192.95,41.8 v1(192.65,42.11)
+3.3V_ALW_UE1: length 28.2
  TOP w0.254: UE1.B7 181.9,22.16 v2(181.9,22.19) ; UE1.K2 177.13,15.79 177.13,16.59 UE1.H1
  TOP w0.508: CE44.1 182.39,25.7 CE43.1 183.19,25.71 v2(183.2,25.7)
  IN1 w0.508: v2(183.13,12.39) 183.13,12.57 183.35,12.79 183.35,13.57 v2(183.13,13.79) v3(183.13,14.55) 183.13,15.96 182.33,16.76 v2(182.33,17.79) 182.33,19.23 182.08,19.47 182.08,20.49 181.73,20.85 181.73,22.01 v2(181.9,22.19) 182.3,22.59 182.3,23.58 183.2,24.48 v2(183.2,25.7)
  IN2 w0.508: v3(183.13,14.55) 182.94,14.55 182.76,14.36 179.55,14.36 177.71,16.2 175.15,16.2 v3(174.58,16.76)
  vias: v1(172.4,17.87)
+3.3V_BAT_LDO: length 267.2
  TOP w0.254: v4(210.07,2.84) 209.39,2.84 208.93,3.29 200.17,3.29 198.14,1.26 165.88,1.26 v1(165.75,1.39) 163.31,1.39 162.7,2 162.7,4.18 v2(162.83,4.31)
  IN1 w0.254: v2(162.83,4.31) 162.28,4.85 159.55,4.85 158.27,6.13 130.13,6.13 128.48,4.49 119.87,4.49 118.96,3.58 114.22,3.58 113.4,2.76 101.66,2.76 v3(100.93,3.5) ; v3(41.28,9.2) 41.28,9.53 41.77,10.03 41.77,10.61 38.75,13.63 38.11,13.63 34.21,17.53 34.05,17.53 31.93,19.65 v3(30.7,19.65) 29.6,19.65 28.97,19.02 23.61,19.02 21.03,21.6 21.03,27.55 19.34,29.25 19.34,32.59 18.84,33.09 17.36,33.09 17.21,33.24 14.01,33.24 13.73,33.52 13.73,34.89 10.13,38.49 9.86,38.49 9.02,39.34 v4(7.23,39.34)
  IN3 w0.254: v4(35.19,18.56) 32.35,18.56 31.26,19.65 v3(30.7,19.65) ; v3(41.28,9.2) 41.28,8.95 42.08,8.15 58.84,8.15 59.4,7.59 72.86,7.59 v4(72.96,7.69) 73.06,7.59 73.96,7.59 74.32,7.94 81.32,7.94 81.78,7.49 93.79,7.49 97.78,3.5 v3(100.93,3.5)
  BOTTOM w0.254: RTCD2.2 8.29,38.4 7.35,39.34 v4(7.23,39.34) ; v4(72.96,7.69) 72.96,9.94 PD604.2 ; v4(35.19,18.56) 35.19,18.74 37.06,20.6 PD105.3 PD105.2 36.4,21.37 PR197.2 ; v4(210.07,2.84) 210.83,2.84 211.1,3.1 212.34,3.1 213.07,3.82 213.07,7.03 212.92,7.17 212.92,11.06 212.2,11.79 210.75,11.79 209.72,12.82 209.72,15.05 210.67,16.01 210.67,16.38 QE23.2 210.75,16.46 211.57,16.46 211.57,16.45 RE520.1
+3.3V_BAT_LDO_R: length 3.3
  TOP w0.069: v1(37.83,20.97) v3(38.11,21.25)
  IN3 w0.061: v4(38.77,20.48) 38.77,20.6 v3(38.11,21.25)
  BOTTOM w0.254: PR197.1 38.53,20.72 v4(38.77,20.48) JBATT1.6
+3.3V_EC_PLL: length 4.4
  TOP w0.254: RE113.2 173.08,19.53 CE47.1 174.3,19.53 CE48.1 175.05,19.25 175.71,18.59 UE1.F1
+3.3V_TBT_L: length 44
  TOP w0.127: v6(32.87,55.42) 32.14,54.7 v2(32.07,54.7)
  TOP w0.381: v4(21.74,55.59) 21.74,56.23 21.95,56.43 25.26,56.43 25.54,56.71 RT226.2 ; v2(32.07,54.7) 31.81,54.95 RT181.2 31.32,54.32 RT218.2
  TOP w0.508: RT180.2 RT181.2
  IN1 w0.381: v3(34.18,45.89) 34.1,45.89 31.87,48.13 v3(31.87,48.25) 33.54,49.93 33.54,52.95 32.07,54.42 v2(32.07,54.7) 32.07,54.7 31.59,55.19 31.59,56.58 30.29,57.88 25.59,57.88 24.83,57.12 22.16,57.12 21.74,56.7 v4(21.74,55.59)
  IN3 w0.381: v4(27.19,46.05) 27.59,46.05 27.64,46 29.61,46 v3(31.87,48.25) ; v4(35.24,44.98) 35.09,44.98 v3(34.18,45.89)
  BOTTOM w0.381: v4(35.24,44.98) 36.21,44.98 36.44,45.2 RT172.2 RT13.2 RT18.2 RT16.2
+3.3V_TBT_L_ANA: length 2.2
  TOP w0.127: v2(25.97,53.41) 26.05,53.33 v1(26.05,52.19)
  IN1 w0.254: v2(25.97,53.41) 25.97,53.23 v3(26.1,53.1)
  IN3 w0.254: v4(26.02,53.63) 26.02,53.17 v3(26.1,53.1)
+3.3V_TBT_L_DB: length 7.7
  IN1 w0.061: v3(26.48,54) 26.23,53.75 25.7,53.75 25.32,53.37 24.74,53.37 23.1,55.01 v4(22.16,55.01)
  IN3 w0.061: v3(26.48,54) 26.48,54.74 v4(26.79,55.05)
  BOTTOM w0.069: v4(22.16,55.01) 21.97,55.2 21.55,55.2 RT203.1
+3.3V_TBT_L_FLASH: length 38.3
  TOP w0.254: v5(36.39,65.22) 36.39,63.44 v1(36.02,63.07) 34.76,61.82 34.76,56.79 34.45,56.48 JDB3.1
  BOTTOM w0.254: RT22.2 RT21.2 RT20.2 28.32,68.61 27.78,69.16 18,69.16 17.67,68.83 17.67,68.5 17.24,68.06 RT23.2 17.91,67.54 18.12,67.76 UTS1.8 ; RT22.2 v5(36.39,65.22) ; RT22.2 28.32,63.61 DT1.1
+3.3V_TBT_L_FLASH_R: length 29.5
  TOP w0.254: RT176.1 29.35,49.38 v5(31.85,49.38) 32.47,50 v1(33.21,50) v2(34.01,50)
  IN1 w0.254: v2(34.01,50) 34.3,50.3 34.3,51.61 35.9,53.21 35.9,60.98 v3(35.93,61)
  IN3 w0.254: 31.88,61 31.56,60.68 v4(31.56,60.45) ; 31.88,61 v3(35.93,61) ; 31.88,61 31.88,63.36 v4(31.42,63.82)
  BOTTOM w0.254: RT168.1 29.8,47.33 v5(31.85,49.38) ; v4(31.42,63.82) 30.83,63.82 DT1.2
+3.3V_TBT_L_LC: length 9.2
  TOP w0.127: RT64.2 27.86,53.18 v1(27.76,53.27)
  TOP w0.254: RT176.2 28.97,50.81 RT65.2 RT63.2 v2(28.83,52.14) 28.65,52.31 RT64.2
  IN1 w0.254: v2(28.79,55.02) 28.43,55.02 v3(28.42,55) ; v3(29.19,52.08) 29.13,52.14 v2(28.83,52.14)
  IN3 w0.254: v4(28.74,55.05) 28.47,55.05 v3(28.42,55) 28.11,54.69 28.11,53.08 27.96,52.93 27.96,52.28 28.16,52.08 v3(29.19,52.08)
+3.3V_TBT_L_SVR: length 6.8
  TOP w0.305: v2(29.78,54.7) 30.04,54.95 RT181.1
  IN1 w0.305: v5(25.09,54.38) 25.39,54.68 26.4,54.68 26.49,54.76 27.81,54.76 28.09,54.49 28.09,53.95 28.4,53.65 28.83,53.65 29.78,54.6 v2(29.78,54.7)
+3.3V_TBT_L_SX: length 4.2
  TOP w0.127: 29.82,56.06 29.82,57.16 v1(29.5,57.47)
  TOP w0.254: v2(28.79,55.65) 28.79,55.76 29.09,56.06 29.82,56.06 30.1,55.78 RT180.1
  IN1 w0.254: v2(28.79,55.65) v3(28.51,55.94)
  IN3 w0.254: v3(28.51,55.94) 28.74,55.7 v4(28.74,55.7)
+3.3V_TBT_R: length 30.9
  IN1 w0.381: v4(261.89,56.51) 261.89,56.35 261.46,55.92 261.46,52.44 261.86,52.04 261.86,50 v5(260.95,49.09)
  IN2 w0.381: v4(273.09,54.83) 272.76,54.5 v4(272.76,50.23) 272.12,49.6 271.11,49.6 269.96,48.46 266.28,48.46 265.06,49.67 261.53,49.67 v5(260.95,49.09)
  BOTTOM w0.381: RT219.2 273.04,46.88 273.24,47.08 273.24,47.74 272.99,48 RT37.2 RT38.2 273.09,48.56 273.25,48.72 273.25,50.02 273.04,50.23 v4(272.76,50.23)
  vias: v5(260.31,49.09) v5(260.57,48.58) v6(260.8,47.64)
+3.3V_TBT_R_ANA: length 0.7
  IN1 w0.254: v3(265.56,50.54) 265.61,50.48 v2(265.94,50.48)
  IN3 w0.254: v4(265.9,50.54) v3(265.56,50.54)
+3.3V_TBT_R_B: length 0.7
  TOP w0.069: 257.9,47.9 v1(257.9,47.21)
+3.3V_TBT_R_DB: length 8.9
  IN3 w0.254: v4(259.32,52.12) 259.73,51.71 259.91,51.71 260.8,50.82 261.89,50.82 262.75,51.68 266.36,51.68 266.63,51.96 v4(266.67,51.96)
  BOTTOM w0.356: RT202.1 v4(259.32,52.12)
+3.3V_TBT_R_FLASH: length 25.4
  TOP w0.254: JDB4.1 278.98,40.47 279.26,40.75 v5(279.26,41.72) v5(281.7,41.72) 281.7,42.13 280.3,43.53 280.3,48.76 283,51.45 v5(283,51.5)
  BOTTOM w0.127: v1(282.11,40.96) 281.7,41.37 v5(281.7,41.72)
  BOTTOM w0.254: v5(281.7,41.72) 281.73,41.75 RT42.2 ; RT43.2 279.41,41.88 v5(279.26,41.72) 278.19,41.72 277.89,42.03 RT44.2 ; 281.52,52.26 281.52,51.38 281.14,51 UTS2.8 ; 281.52,52.26 281.57,52.21 281.98,52.21 DT2.1 283,52.27 v5(283,51.5) ; 281.52,52.26 281.4,52.39 RT45.2
+3.3V_TBT_R_FLASH_R: length 79.2
  TOP w0.254: RT187.1 272.39,46.45 272.68,46.16 v3(272.68,45.33)
  IN2 w0.254: v4(260.57,47.44) 262.67,45.34 v3(272.68,45.34) 272.68,45.4 272.73,45.46 273.17,45.46 273.65,45.94 273.65,47.95 v3(274.47,48.77)
  IN3 w0.254: v3(272.68,45.33) 272.68,45.33 272.65,45.36 272.65,45.39 v4(272.38,45.66) ; v4(275.2,49.37) 275.07,49.37 v3(274.47,48.77)
  BOTTOM w0.254: 276.67,49.4 275.22,49.4 v4(275.2,49.37) ; 276.67,49.4 276.67,45.49 275.91,44.72 v1(275.91,43.88) 275.91,41.68 269.75,35.52 269.32,35.52 268.07,34.27 261.81,34.27 261.26,33.72 261.26,31.09 260.77,30.6 260.77,29.05 258.66,26.94 250.63,26.94 249.18,25.48 RT170.1 ; 276.67,49.4 281.8,49.4 283.55,51.15 283.55,52.72 282.51,53.76 DT2.2
+3.3V_TBT_R_LC: length 18.4
  TOP w0.254: RT72.2 RT73.2 269.89,48.13 v1(270.52,48.76) 270.72,48.96 v2(270.72,49.85)
  IN1 w0.254: v2(268.5,51.84) 268.67,51.84 268.79,51.72 268.86,51.72 v3(268.92,51.65) v2(270.72,49.85) 271.57,49.85 273.01,48.4 v3(273.01,46.04)
  IN2 w0.254: v3(273.01,46.04) 272.99,46.02 v4(268.39,46.02)
  IN3 w0.254: v3(268.92,51.65) 268.92,51.7 268.67,51.96 v4(268.62,51.96) ; v3(273.01,46.04) 273.01,45.69 272.99,45.66 v4(272.96,45.66)
  BOTTOM w0.254: v4(272.96,45.66) RT98.2 ; RT71.2 268.62,45.79 v4(268.39,46.02)
+3.3V_TBT_R_SVR:
  vias: v1(264.25,51.99)
+3.3V_TBT_R_SX: length 11.8
  TOP w0.254: v4(268.96,52.94) 268.74,52.94 268.5,52.71 CT70.1
  IN2 w0.254: v4(268.96,52.94) 267.67,51.66 266.23,51.66 266.1,51.53 263.21,51.53 262.62,50.94 259.98,50.94 v3(259.84,51.08)
  IN3 w0.254: v4(259.84,50.65) v3(259.84,51.08)
  BOTTOM w0.203: v4(268.96,52.94) URT2.E6
+3.3V_VPS_TPM: length 1.3
  BOTTOM w0.254: C97.1 186.81,37.95 U712.22
  vias: v1(183.19,36.95) v2(183.83,36.75) v3(183.83,36.75) v4(183.83,36.75)
+3.3VA_TBT_L: length 15
  TOP w0.254: v2(26.8,56.38) CT302.1 26.05,56.38 25.67,56 24.43,56 24.19,55.76 24.19,53 24.73,52.47 24.73,51.73 24.3,51.3 24.3,49.9 23.75,49.36 v1(23.75,48.96) v3(23.75,47.88)
  IN1 w0.254: v3(27.06,56.61) 27.03,56.61 v2(26.8,56.38)
  IN3 w0.254: v4(25.83,47.88) v3(23.75,47.88) ; v3(27.06,56.61) 27.05,56.61 v4(26.79,56.35)
  BOTTOM w0.254: v4(25.83,47.88) 25.83,47.07 25.82,47.06 RT79.2
+3.3VA_TBT_R: length 10.8
  TOP w0.127: v1(264.72,53.6) 264.99,53.33 v2(265.94,53.33)
  TOP w0.356: v2(265.94,53.33) CT305.1
  IN1 w0.254: v2(265.94,53.33) 266.1,53.33 266.39,53.05 v3(266.39,52.97)
  IN2 w0.254: v3(266.39,52.97) 266.25,53.11 264.46,53.11 263.87,52.52 263.51,52.52 262.29,51.3 261.23,51.3 261.18,51.35 v3(261.18,51.48)
  IN3 w0.254: v3(261.18,51.48) 261.05,51.61 260.7,51.61 260.68,51.59 v4(260.68,51.46) ; v4(266.67,53.26) v3(266.39,52.97)
  BOTTOM w0.254: RT88.2 260.61,51.39 v4(260.68,51.46)
+3V_1.8V_HDA: length 12.7
  IN1 w0.381: v3(164.13,46.3) 164.13,45.91 164.81,45.23 165.39,45.23 166.05,45.89 166.94,45.89 167.12,46.07 168.41,46.07 168.93,45.54 170.97,45.54 171.74,44.77 v5(171.74,44.72)
  IN3 w0.381: v4(164.13,46.82) v3(164.13,46.3)
  BOTTOM w0.381: LC2.2 174.18,44.7 173.69,45.19 CC168.2 CC23.1 172.42,45.19 172.41,45.18 172.1,45.18 171.74,44.82 v5(171.74,44.72)
+3V_ALS: length 1.8
  TOP w0.069: v1(159.48,64.1) 159.86,64.48 v2(160.67,64.48)
  IN1 w0.254: v2(160.67,64.48) 160.45,64.48 v4(160.3,64.33)
+3V_NB_LID: length 57
  TOP w0.254: PR600.1 107.1,2.36 PR601.1 106.62,3.14 v3(105.75,4.01) 105.75,4.51 v1(106.65,5.41) 106.95,5.71 111.37,5.71 PR606.1 115.69,5.15 116.12,4.72 PD603.1 115.49,3.41 PR602.1 114.22,3.72 113.91,4.03 112.87,4.03 112.66,3.83 112.66,3.4 112.6,3.34 PU600.8
  IN3 w0.254: v3(105.75,4.01) 104.48,4.01 104,4.49 100.42,4.49 99.86,3.93 97.85,3.93 93.74,8.04 81.98,8.04 81.7,8.32 74.11,8.32 73.72,7.94 73.34,7.94 73.19,8.09 72.25,8.09 v4(72.12,7.97)
  BOTTOM w0.254: PD604.1 v4(72.12,7.97)
+3V_PRIM: length 566.3
  TOP w0.203: R6174.1 176.78,43.89 176.98,44.09 177.8,44.09 v5(178.06,43.83)
  TOP w0.254: 144.49,64.25 145.12,64.89 145.12,66.44 145.53,66.85 145.96,66.85 v2(146.01,66.9) ; 144.49,64.25 144.82,63.92 144.82,63.06 145.07,62.81 v2(145.38,62.81) ; 144.49,64.25 143.55,64.25 143.32,64.03 143.32,63.54 CC633.1 143.35,63.31 UC11.5 ; CC621.1 179.4,47.19 179.4,46.74 v3(179.36,46.7) ; CC621.1 179.01,47.59 179.01,48.33 179.24,48.56 179.57,48.56 179.91,48.9 UC8.5 ; CC621.1 179.46,47.24 179.46,47.9 UC8.1 ; 272.99,46.86 273.17,47.03 273.17,55.32 v4(273.09,55.4) ; 272.99,46.86 RT187.2 ; 272.99,46.86 272.99,46.73 275.55,44.16 v3(276.75,44.16) ; v3(89.47,61.18) 89.45,61.15 89.45,60.47 89.6,60.32 91.96,60.32 92.19,60.09 92.29,60.09 92.42,59.96 v4(92.75,59.96) ; JAPS1.1 194.27,21.01 193.49,20.22 193.49,17.65 192.99,17.14 192.99,12.98 v2(193.02,12.95) ; 167.27,51.65 167.3,51.63 R6172.1 ; v2(107.25,72.74) 108.03,72.74 109.4,71.37 R138.1 ; RH618.2 166.24,39.98 165.7,39.44 164.22,39.44 163.95,39.71 RC747.1 ; UC10.5 CC632.1
  TOP w0.305: JAPS1.7 194.9,24.35 195.06,24.5 195.06,24.56 195.36,24.86 195.76,24.86 196.05,24.57 196.05,24.07 v5(195.54,23.56) 195.54,22.19 194.7,21.35 JAPS1.1
  TOP w0.381: 154.65,38.17 v6(154.15,37.67) 153.76,37.28 153.02,37.28 151.85,36.11 151.85,33.08 152.46,32.47 155.11,32.47 RH647.2 RC682.1
  TOP w0.508: v2(146.01,66.9) 146.44,66.9 146.78,66.57 CC632.1 ; v2(186.53,27.5) 186.37,27.65 RC745.1 186.37,28.34 185.54,29.18 D20.2 ; 176.11,49.6 177.56,49.6 179.47,51.5 182.54,51.5 183.55,50.49 183.75,50.49 arc(184.25,50.39) v5(184.67,50.11) ; 165.24,47.82 165.24,49.32 165.93,50 165.93,50.3 167.27,51.65 167.27,52.57 166.36,53.49 166.36,56.46 165.34,57.47 165.34,60.65 164.46,61.53 164.46,63.04 164.89,63.47 164.89,64.99 164.56,65.32 164.56,65.57 164.53,65.6 164.53,65.6 164.2,65.93 163.84,65.93 163.62,66.16 162.9,66.16 162.7,65.96 F1.1
  IN1 w0.254: v2(193.02,12.95) 194.05,12.95 194.44,12.56 194.44,11.64 195.24,10.84 195.24,9.19 ; 195.24,9.19 195.64,9.19 196.41,8.43 198.42,8.43 202.16,4.68 209.58,4.68 209.75,4.51 213.04,4.51 214.24,3.32 230.54,3.32 231.66,2.21 233.9,2.21 234.56,1.55 252.8,1.55 v3(252.9,1.64) ; 195.24,9.19 193.82,7.76 v4(193.82,7.56) ; v4(103.8,73.47) 104.13,73.47 104.76,72.84 107.15,72.84 v2(107.25,72.74) 108.03,72.74 109.02,71.75 114.11,71.75 115.03,70.83 115.03,69 116.19,67.84 145.07,67.84 v2(146.01,66.9) ; v2(159.47,38.17) 158.99,37.7 158.99,33.93 159.57,33.35 161.44,33.35 v3(161.97,33.88) ; v3(77.56,21.38) 73.25,17.07 68.23,17.07 67.23,16.07 55.08,16.07 v3(53.68,17.47)
  IN1 w0.381: v2(162.68,65.6) 160.13,65.6 159.59,65.07 157.5,65.07 157.14,65.42 154.55,65.42 153.73,64.61 150.33,64.61 148,62.28 148,61.75 147.89,61.64 146.55,61.64 v2(145.38,62.81) ; v3(186.68,26.03) 186.63,26.08 186.63,27.4 v2(186.53,27.5)
  IN1 w0.508: 163.41,47.19 162.88,47.72 161.51,47.72 160.52,46.73 160.52,45.13 158.33,42.94 158.33,41.37 v2(159.47,40.23)
  IN2 w0.254: v3(39.3,31.98) 37.56,33.72 37.56,48.51 37.05,49.01 v4(37.05,49.02) ; v3(252.9,1.64) 254.19,2.94 258.59,2.94 259.07,3.42 259.07,7.69 259.5,8.12 262.47,8.12 270.04,15.69 270.04,21 272.99,23.94 272.99,28.15 274.05,29.22 274.05,32.35 277.49,35.79 277.49,43.42 v3(276.75,44.16)
  IN2 w0.508: v4(174.33,41.58) 174.31,41.55 v5(174.31,36.8) ; v3(186.68,26.03) 186.93,25.77 188,25.77 190.15,23.62 190.3,23.62 191.65,22.27 191.95,22.27 191.97,22.26 194.24,22.26 v5(195.54,23.56)
  IN3 w0.254: v4(31.56,59.87) 34.12,59.87 34.52,60.27 36.37,60.27 37.05,59.59 v4(37.05,49.02) ; v4(164.78,45.99) v3(165.01,45.76) ; v3(39.3,31.98) 37.66,30.35 37.66,26.05 39.26,24.45 40.91,24.45 48.15,17.21 53.43,17.21 v3(53.68,17.47) ; v3(77.56,21.38) 78.3,21.38 87.86,30.94 87.86,49.71 92.04,53.89 92.04,56.53 89.41,59.16 89.41,61.12 v3(89.47,61.18) 89.65,61.35 89.65,68.57 94.02,72.93 99.98,72.93 101,73.96 101.92,73.96 102.4,73.47 v4(103.8,73.47) ; v4(164.13,47.65) v3(164.36,47.42) ; v3(161.97,33.88) 161.99,33.88 163.21,32.66 164.41,32.66 v4(164.46,32.61) ; v4(182.49,39.34) 182.64,39.49 183.86,39.49 184.95,38.39 188.26,38.39 v4(188.74,37.91) ; v4(164.78,46.82) v3(165.01,46.59) ; v4(189.45,37.47) 190.44,36.48 190.44,32.39 188.46,30.41 188.46,29.53 187.19,28.27 186.52,28.27 186.03,28.76 184.99,28.76 184.47,29.28 184.34,29.28 184.13,29.49 182.95,29.49 181.63,28.16
  IN3 w0.508: 180.25,27.55 180.73,27.55 181.35,28.16 181.63,28.16
  BOTTOM w0.152: v4(193.82,7.56) 193.94,7.43 194.36,7.43 195.17,7.1 195.9,6.96 197.82,6.96 199.45,8.58 199.61,8.58 200.02,8.99 200.02,10.92 200.17,11.07 200.33,11.07 200.67,11.41 R617.1
  BOTTOM w0.254: RC616.1 176.92,52.39 176.9,52.37 ; v4(188.74,37.91) 189.13,37.91 R656.1 189.16,37.84 189.16,37.69 189.37,37.47 v4(189.45,37.47) ; R617.1 R616.1 ; RT109.2 v4(31.56,59.87) ; 176.9,52.37 176.9,52.93 176.54,53.28 174.84,53.28 174.58,53.02 174.57,53.02 174.35,52.79 RH629.2 ; 176.9,52.37 176.72,52.19 RH660.2 176.24,51.88 176.11,51.76 175.34,51.76 174.9,52.21 174.09,52.21 RH604.2 ; RT8.2 v4(37.05,49.02)
  BOTTOM w0.381: R210.1 R311.1 v4(103.8,73.47)
  BOTTOM w0.508: v5(184.67,50.11) 184.6,50.18 182.11,50.18 181.12,49.19 179.57,49.19 ; v4(179.77,27.55) 179.77,27.75 179.99,27.97 179.99,29.34 179.41,29.91 179.41,30.75 178.47,31.69 177.84,31.69 177.35,32.18 177,32.18 174.59,34.59 174.59,36.52 v5(174.31,36.8) ; 178.78,49.09 178.78,51 RC617.1 178.27,51.12 177.76,51.63 RC616.1 ; RC673.1 175.46,42.47 175.46,42.14 175.2,41.88 174.54,41.88 174.33,41.67 v4(174.33,41.58)
  vias: v2(164.3,46.93) v2(164.68,46.93) v2(165.06,46.17) v4(179.01,47.06) v4(179.01,46.8)
+3V_PRIM_R: length 0.9
  TOP w0.069: v1(186.2,47.46) 185.94,47.46 185.51,47.9
+3V_SPI: length 24.9
  TOP w0.381: RC745.2 187.29,28.57 187.08,28.77 D20.1
  TOP w0.508: v3(190.59,31.74) 190.59,31.16 v1(189.96,30.53) 188.44,30.53 D20.1
  IN1 w0.508: v4(181.85,32.89) 181.88,32.89 181.9,32.91 181.9,34.21 182.48,34.79 186.22,34.79 187.55,33.46 188.19,33.46 188.71,32.94 189.39,32.94 v3(190.59,31.74)
  IN2 w0.508: v4(194.28,31.77) 194.27,31.76 190.61,31.76 v3(190.59,31.74)
  BOTTOM w0.254: JSPI1.9 194.11,31.53 194.28,31.69 v4(194.28,31.77) 194.3,31.79 194.3,31.83 194.09,32.03 JSPI1.8
  BOTTOM w0.381: UH8.8 183.43,33.57 182.31,33.57 181.85,33.11 v4(181.85,32.89)
+3VALW: length 411.7
  TOP w0.203: UM1.13 v2(30.91,63.41)
  TOP w0.254: RE446.2 183.55,30.83 Q30.5 Q30.2 183.55,29.23 183.77,29.01 183.81,29.01 v3(183.85,29.06) 183.85,29.03 183.72,28.9 RE445.2 ; v3(173.35,21.12) RE247.1 ; v2(163.93,5.57) 163.81,5.69 163.81,6.05 R532.1 ; 185.19,44.03 185.65,44.03 185.89,44.26 185.89,46.55 186.68,47.34 186.68,49.27 186.96,49.55 186.96,51.33 186.55,51.73 185.1,51.73 184.52,51.15 183.61,51.15 182.61,52.14 179.16,52.14 v6(177.24,50.22) 176.89,50.22 176.11,51 176.11,52.23 RC147.2 ; v3(177.66,28.11) 178.02,27.75 RE527.1 RE526.1 176.77,27.41 RE459.2 176.12,27.44 RE458.2 ; UT2.4 255.89,50.51 255.74,50.36 v3(255.51,50.36) ; CS94.1 176.2,7.23 175.86,7.57 175.86,9.28 RE112.2 RE111.2 ; RE521.1 194.83,4.03 195.87,5.07 v3(195.87,8.27) ; RE484.2 v2(181.88,3.88)
  TOP w0.305: 192.37,21.79 192.93,22.35 JAPS1.3
  TOP w0.508: v2(20.56,57.27) 21.02,57.27 21.03,57.28 22.71,57.28 23,56.99 RT228.2 ; PD603.2 v3(115.2,2.33) ; PR103.1 105.12,10.53 104.66,10.99 v5(103.21,10.99) ; 200.92,58.66 PR509.1 ; 200.92,58.66 200.92,57.16 200.37,56.61 v2(200.37,54.42) ; 200.92,58.66 200.22,59.37 200.22,63.11 197.88,65.45 195.39,65.45 192.57,68.27 192.57,71.72 192.18,72.12 v5(191.63,72.12) ; RD41.1 203.04,45.99 202.27,45.23 202.27,43.6 201.51,42.84 ; 198.67,42.92 198.67,45.74 v2(201.32,48.39) ; v3(261.34,29.43) 261.34,29.93 RPD93.1
  TOP w1.016: 7.08,42.87 10.81,39.13 13.88,39.13 15.33,40.58 17.79,40.58 19.88,42.66 20.41,42.66
  IN1 w0.254: v2(163.93,5.57) 164.77,5.57 164.88,5.68 168.92,5.68 170.34,7.1 171.42,7.1 172.06,7.74 174.14,7.74 v5(175.2,6.68) ; v2(187.13,10.16) 187.13,10 v3(186.94,9.81) ; v3(181.74,6.72) 181.52,6.51 181.52,3.9 181.55,3.88 v2(181.88,3.88)
  IN1 w0.508: v2(200.37,54.42) 200.37,50.11 201.32,49.15 v2(201.32,48.39) ; v3(97.47,67.99) 96.41,67.99 95.75,68.65 89.52,68.65 89.19,68.32 v5(89.19,66.24) ; 30.95,26.23 v3(31.03,26.23)
  IN1 w1.016: 30.95,26.23 29.19,27.99 v4(28.41,27.99) 26.65,27.99 24.52,30.12 24.52,30.6 23.1,32.02 23.1,34.51 20.28,37.33 20.28,39.26 20.82,39.79 20.82,41.88
  IN2 w0.254: v5(258.41,51.63) 257.77,51.63 256.5,50.36 v3(255.51,50.36)
  IN2 w0.508: v3(122.1,5) 121.88,4.78 v3(121.88,2.51) 121.71,2.33 v3(115.2,2.33) 112.16,5.38 109.49,5.38 108.68,4.56 v3(108.68,4.51) ; v5(103.21,10.99) 103.42,11.19 103.42,12.31 102.2,13.53 v4(102.2,14.17) ; v3(257.34,24.91) 257.34,25.28 261.34,29.28 v3(261.34,29.43) ; v3(270.73,17.95) 270.73,21 273.67,23.95 273.67,25.7 274.54,26.56 274.54,31.64 278.25,35.35 278.25,42.99 278.78,43.53 278.78,53.33 v4(279.3,53.84)
  IN2 w1.016: 95.8,23.03 90.72,28.11 89.07,28.11 74.67,13.71 68.54,13.71 68.26,13.43 43.3,13.43 39.28,17.44 37.58,17.44 36.01,19.02 33.69,19.02 30.87,21.84 30.87,24.5
  IN3 w0.254: v4(98.82,55.85) 99.1,56.13 v4(100.36,56.13) 100.45,56.04 v3(100.45,55.34)
  IN3 w0.508: v4(95.59,9.64) 96.43,8.81 96.43,7.51 97.65,6.29 102.2,6.29 ; v3(263.26,17.42) 263.26,19.88 v4(263.54,20.16) ; 102.2,6.29 104.43,6.29 106.44,4.28 108.45,4.28 v3(108.68,4.51) ; 102.2,6.29 102.2,9.24 103.21,10.25 v5(103.21,10.99)
  BOTTOM w0.152: R322.1 200.43,9.95 200.43,9.13 200.95,8.6 v4(201.28,8.6)
  BOTTOM w0.203: v5(110.63,65.81) 110.63,66.03 R652.1 ; RC664.1 181.03,41.61 181.39,41.25 182.15,41.25 182.6,40.8 v4(182.6,40.59) ; PR1112.1 PR1111.1 96.1,55.95 95.91,55.76 94.9,55.76 94.25,56.41 94.25,57.29 95.09,58.13 PR1102.1 ; UM2.13 279.42,53.97 v4(279.3,53.84) ; v4(98.82,55.85) 98.83,55.86 PR1113.1
  BOTTOM w0.254: v4(263.54,20.16) 263.84,20.46 RW19.2 ; UC4.5 194.42,28.34 C4202.1 v4(193.82,28.48) ; v4(204.57,16.39) 204.64,16.39 206.21,14.83 RE449.2 ; v4(182.6,40.59) 182.97,40.23 RC663.1 ; UC5.5 193.13,21.46 192.88,21.2 C4201.1 v5(192.88,20.26) ; RE87.2 151.82,28.33 152.08,28.06 155.89,28.06 160.23,23.72 169.51,23.72 170.19,23.03 v4(170.19,22.84) ; v4(162.04,28.24) 162.32,28.52 162.48,28.52 162.82,28.86 RE215.1 ; PR101.1 v5(103.21,10.99)
  BOTTOM w0.381: v4(96.28,58.08) 95.78,58.08 95.73,58.13 PR1102.1 ; RE488.2 5.02,43.25 v5(5.35,43.58) ; v5(258.41,52.27) 258.28,52.39 258.28,56.08 258.71,56.51 RT225.2
  BOTTOM w0.508: 102.71,70.1 102.71,71.47 101.86,72.32 U7.5 100.52,72.32 C37.1 100.46,72.38 C4199.1 ; 102.71,70.1 103.06,69.74 105.23,69.74 U714.5 ; 102.71,70.1 101.89,69.28 v4(101.89,68.66) ; v5(191.63,72.12) 192.18,72.12 192.27,72.02 PR900.1 ; v5(89.19,66.24) 89.37,66.06 CZ1.1 ; UC2.5 104.81,64.71 CC1.1 103.98,64.18 v4(103.87,64.08) ; RPD84.1 28.93,27.99 v4(28.41,27.99) ; RC663.1 183.27,39.84 183.53,39.59 R5717.1 ; R688.1 184.42,46.45 184.21,46.65 183.2,46.65 C455.1 C454.1 182.08,46.55 181.67,46.14 v5(181.67,44.95)
  vias: v2(21.15,42.79) v2(21.5,42.44) v2(190.74,44.92) v2(190.67,44.65) v2(203.54,17.04) v2(203.59,17.49) v2(203.87,16.71) v2(203.98,17.14) v2(204.34,16.82) v2(208.15,9.5) v2(208.66,9.5) v2(209.17,9.5) v2(225.34,9.02) v2(225.82,9.02) v2(226.28,9.01) v3(21.15,42.79) v3(21.5,42.44) v3(31.03,25.57) v3(96.74,22.95) v3(97.35,22.95) v3(191.22,44.48) v3(191.56,44.19) v3(196.59,34.25) v3(196.59,33.49) v3(196.59,33.05) v3(196.74,33.87) v3(196.87,32.59) v3(196.97,33.33) v3(197.12,33.71) v3(197.08,32.94) v3(197.18,32.31) v3(197.42,33.41) v3(197.48,33.01) v3(197.48,32.58) v3(203.54,17.04) v3(203.59,17.49) v3(203.87,16.71) v3(203.98,17.14) v3(204.34,16.82) v3(208.15,9.5) v3(208.66,9.5) v3(209.17,9.5) v3(225.34,9.02) v3(225.82,9.02) v3(226.28,9.01) v3(237.96,11.22) v3(238.52,11.22) v3(239.05,11.22) v3(265.93,6.49) v3(266.49,6.49) v4(20.97,46.37) v4(21.15,42.79) v4(21.27,46.14) v4(21.5,42.44) v4(191.22,44.48) v4(191.56,44.19) v4(196.59,34.25) v4(196.59,33.49) v4(196.59,33.05) v4(196.74,33.87) v4(196.87,32.59) v4(196.97,33.33) v4(197.12,33.71) v4(197.08,32.94) v4(197.18,32.31) v4(197.42,33.41) v4(197.48,33.01) v4(197.48,32.58) v4(208.15,9.5) v4(208.66,9.5) v4(209.17,9.5) v4(209.77,4.28) v4(210.1,4.28) v4(211.04,4.17) v4(211.62,4.17) v4(225.34,9.02) v4(225.82,9.02) v4(226.28,9.01) v4(237.96,11.22) v4(238.52,11.22) v4(239.05,11.22) v4(265.93,6.49) v4(266.49,6.49) v5(21.55,47.87) v5(21.55,47.31) v5(107.79,61.84) v5(171.29,14.57) v5(175.83,6.68) v6(188.56,38.22) v6(193.82,39.9)
+3VALW_DSW: length 139.5
  TOP w0.254: v5(171.28,38.65) 171.2,38.57 168.82,38.57 165.06,34.82 v6(165.06,33.62) 165.03,33.59 v4(165.03,32.61) 165.81,32.61 166.08,32.89 169.32,32.89 169.51,32.7 169.51,29.68 v3(169.35,29.53) ; v5(162.64,33.88) RH601.2
  TOP w0.508: R204.2 181.95,50.11 C218.1 v5(181.22,50.61) 181.01,50.82 179.64,50.82 177.74,48.91 177.08,48.91 176.52,48.35 176.52,47.54 175.35,46.37 175.35,44.39 174.99,44.04
  IN1 w0.254: v3(163.75,44.06) 163.76,44.08 164.11,44.08 v2(164.17,44.13)
  IN2 w0.254: v5(172.3,44.65) 172.3,42.89 171.41,42 171.41,38.79 v5(171.28,38.65)
  IN2 w0.508: v3(114.57,70.66) 114.82,70.4 114.82,69.15 116.01,67.96 116.91,67.56 140.04,67.56 140.93,66.67 142.01,66.67 142.62,67.28 145.99,67.28 146.5,66.77 148.86,66.77 149.37,67.28 168.49,67.28 169.69,66.08 169.69,65.06 171.77,62.98 171.77,61.84 176.87,56.74 178.25,56.74 181.09,53.89 181.09,50.74 v5(181.22,50.61)
  IN3 w0.254: v3(169.35,29.53) 169.79,29.53 170.02,29.3 v4(170.02,28.86) ; v4(163.48,44.33) v3(163.75,44.06)
  IN3 w0.508: v4(101.56,73.47) 102.38,72.66 108.29,72.66 109.35,71.59 114.03,71.59 114.57,71.06 v3(114.57,70.66)
  BOTTOM w0.254: v5(171.28,38.65) 171.35,38.57 171.51,38.57 171.67,38.42 RH653.2 ; v4(165.03,32.61) 165.03,32.44 164.78,32.19 163.01,32.19 162.9,32.3 162.9,32.86 162.49,33.27 RH297.2 162.46,33.37 162.46,33.69 v5(162.64,33.88)
+3VALWP: length 18.2
  IN2 w0.254: v3(213.48,19.55) 207.47,19.55 202.4,24.62 v4(202.4,28.9)
  IN3 w0.254: v4(214.03,19.11) 213.91,19.11 v3(213.48,19.55)
  vias: v1(205.2,29.25)
+3VLP: length 450.6
  TOP w0.254: RE411.1 184.72,6.64 184.82,6.54 RE478.1 184.52,6.16 v2(184.29,5.93) ; v4(170.19,22.33) 170.19,22.27 170.05,22.12 RE152.1 ; RE479.1 v2(183.15,8.98)
  TOP w0.508: v5(94.58,10.91) 94.83,11.17 95.29,11.17 96.38,12.26 PJTAG2.1 96.41,13.43 PJTAG8.1 PJTAG7.1 96.41,17.44 PJTAG3.1 96.38,18.79 PJTAG9.1 96.41,20.13 PJTAG1.1 96.38,21.46 PJTAG4.1 ; R6225.2 4.97,40.33 4.61,39.97 4.61,38.76 4.87,38.5 9.14,38.5 10.82,36.82 19.47,36.82 24.02,32.28 32.42,32.28 35.5,29.2 35.5,27.75 36.3,26.95 36.3,25.21 37.91,23.61 37.91,22.5 36.31,20.9 36.31,18.25 36.79,17.77 36.79,16.81 v3(36.74,16.76) ; v4(212.55,3.81) 212.87,4.13 230.37,4.13 v5(231.67,2.83) 231.67,2.47 231.94,2.2 232.6,2.2 232.96,2.56 232.96,2.89 233.19,3.12 R6227.1 234.61,3.12 234.94,2.79 C4241.1 234.94,1.82 235.22,1.54 252.34,1.54 v1(252.92,2.13) 254.29,3.5 v5(256.38,3.5)
  IN1 w0.254: v4(212.55,3.81) 212.55,3.74 212.36,3.55 211.65,3.55 211.06,4.13 209.59,4.13 209.51,4.21 201.94,4.21 198.77,7.38 197.8,7.38 197.51,7.68 195.43,7.68 194.4,6.65 193.23,6.65 193.06,6.48 189.22,6.48 188.09,5.34 184.22,5.34 v3(183.99,5.58) 184.29,5.89 v2(184.29,5.93) 184.01,6.22 183.12,6.22 182.62,6.71 182.62,7.54 183.15,8.07 v2(183.15,8.98)
  IN1 w0.508: v3(33.05,16.92) 32.35,16.22 v3(30.9,16.22)
  IN2 w0.508: v5(256.38,3.5) 256.38,5.89 259.09,8.6 262.27,8.6 269.41,15.74 269.41,23.77 272.51,26.87 272.51,28.35 273.41,29.26 273.41,31.24 272.96,31.7 272.96,32.61 275.63,35.27 275.63,42.16 274.61,43.17 v3(271.49,43.17) ; v3(30.9,16.22) 30.38,15.7 30.38,12.46 29.83,11.91 29.83,5.63 30.75,4.72 30.75,3.52 31.05,3.22 37.71,3.22 39.28,4.79 40.39,4.79 41.52,5.92 41.52,5.99 42.43,6.91 62.1,6.91 62.56,6.44 74.28,6.44 74.84,7 79.95,7 80.46,6.49 92.96,6.49 94.34,5.12 v3(97.63,5.12) 98.26,4.49 101.41,4.49 102.66,3.24 108.29,3.24 109.44,4.39 v5(109.44,4.46)
  IN3 w0.508: v3(271.49,43.17) 270.72,43.94 268.51,43.94 267.87,43.31 265.36,43.31 264.83,42.79 263.75,42.79 263.39,43.15 263.39,43.4 263.11,43.68 v4(261.94,43.68) ; v5(94.58,10.91) 94.27,10.91 93.89,10.53 93.89,8.85 v3(97.63,5.12) ; v3(33.05,16.92) 33.81,16.92 34.48,16.25 35.83,16.25 36.34,16.76 v3(36.74,16.76) ; v3(180.54,5.5) 180.44,5.61 180.27,5.61 179.86,6.02 178.18,6.02 177.19,7.01 176.71,7.01 175.81,7.92 v4(173.27,7.92) ; v4(173.27,2.34) 160.28,2.34 v4(159.78,2.84)
  BOTTOM w0.254: PR305.1 211.29,17.95 211.16,17.82 210.96,17.82 210.02,16.88 210.02,15.94 209.28,15.21 209.28,12.64 210.49,11.43 211.87,11.43 212.57,10.73 212.57,7.03 212.71,6.88 212.71,3.97 v4(212.55,3.81) ; JIO1.35 225.35,7.7 228.97,4.08 229.33,4.08 230.06,3.35 231.15,3.35 v5(231.67,2.83) ; v4(170.19,22.33) 170.19,19.58 170.73,19.04 170.73,14.8 170.04,14.11 170.04,11.14 v4(173.27,7.92)
  BOTTOM w0.508: v4(159.78,2.84) 159.4,3.22 159.4,4.47 157.02,6.85 110.4,6.85 109.44,5.88 v5(109.44,4.46) ; v4(173.27,2.34) v4(173.27,7.92)
+3VS: length 734.7
  TOP w0.254: 175.48,28.29 175.48,26.48 175.22,26.23 174.23,26.23 173.67,26.79 v4(173.32,26.79) 172.74,26.79 UH6.5 ; 175.48,28.29 175.91,28.29 175.96,28.24 ; 175.48,28.29 174.87,28.9 RH733.2 ; v2(94.53,36.03) 93.49,36.03 91.57,37.95 91.57,38.82 88.56,41.83 88.56,47.62 92.39,51.45 92.39,57.76 91.58,58.56 88.08,58.56 v5(87.39,59.25) ; RH713.1 171.43,49.59 v5(171.62,49.78) 172.18,49.78 RH655.2 ; R237.2 128.59,60.75 129.53,59.81 130.16,59.81 130.44,59.53 130.44,58.85 131.36,57.93 134.23,57.93 135.24,58.95 135.24,61.56 138.32,64.64 v2(138.32,64.89)
  TOP w0.356: 156.5,35.81 156.85,36.16 161.49,36.16 161.91,35.73 165.32,35.73 168.7,39.11 170.6,39.11 v2(172.73,41.24)
  TOP w0.381: F5.1 161.71,62.98 CC17.1 161.76,62.3 161.96,62.1 v5(161.96,61.47) ; CC652.2 181.6,28.29 181.43,28.46 UH1.5 180.67,28.46 180.4,28.72 180.4,28.75 180.2,28.96 179.12,28.96 178.58,29.51 176.37,29.51 175.96,29.1 175.96,28.24 RH727.1
  TOP w0.508: RC433.1 168.67,56.08 167.92,55.33 167.92,53.32 168.77,52.47 170.45,52.47 171.62,51.3 v5(171.62,49.78) ; 170.47,57.27 170.47,57.74 ; 170.47,57.74 172.79,57.74 173.15,57.38 RC244.2 ; 170.47,57.74 168.15,57.74 166.74,59.15 166.74,60.58 166.51,60.8 R6223.1 166.08,61.07 v5(165.07,62.08) ; v3(86.88,32.76) 89.68,29.96 v2(92.5,29.96) ; v2(176.49,40.58) 177.05,40.58 177.26,40.78 RH631.1 177.67,41.6 178.05,41.98 ; R216.2 123.46,6.46 C230.1 122.76,6.28 122.57,6.47 122.06,6.47 121.3,5.71 v3(121.3,5.48) ; v3(190.87,4.78) 190.87,5.06 191.26,5.46 RE237.1 ; v2(19.6,43.63) 22.19,43.63 23,42.82 v6(23.61,42.82) 26.51,42.82 32.12,48.43 v2(33.95,48.43) ; v5(230.84,8.26) 228.87,6.29 v3(226.48,6.29) 226.43,6.24 198.81,6.24 198.28,5.71 197.5,5.71 v3(197.22,5.43) ; v5(255.13,39.13) 255.13,35.98 255.69,35.43 256.13,35.43 257.87,33.69 257.87,30.62 256.27,29.02 253.84,29.02 253.61,28.8 253.61,25.54 254.14,25.01 ; v3(96,38.17) 97.25,36.92 v2(97.25,36.09) 97.25,35.65 99.53,33.36 99.53,29.84 100.47,28.9 v5(101.94,28.9)
  IN1 w0.254: v2(138.32,64.89) 138.42,64.79 144.08,64.79 v3(144.29,64.99) ; v2(178.05,43.11) 178.91,43.11 179.36,42.66 180.46,42.66 181.38,41.75 182.3,41.75 182.83,41.22 v4(183.22,41.22) ; v4(95.26,47.82) 95.26,47.92 94.83,48.35 94.33,48.35 93.62,47.64 arc(93.37,47.27) 93.28,46.84 93.28,44.95 92.75,44.42 92.75,43.39 94.02,42.12 94.02,39.64 95.49,38.17 v3(96,38.17) ; v2(97.25,36.09) 97.19,36.03 v2(94.53,36.03)
  IN1 w0.508: v2(176.49,40.58) 176.42,40.51 173.68,40.51 172.94,41.24 v2(172.73,41.24) 172.27,40.78 171.57,40.78 171.08,41.27 171.08,42.31 170.04,43.35 168.51,43.35 v3(167.97,42.81) ; v2(33.95,48.43) 36.69,48.43 v4(36.95,48.18) ; v2(92.5,29.96) 94.25,28.21 101.31,28.21 101.94,28.85 v5(101.94,28.9) ; v4(174.41,6.65) 174.18,6.65 173.25,5.71 170.87,5.71 v3(170.5,5.34) ; v4(18.51,43.5) 18.63,43.63 v2(19.6,43.63)
  IN2 w0.254: v4(103.34,69.05) 103.34,71.95 100.03,75.27 98.2,75.27 96.39,73.46 92.56,73.46 92.11,73.91 89.5,73.91 88.63,74.77 v4(88.63,75.11) ; v3(180.99,46.73) 181.04,46.68 181.04,45.79 180.61,45.36 180.61,44.13 183.22,41.52 v4(183.22,41.22)
  IN2 w0.381: v4(183.22,41.22) 183.41,41.03 183.41,40.06 184.25,39.22 184.25,38.41 185.57,37.09 v3(185.57,36.55)
  IN2 w0.508: v5(255.59,47.74) 255.39,47.54 255.39,39.39 v5(255.13,39.13) ; v4(36.95,48.18) 36.95,30.7 32.55,26.3 32.55,24.75 34.94,22.37 35.47,22.37 35.65,22.55 36.24,22.55 36.92,21.86 38.57,21.86 44.46,15.97 67.21,15.97 67.49,16.25 73.49,16.25 87.39,30.15 87.39,32.25 v3(86.88,32.76) ; v5(171.62,49.78) 171.41,49.57 171.41,47.1 169.18,44.87 169.18,44.82 167.97,43.62 v3(167.97,42.81) ; v3(254.47,24.25) 253.68,24.25 251.7,22.27 251.7,19.35 249.66,17.31 249.66,15.07 247.18,12.59 245.28,12.59 242.69,10 242.69,9.53 241.54,8.39 236.22,8.39 235.62,8.98 234.58,8.98 234.25,8.65 231.23,8.65 v5(230.84,8.26) ; v5(154.01,34.71) 150.61,31.31 113.57,31.31 111.74,29.48 106.49,29.48 105.6,30.37 103.42,30.37 v5(101.94,28.9)
  IN2 w0.762: 175.43,4.31 171.13,4.31 170.89,4.55 170.89,4.94 v3(170.5,5.34) 170.11,5.34 169.89,5.55 153.4,5.55 152.2,4.35
  IN3 w0.254: v3(226.48,6.29) 226.15,5.96 v4(226.15,5.83) ; v4(106.8,3.7) 113.15,3.7 114.39,4.95 119.44,4.95 119.83,5.33 121.04,5.33 121.2,5.48 v3(121.3,5.48) ; v4(184.8,47.19) 184.65,47.03 184.21,47.03 183.58,47.67 181.93,47.67 181.27,47.01 v3(180.99,46.73) ; v4(184.71,36.85) 184.77,36.79 185.33,36.79 v3(185.57,36.55) ; v4(273.09,53.11) 273.55,52.66 273.55,50.34 272.28,49.07 272.28,48.64 271.24,47.59 271.24,46.7 270.78,46.25 269.23,46.25 268.57,45.59 260.77,45.59 259.47,44.29 259.47,43.63 v4(259.32,43.48) ; v3(144.29,64.99) v4(143.78,64.99)
  IN3 w0.381: v5(171.62,49.78) 171.62,48.66 v4(172.15,48.13)
  IN3 w0.508: v3(96,38.17) v4(95.26,38.17) ; v4(143.52,67.24) 143.82,66.95 148.07,66.95 148.36,67.24 v4(154.57,67.24)
  BOTTOM w0.254: v5(154.01,34.71) 153.76,34.46 153.54,34.46 151.71,32.63 RH745.2 RH621.2 RC717.1 RH746.2 ; v4(143.52,67.24) 143.52,66.62 143.78,66.36 v4(143.78,64.99) ; RT12.2 36.68,48.44 v4(36.95,48.18) ; R200.1 188.08,46.78 R704.1 186.98,46.78 186.55,47.21 184.9,47.21 184.88,47.19 v4(184.8,47.19) ; R220.1 103.48,69.05 v4(103.34,69.05) ; v4(106.8,3.7) 106.08,3.7 105.37,2.99 96.93,2.99 95.64,4.28 93.49,4.28 92.47,5.3 73.17,5.3 72.82,5.64 72.82,6.82 72.87,6.88 R37.2 R36.2 ; v5(87.39,59.25) 87.24,59.4 87.24,70.4 87.19,70.45 87.19,71.7 87.85,72.36 87.85,74.67 88.29,75.11 v4(88.63,75.11)
  BOTTOM w0.305: v4(226.15,5.83) 225.97,6.01 225.97,6.39 224.75,7.62 JIO1.33
  BOTTOM w0.356: 173.47,49.08 RC223.2 173.47,48.51 ; RC222.2 173.47,49.66
  BOTTOM w0.381: R649.1 183.35,41.34 v4(183.22,41.22) ; 173.47,49.08 RC656.2 173.47,49.66 ; 173.47,48.51 RC655.2 173.47,47.64 173.14,47.31 172.53,47.31 172.15,47.69 v4(172.15,48.13)
  BOTTOM w0.508: 161.96,61.28 161,60.32 156.22,60.32 156.02,60.52 RH747.1 156.02,61.43 156.56,61.97 156.56,62.42 155.16,63.82 155.16,66.64 154.57,67.23 v4(154.57,67.24) ; 161.96,61.28 v5(161.96,61.47) ; 161.96,61.28 162.22,61.03 RC749.1 RC748.1 163.67,61.03 164.2,61.56 164.55,61.56 v5(165.07,62.08) ; v4(143.52,67.24) 143.07,67.7 RC631.1 ; R39.2 233.11,6.65 232.93,6.82 231.2,6.82 R40.2 230.77,8.2 v5(230.84,8.26) ; R232.1 255.23,49.4 255.59,49.04 v5(255.59,47.74) 255.59,44.19 256.3,43.48 v4(259.32,43.48) 260.34,43.48 R638.1 ; v4(156.81,34.74) 156.81,34.16 156.8,34.15 156.8,32.45 156.47,32.12 RE93.2 156.47,31.09 156.79,30.77 156.79,29.13 158.31,27.61 159.26,27.61 162.15,24.72 169.52,24.72 170.98,26.18 172.71,26.18 v4(173.32,26.79) 175.22,24.88 175.22,19.5 173.45,17.72 173.45,13.4 174.03,12.81 v4(174.03,11.72) 174.36,11.4 174.36,6.7 v4(174.41,6.65)
  vias: v2(156.33,35.17) v2(254.09,24.02) v2(254.94,24.01) v4(253.61,24.09) v4(253.96,24.09) v5(150.67,4.75) v5(150.67,4.12) v5(151.31,4.75) v5(151.31,4.12)
+3VS_CR: length 4.8
  TOP w0.127: v5(15.56,38.63) v6(17.9,38.63)
  BOTTOM w0.203: UCR1.27 12.72,39.13 13.54,38.31 CR20.1
  vias: v5(12.05,46.25) v5(12.05,45.69) v5(14.97,38.63)
+3VS_CR_R: length 2.7
  BOTTOM w0.069: R669.1 20.66,37.15 v1(20.74,37.08)
  BOTTOM w0.508: UC31.1 20.92,38.68 R669.1
+3VS_FP: length 103.3
  TOP w0.508: v2(199.86,3.85) 199.86,3.85 199.86,3.81 197.87,1.82 v1(190.95,1.82) 189.27,1.82 188.48,2.61 188.43,2.61 R629.2
  IN1 w0.254: v2(199.86,3.85) 199.72,3.99 199.72,5.32 198.3,6.73 198.3,6.83 198.28,6.86 198.28,6.91 v3(198.23,6.95)
  IN2 w0.254: v3(198.23,6.95) 198.36,7.08 222.79,7.08 223.17,7.46 227.65,7.46 227.9,7.21 241.69,7.21 243.09,8.6 244.31,8.6 246.54,10.84 246.54,11.32 246.8,11.57 247.28,11.57 250.45,14.75 250.45,16.87 252.9,19.31 252.9,21.99 254.95,24.05 254.95,24.69 258.22,27.96 258.22,28.21 258.98,28.96 258.98,34.06 257.34,35.69 257.34,40.06 v4(258.32,41.04)
+3VS_FP_R: length 4.9
  BOTTOM w0.508: F2.1 256.48,42.87 v1(257.82,42.87) C2990.1 259.63,42.87 259.98,42.51 R638.2 R390.1
+3VS_R: length 2.2
  TOP w0.069: R216.1 123.24,5.06 122.47,5.83 122.39,5.83 v1(122.37,5.86)
+3VS_SSD: length 40.1
  TOP w0.127: CS89.1 184.24,5.2 185.01,4.43 185.01,4.19 185.62,3.58 v6(185.62,3.23) 185.62,2.54 184.9,1.82 v6(184.9,1.69) 184.93,1.67 186.55,1.67 v6(186.58,1.69)
  IN1 w0.254: v2(177.18,8.73) 177.2,8.76 v3(177.2,9.67)
  IN3 w0.254: v3(177.2,9.67) 177.64,9.24 179.41,9.24 180.68,7.97 181.22,7.97 182.82,6.37 v5(182.82,5.73)
  BOTTOM w0.254: 183.73,23.82 183.35,23.44 180.56,23.44 176.89,27.1 176.1,27.1 RS380.2
  BOTTOM w1.016: 184.75,23.56 184.11,22.93 184.11,17.34 184.75,16.71 184.75,10.48
  vias: v5(183.43,5.73) v5(184.62,26.41) v5(184.82,26.94)
+3VS_SSD_R: length 1
  TOP w0.069: US1.8 178.67,6.89 v1(178.98,7.21)
+3VS_TP: length 52
  IN3 w0.254: v4(215.76,5.57) v4(212.13,5.57)
  BOTTOM w0.254: 195.31,4.69 195.06,4.95 193.94,4.95 193.74,4.74 193.74,2.3 194.45,1.59 R6215.1 196.51,1.58 196.66,1.43 198.76,1.43 199.25,1.92 199.25,2.46 200.42,3.62 202.55,3.62 205.37,6.45 205.37,8.35 206.85,9.82 ; 195.31,4.69 195.58,4.96 R6217.1 195.82,5.07 196.1,5.35 196.1,5.54 R6218.1 ; 195.31,4.69 195.31,3.66 195.57,3.41 196.08,3.41 196.1,3.38 R6216.1 ; 207.1,10.74 207.1,11.37 v1(206.69,11.78) R6214.2 205.89,12.68 204.69,13.89 204.69,14.8 204.59,14.9 203.86,14.9 203.61,14.65 203.61,14.19 203.95,13.84 203.95,13.51 204.69,12.77 204.69,12.52 ; v4(212.13,5.57) 212.03,5.67 212.03,10.43 211.78,10.68 210.12,10.68 210,10.56 ; v4(215.76,5.57) 218.03,5.57 218.75,6.29 218.75,8.23 JIO1.13
+3VS_TP_R:
  vias: v1(211.6,8.55)
+3VS_TPM: length 5.8
  BOTTOM w0.254: U712.8 189.32,44.8 189.14,44.98 189.14,45.46 ; 189.14,45.46 C95.1 188.48,45.46 R200.2 ; 189.14,45.46 190.11,45.46 v1(190.18,45.38) 190.18,44.8 191.43,43.55 C94.1
+3VS_TS: length 21.7
  TOP w0.508: v2(120.99,67.07) 125.13,67.07 125.19,67.02
  IN1 w0.508: v2(120.99,67.07) 115.18,67.07 112.76,69.49 110.25,69.49 109.43,70.3 107.77,70.3 107.15,70.92 107.15,71.24
  BOTTOM w0.508: v4(126.13,65.46) 126.13,65.06 126.85,64.34 127.17,64.34 JEDP1.45
  vias: v3(106.87,71.9) v3(107.35,71.9) v4(106.87,71.9) v4(107.35,71.9)
+3VS_WLAN: length 247.6
  TOP w0.127: v6(263.77,7.41) 263.72,7.36 CW12.1
  TOP w0.508: v2(250.97,7) 248.65,7 244.31,11.35 229.82,11.35 226.62,8.15 225.34,8.15 225.13,7.94 201.05,7.94 200.7,8.3 v3(200.7,8.6)
  IN1 w0.508: v3(63.46,8.37) 46.71,8.37 v3(44.22,10.87) ; v3(71.03,8.25) 71.36,7.92 73.68,7.92 74.36,8.6 80.85,8.6 81.48,7.97 93.51,7.97 95.57,5.91 103.63,5.91 v3(104.26,5.28) ; v2(250.97,7) 252.54,7 v3(253,7.46)
  IN2 w0.508: v3(104.26,5.28) 105.3,5.28 105.55,5.53 108.16,5.53 109.08,6.46 114.89,6.46 115.56,7.13 170.4,7.13 171.16,7.89 176.65,7.89 177.77,9.01 179.26,9.01 180.18,9.92 184.59,9.92 186.67,12.01 189.78,12.01 191.42,10.36 193.43,10.36 193.74,10.05 194.81,10.05 195.42,10.66 197.89,10.66 199.62,8.93 200.37,8.93 v3(200.7,8.6)
  IN3 w0.508: v3(44.22,10.87) 44.22,11.2 41.97,13.44 41.97,13.48 36.23,19.22 32.75,19.22 29.4,22.57 25.97,22.57 25.36,23.18 v4(24.3,23.18) ; v3(63.46,8.37) 63.87,8.37 64.15,8.65 70.63,8.65 v3(71.03,8.25)
  BOTTOM w0.508: v4(24.3,23.18) 24.22,23.18 24.14,23.26 L74.1
  vias: v2(259.46,11.35) v2(259.46,10.71) v2(261.84,7.82) v2(262.17,7.84) v2(262.52,7.84) v2(262.62,17.21) v2(262.85,7.84) v2(264.71,3.52) v2(265.22,3.65) v2(265.22,3.32) v2(265.49,3.52) v2(267.91,16.76) v2(267.91,16.43) v2(268.21,16.96) v2(268.21,16.6) v3(258.94,11.19) v3(258.99,11.73) v3(259.09,10.71) v3(261.99,7.43) v3(261.99,6.93) v3(262.52,7.43) v3(262.55,6.93) v3(265.01,4.59) v3(265.01,4.08) v3(265.52,4.59) v3(265.52,4.08) v4(252.64,8.15) v4(252.67,8.48) v4(261.56,11.47) v4(261.56,11.09) v4(261.84,11.22) v4(261.81,10.89) v4(262.04,8.4) v4(262.04,8.02) v4(262.37,8.4) v4(262.37,8.02) v4(264.45,3.78) v4(264.5,3.5) v4(264.76,3.65) v4(265.06,3.65)

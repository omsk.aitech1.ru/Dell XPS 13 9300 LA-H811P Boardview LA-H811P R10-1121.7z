# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3.3A_CPU_NOA_LA_VAL: length 9.7
  TOP w0.069: JMIPI60.52 103.38,72.76 103.54,72.92 105.88,72.92 106.34,72.46 106.34,71.04 107.07,70.3 109.61,70.3 R138.2
VCC1P8A_EN: length 2.2
  BOTTOM w0.069: v1(139.82,67.84) 140.62,67.84 140.7,67.75 RC226.2 140.7,67.2 140.27,66.76 UC22.4
VCC_3V: length 2.6
  BOTTOM w0.069: PC335.1 218.5,20.06 218.61,20.16 v1(218.61,21.02)
  BOTTOM w0.254: PC335.1 218.45,20.01 218.06,19.61 PU302.9
VCC_SFR_OC_EN: length 2.2
  BOTTOM w0.069: RC640.2 148.74,32.86 v1(148.1,32.86) 148.1,31.65 UC27.4
VCCDSW_EN: length 26.6
  TOP w0.069: CE108.1 181.95,10.99 v2(181.3,11.63) 181.21,11.73 181.21,13.47 UE1.M7
  IN1 w0.061: v4(181.12,23.87) 181.5,23.87 181.78,23.59 181.78,22.75 181.24,22.22 181.24,21.2 180.58,20.54 180.58,19.7 180.35,19.47 180.35,18.51 180.73,18.13 181.29,18.13 181.52,17.9 181.52,16.69 181.23,16.4 181.01,16.4 180.86,16.25 180.86,15.77 180.99,15.64 180.99,11.95 v2(181.3,11.63)
  BOTTOM w0.069: v4(181.12,23.87) 180.5,23.87 177,27.36 176.21,27.36 175.06,28.52 RC697.1
VCCDSW_EN_GPIO: length 35.5
  TOP w0.069: R374.2 R375.2 RC657.1 ; R374.2 RC651.1 ; R374.2 183.35,41.89 183.35,41.47 183.96,40.86 v2(183.96,40.81)
  IN1 w0.061: v2(183.96,40.81) 184.01,40.76 184.01,39.95 185.26,38.7 187.74,38.7 188,38.44 188.64,38.44 189.03,38.04 v3(189.57,38.04)
  IN3 w0.061: v4(175.64,28.34) 175.94,28.63 178.08,28.63 178.53,28.19 180.53,28.19 181.06,28.71 181.44,28.71 182.63,29.91 184.31,29.91 184.46,29.75 185.37,29.75 185.79,30.18 187.86,30.18 190.18,32.5 190.18,36.34 189.19,37.32 189.19,37.76 189.47,38.04 v3(189.57,38.04)
  BOTTOM w0.069: DC1.2 175.64,29.39 RC697.2 v4(175.64,28.34)
VCCDSW_EN_Q: length 3
  BOTTOM w0.069: RC698.1 174.33,30.38 DC1.1 175.88,30.85 DC2.2
VCCIN_AUX_CORE_VID: length 3.4
  BOTTOM w0.069: RC624.2 180.3,43.29 180.3,43.86 RC735.1 180.32,44.4 180.17,44.55 UC9.2
VCCIN_AUX_VCCSENSE: length 61.7
  IN1 w0.254: v4(189.65,71.27) 189.61,71.32 180.56,71.32 176.58,67.33 148.76,67.33 146.88,65.45 140.76,65.45 140.04,66.16 139.77,66.16 139.35,65.74 v4(139.35,65.64)
  BOTTOM w0.254: v4(189.65,71.27) 190.14,70.78 PR915.2 ; RC685.1 135.44,62.43 136.49,62.43 137,62.93 138.6,62.93 139.35,63.68 v4(139.35,65.64)
VCCIN_AUX_VCCSENSE_R: length 14.3
  IN3 w0.254: v4(144.49,55.04) 143.98,55.55 143.36,55.55 142.72,54.91 138.6,54.91 136.82,56.69 136.82,58.44 134.94,60.32 134.82,60.32 v4(134.67,60.32)
  BOTTOM w0.254: RC685.2 134.64,60.35 v4(134.67,60.32)
VCCIN_AUX_VCCSENSE_VR: length 2.2
  BOTTOM w0.254: PR915.1 191.64,69.98 PU900.16
VCCIN_AUX_VR_PG: length 306.2
  TOP w0.069: v3(198.21,34.28) 194.56,34.28 191.99,31.71 191.99,30.75 192.4,30.34 194.72,30.34 195.19,29.87 195.19,27.45 197.21,25.43 197.21,22.55 194.59,19.94 194.59,17.34 194.13,16.87 v1(194.13,15.46) 194.13,13.25 194.67,12.71 194.67,11.9 194.35,11.57 v3(194.35,10.91) ; v3(174.51,9.05) 174.42,9.05 174.03,9.44 D474.1
  IN1 w0.061: v4(4.43,42.73) 4.43,40.25 4.92,39.77 5.91,39.77 6.69,38.98 9.01,38.98 9.45,38.54 9.76,38.23 10.02,38.23 13.47,34.78 13.47,33.42 13.9,32.98 16.78,32.98 19.08,30.68 19.08,29.14 20.62,27.59 20.62,19.41 21.91,18.12 23.46,18.12 23.81,18.47 28.96,18.47 29.63,19.14 v3(31.13,19.14) ; v2(183.11,10.16) 183.11,10.39 183.17,10.44 183.17,10.65 v3(183.33,10.81)
  IN2 w0.051: v3(194.35,10.91) 194.15,11.12 193.69,11.12 193.47,10.89 191.64,10.89 191.27,11.27 191.27,12.42 191,12.69 186.39,12.69 184.69,10.99 183.68,10.99 183.5,10.81 v3(183.33,10.81) 177.63,10.81 176.05,9.23 174.7,9.23 v3(174.51,9.05) 174.14,9.42 171.24,9.42 169.64,7.82 112.34,7.82 111.74,7.21 108.86,7.21 107.87,6.22 105.04,6.22 104.84,6.01 94.63,6.01 93.31,7.33 80.8,7.33 80.3,7.84 74.49,7.84 73.93,7.28 62.91,7.28 62.44,7.74 42.09,7.74 41.94,7.6 41.59,7.6 40.68,6.69 40.68,6.27 40.05,5.63 38.15,5.63 38.03,5.5 36.07,5.5 36.02,5.55 33.68,5.55 33.2,5.07 32.41,5.07 30.52,6.97 30.52,11.45 31.13,12.06 31.13,15.11 31.74,15.71 31.74,17.06 31.13,17.67 v3(31.13,19.14) ; v3(198.21,34.28) 198.24,34.3 198.24,36.01 197.8,36.44 197.8,37.53 199.25,38.98 199.25,45.76 v3(199.53,46.04)
  IN3 w0.061: v4(194.66,65.75) 195.35,66.44 197.27,66.44 201.13,62.58 201.94,62.58 202.83,61.69 202.83,60.34 200.78,58.29 200.78,52.67 201.87,51.58 201.87,49.62 200.6,48.35 200.6,47.11 v3(199.53,46.04)
VCCIN_AUX_VSSSENSE: length 63.1
  IN1 w0.254: v4(138.8,65.63) 138.8,65.91 139.55,66.67 140.25,66.67 140.97,65.96 146.67,65.96 148.55,67.84 176.37,67.84 180.35,71.82 190.05,71.82 v4(190.13,71.74)
  BOTTOM w0.254: v4(138.8,65.63) 138.84,65.59 v1(138.84,64.33) 138.84,63.89 138.39,63.44 136.79,63.44 136.28,62.93 135.23,62.93 134.07,61.77 RC686.1 ; PR916.2 190.62,71.26 v4(190.13,71.74)
VCCIN_AUX_VSSSENSE_R: length 14
  IN3 w0.254: v4(134.1,60.32) 134.61,59.81 134.73,59.81 136.31,58.23 136.31,56.47 138.39,54.4 142.93,54.4 v4(143.57,55.04)
  BOTTOM w0.254: RC686.2 134.07,60.35 v4(134.1,60.32)
VCCIN_AUX_VSSSENSE_VR: length 2
  BOTTOM w0.254: PR916.1 191.57,70.61 PU900.17
VCCIN_SENSE: length 31
  TOP w0.254: RC683.2 118.13,53.56 116.79,52.22 109.78,52.22 104.35,57.65 103.92,57.65 101.26,60.31 101.26,60.8 v2(101.23,60.83)
  IN1 w0.254: v3(100.95,61.26) 100.95,61.1 v2(101.23,60.83)
  IN2 w0.254: v3(100.95,61.26) 100.83,61.26 99.91,62.17 99.91,63.26 99.15,64.02 99.15,65.1 100.17,66.12 100.17,67 v3(100.04,67.12)
  IN3 w0.254: v4(100.52,66.32) 100.52,66.65 100.34,66.84 100.33,66.84 v3(100.04,67.12)
  BOTTOM w0.254: v4(100.52,66.32) PR1122.1
VCCIN_SENSE_R: length 6.7
  TOP w0.254: RC683.1 119.46,53.15 120.03,53.15 v2(120.62,52.56)
  IN1 w0.254: v2(120.62,52.56) 121.5,51.68 123.88,51.68 v8(124.68,50.88)
VCCIN_SENSE_VR: length 2.6
  BOTTOM w0.254: PU1100.6 99.1,63.5 99.85,64.24 99.95,64.24 100.47,64.76 PR1122.2
VCCST_EN: length 56.8
  TOP w0.069: UC13.4 147.1,61.62 146.83,61.89 v2(146.83,62.25)
  IN1 w0.061: v3(153,65.98) 152.52,65.5 150.07,65.5 147.51,62.94 147.06,62.94 146.8,62.68 146.8,62.27 v2(146.83,62.25)
  IN2 w0.051: v4(182.11,44.62) 182.11,45.64 182.61,46.14 182.61,49.99 181.62,50.98 181.62,54.4 178.61,57.41 177.16,57.41 173.1,61.47 173.1,62.44 v3(170.24,65.3)
  IN3 w0.061: v3(153,65.98) 153.07,65.98 154.14,64.91 155.56,64.91 157.21,66.57 168.97,66.57 v3(170.24,65.3)
  BOTTOM w0.069: RC627.2 181.57,44.08 v4(182.11,44.62) 182.11,44.7 v1(182.36,44.95)
VCCST_OVERRIDE: length 4.2
  BOTTOM w0.069: RH584.1 154.47,60.7 153.82,60.05 153.82,58.47 154.13,58.16 154.13,57.89 153.99,57.75 153.99,57.54 UC1.CE4
VCCST_OVERRIDE_R: length 39.3
  IN3 w0.061: v4(168.22,64.69) 162.37,64.69 161.79,65.27 158.46,65.27 156.35,63.16 v4(154.83,63.16)
  BOTTOM w0.069: v4(154.83,63.16) 154.83,62.45 154.47,62.1 RH584.2 RH586.2 ; RC615.1 180.76,51.69 181.07,52 181.07,52.68 180.96,52.79 QM1.5 179.96,52.79 179.64,53.1 179.64,53.56 179.01,54.2 v1(179.01,54.7) 178.47,55.24 178.47,56.51 177.76,57.22 176.02,57.22 174.03,59.21 174.03,60.47 173.75,60.75 170.5,60.75 168.22,63.03 v4(168.22,64.69)
VCCST_PWRGD: length 3.6
  BOTTOM w0.069: RH587.2 RH588.1 108.37,63.49 CC649.1 ; CC649.1 108.29,63.82 RC647.1 ; CC649.1 108.02,63.55 UE8.4
VCCST_PWRGD_CPU: length 56.2
  IN2 w0.051: v4(110.55,55.67) 110.88,56 118.2,56 119.06,55.14 133.08,55.14 133.55,54.67 134.19,54.67 134.48,54.37 146.95,54.37 148.96,56.38 153.91,56.38 v4(154.19,56.1)
  BOTTOM w0.069: RH587.1 109.03,62.55 109.46,62.55 109.82,62.2 109.82,62.02 110.12,61.72 110.25,61.41 110.25,60.42 110.81,59.86 v1(110.81,57.65) 110.81,56.28 110.55,56.02 v4(110.55,55.67) ; UC1.CF2 154.4,58.1 154.67,57.83 154.67,57.6 154.51,57.44 154.38,57.44 154.09,57.15 154.09,56.2 v4(154.19,56.1)
VCCSTG_EN: length 100.7
  TOP w0.069: v2(146.78,63.24) 146.47,62.93 146.47,62.27 v1(146.37,62.17) 145.78,61.59 RC634.2
  IN1 w0.061: v2(146.78,63.24) 147.58,63.24 150.07,65.73 152.16,65.73 v4(152.41,65.98)
  IN2 w0.051: v4(152.41,65.98) 152.41,66.01 152.8,66.39 167.24,66.39 167.45,66.19 167.45,64.97 175.22,57.2 175.22,53.41 176.52,52.11 179.16,52.11 180.25,51.02 180.25,45.89 179.78,45.42 179.78,44.01 181.14,42.65 181.14,42.26 181.82,41.59 v3(181.82,41.15)
  IN3 w0.061: v3(181.82,41.15) 181.8,41.14 181.21,41.14 180.7,41.64 175.45,41.64 175.1,41.29 174.56,41.29 174.51,41.24 173.91,41.24 173.25,41.91 169.52,41.91 169.02,42.42 168.52,42.42 168.02,41.92 165.54,41.92 165.26,41.64 160.43,41.64 160.15,41.35 157.61,41.35 157.44,41.19 v4(156.17,41.19)
  BOTTOM w0.069: v4(156.17,41.19) 155.59,41.19 155.41,41.01 154.9,41.01 154.65,41.27 154.42,41.27 154.29,41.39 153.91,41.39 153.73,41.22 153.28,41.22 153.15,41.34 152.69,41.34 152.39,41.04 152.39,37.94 152.54,37.79 152.54,35.07 151.6,34.13 149.81,34.13 RC640.1 ; UC12.4 151.93,67.28 152.41,66.79 v4(152.41,65.98)
VCCSTG_EN_MIPI: length 3.9
  TOP w0.069: UC11.4 144.33,63.81 144.41,63.72 144.41,61.97 RC634.1 145.61,60.77 v1(145.61,60.72)
VCCSTG_EN_R: length 3.9
  TOP w0.069: UC11.3 146.12,63.81 RC701.1 ; RC701.1 146.14,64.2 145.75,64.59 UC10.4 146.75,64.94 v1(146.93,64.76) ; RC701.1 RC636.1
VCCSTPWRGOOD_TCSS: length 3.2
  BOTTOM w0.069: RH586.1 153.89,60.55 153.61,60.27 153.61,58.26 UC1.CE3
VDD: length 13.8
  TOP w0.127: v6(29.33,4.26) 29.69,4.26 29.7,4.26 30.15,4.26 30.15,4.26 v2(30.6,4.26)
  TOP w0.254: PR207.2 36.29,7.49 v2(36.29,7.43) v2(36.29,7.05)
  IN1 w0.254: v3(31.94,3.88) 30.98,3.88 v2(30.6,4.26) ; v2(36.29,7.43) v2(36.29,7.05) 36.29,6.24 35.65,5.61 35.65,4.84 35.27,4.46 35.02,4.46 34.72,4.17 34.72,3.84 v5(34.76,3.8)
  IN2 w0.254: v3(31.94,3.88) 34.68,3.88 v5(34.76,3.8)
  BOTTOM w0.254: PC229.2 34.23,4.69 34.59,5.06 PU200.18
  BOTTOM w0.381: PC229.2 34.23,4.34 v5(34.76,3.8)
VDD18: length 2.2
  BOTTOM w0.203: PU1100.11 v1(101.31,60.91) 101.73,60.91 PC1108.1
VIN_AUX:
  vias: v1(199.33,71.87) v5(194.04,68.47) v5(194.68,69.11) v5(194.78,67.86) v5(195.23,69.54) v5(195.37,68.45) v5(195.72,69.03) v5(196.97,70.2) v5(197.35,69.77) v5(197.4,70.6) v5(197.78,70.15) v5(201,71.82) v5(201,71.06) v5(201,70.3) v5(202.02,72.33) v5(202.02,70.05) v5(202.66,72.33) v5(202.66,70.05) v5(203.29,72.33) v5(203.29,70.05) v5(203.93,72.33) v5(203.93,70.05) v5(204.94,71.82) v5(204.94,71.06) v5(204.94,70.3)
VSSIN_SENSE: length 30.3
  TOP w0.254: v2(101.72,60.85) 101.72,60.55 104.1,58.16 104.56,58.16 109.99,52.72 116.58,52.72 118,54.14 RC684.2
  IN1 w0.254: v2(101.72,60.85) 101.66,60.9 101.66,61.13 v3(101.49,61.31)
  IN2 w0.254: v3(100.8,67.12) 100.67,67 100.67,65.91 99.66,64.89 99.66,64.23 100.42,63.47 100.42,62.38 100.96,61.84 101.26,61.84 101.49,61.61 v3(101.49,61.31)
  IN3 w0.254: v4(101.28,66.32) 101.28,66.64 v3(100.8,67.12)
  BOTTOM w0.254: v4(101.28,66.32) PR1124.1
VSSIN_SENSE_R: length 7.7
  TOP w0.254: v2(121,52.9) v1(120.44,53.46) 120.11,53.79 119.54,53.79 119.19,54.14 RC684.1
  IN1 w0.254: v2(121,52.9) 121.71,52.19 124.09,52.19 125.33,50.95 v4(125.33,50.88)
VSSIN_SENSE_VR: length 3
  BOTTOM w0.254: PU1100.7 99.5,63.06 100.12,63.67 100.7,63.67 101.28,64.25 PR1124.2
3.3_VCCST_OVERRIDE: length 2.6
  BOTTOM w0.069: QM1.6 180.38,52.01 RC617.2 180.05,50.56 UC7.2
32KHZ_OUT: length 8.8
  TOP w0.069: CE105.1 172.19,18.53 172.49,18.83 172.49,19.58 172.89,19.99 174.86,19.99 175.8,19.05 176.76,19.05 177.22,18.59 177.22,18.46 177.4,18.28 178.02,18.28 UE1.F3
+BATT:
  vias: v3(42.25,24.33) v3(42.38,23.82) v3(42.64,24.71) v3(42.76,24.2) v3(43.14,24.58) v3(43.27,25.21) v3(43.65,25.6) v3(43.78,24.71) v3(43.78,22.42) v3(43.85,23.82) v3(44.03,25.98) v3(44.16,25.09) v3(44.16,22.8) v3(44.16,22.04) v3(44.44,24.25) v3(44.54,25.47) v3(44.54,24.71) v3(44.54,23.18) v3(44.54,22.42) v3(44.54,21.66) v3(44.92,25.09) v3(44.92,24.33) v3(44.92,23.56) v3(44.92,22.8) v3(44.92,22.04) v3(44.92,21.28) v3(45.3,24.71) v3(45.3,23.94) v3(45.3,23.18) v3(45.3,22.42) v3(45.3,21.66) v3(45.3,20.9) v3(45.68,24.33) v3(45.68,23.56) v3(45.68,22.8) v3(45.68,22.04) v3(45.68,21.28) v3(46.06,23.94) v3(46.06,22.42) v3(46.06,21.66) v3(46.45,22.04) v3(48.73,19.25) v3(48.73,18.74) v3(48.73,18.23) v3(48.73,17.72) v3(49.24,19.25) v3(49.24,18.74) v3(49.24,18.23) v3(49.24,17.72) v3(49.75,19.25) v3(49.75,18.74) v3(49.75,18.23) v3(49.75,17.72) v3(50.26,19.25) v3(50.26,18.74) v3(50.26,18.23) v3(50.26,17.72) v3(50.76,19.25) v3(50.76,18.74) v3(50.76,18.23) v3(50.76,17.72) v3(51.27,19.25) v3(51.27,18.74) v3(51.27,18.23) v3(51.27,17.72) v3(51.78,19.25) v3(51.78,18.74) v3(51.78,18.23) v3(51.78,17.72) v4(42.91,23.41) v4(43.22,24.05) v4(43.3,23.03) v4(43.42,24.86) v4(43.68,25.19) v4(43.89,24.2) v4(43.85,23.31) v4(44.11,25.54) v4(44.16,22.42) v4(44.27,23.82) v4(44.54,25.11) v4(44.54,22.8) v4(44.54,22.04) v4(44.82,23.94) v4(44.92,24.71) v4(44.92,23.18) v4(44.92,22.42) v4(44.92,21.66) v4(45.3,23.56) v4(45.3,22.8) v4(45.3,22.04) v4(45.3,21.28) v4(45.68,23.92) v4(45.68,22.42) v4(45.68,21.66) v4(46.06,22.04) v4(48.48,18.99) v4(48.48,18.48) v4(48.48,17.98) v4(48.99,18.99) v4(48.99,18.48) v4(48.99,17.98) v4(49.49,18.99) v4(49.49,18.48) v4(49.49,17.98) v4(50,18.99) v4(50,18.48) v4(50,17.98) v4(50.51,18.99) v4(50.51,18.48) v4(50.51,17.98) v4(51.02,18.99) v4(51.02,18.48) v4(51.02,17.98) v4(51.53,18.99) v4(51.53,18.48) v4(51.53,17.98) v6(53,17.67) v6(54.7,16.6) v6(55.64,14.9)
+CAM_PWR:
  vias: v1(158.36,67.33) v5(155.76,64.54) v5(156.53,64.51) v5(157.09,64.51) v5(168.52,65.35) v5(169.08,65.35)
+CHG_SRC_20V:
  vias: v1(81.32,13.89)
+CHG_VIN_20V:
  vias: v2(40.15,3.29) v2(40.58,3.29) v2(263.62,33.72) v2(263.87,34.1) v2(263.87,33.34) v2(263.87,32.83) v2(264.12,33.72) v2(264.38,34.1) v2(264.63,33.72) v3(25.44,30.65) v3(26.23,30.62) v3(40.15,3.29) v3(40.58,3.29) v3(75.07,6.39) v3(75.58,6.39) v3(76.09,6.39) v3(76.59,6.39) v3(77.1,6.39) v3(77.61,6.39) v3(78.12,6.39) v3(78.63,6.39) v3(79.13,6.39) v3(79.64,6.39) v3(263.62,33.72) v3(263.87,34.1) v3(263.87,33.34) v3(263.87,32.83) v3(264.12,33.72) v3(264.38,34.1) v3(264.63,33.72) v4(25.78,30.52) v4(25.78,30.2) v4(75.07,6.39) v4(75.58,6.39) v4(76.09,6.39) v4(76.59,6.39) v4(77.1,6.39) v4(77.61,6.39) v4(78.12,6.39) v4(78.63,6.39) v4(79.13,6.39) v4(79.64,6.39) v5(25.72,31.18) v5(25.97,31.69) v5(26.29,31.18) v5(26.55,31.69) v5(26.89,31.21) v5(160.01,3.7) v5(160.6,4.31) v5(160.6,3.73) v5(161.16,4.34) v5(161.16,3.75) v6(26.33,30.57)
+EC_DEBUG_VCC: length 5.1
  BOTTOM w0.254: 237.63,13 237.73,13.09 238.15,13.09 238.61,13.55 JDEG1.1 ; 237.63,13 RE200.1 ; 237.63,13 235.52,13 235.22,12.69 v5(235.22,11.98)
+INV_PWR_SRC:
  vias: v2(109.08,66.44) v2(109.11,65.78) v3(95.72,72.5) v3(96.23,72.5) v3(109.08,66.44) v3(109.11,65.78) v4(96.66,72.48) v4(96.99,72.48) v4(109.08,66.44) v4(109.11,65.78) v5(118.34,62.05) v5(118.68,62.5) v5(137.5,65.73) v5(138.14,65.73) v6(115.99,58.46) v6(117.57,59.76) v6(118.84,61.18)
+INV_PWR_SRC_R: length 1.6
  BOTTOM w0.069: v1(97.82,71.4) 96.95,70.54 96.95,70.44 F3.2
+LCDVDD: length 5.2
  TOP w0.127: C46.1 134.25,64.38 134.48,64.15 134.48,63.82 v6(135.22,63.09) 135.22,63.01 134.96,62.76 v6(133.54,62.76) ; v6(131.66,67.28) 132.58,66.36 C41.1
  vias: v2(134.05,65.51) v2(134.53,65.51) v3(104.89,71.26) v3(105.35,71.26) v3(113.73,71.04) v3(113.74,70.4) v3(134.05,65.51) v3(134.53,65.51) v4(104.89,71.26) v4(105.35,71.26) v4(113.73,71.04) v4(113.74,70.4) v4(134.05,65.51) v4(134.53,65.51)
+LCDVDD_R: length 1
  BOTTOM w0.069: 104.46,72.71 104.43,72.74 104.43,73.47 v1(104.26,73.65)
+P_VCC: length 2.8
  TOP w0.508: v5(165.52,65.27) 165.52,64.81 165.95,64.38 F6.2
  BOTTOM w0.254: JUFC1.3 164.85,64.93 165.19,65.27 v5(165.52,65.27)
+P_VCC_R: length 1.4
  TOP w0.069: R6224.2 v1(168.49,61.65)
+PECI_VREF: length 8.5
  TOP w0.254: v2(185.87,15.79) 185.86,15.79 185.13,15.79 UE1.J11 ; v2(186.55,9.49) RE147.1
  IN1 w0.254: v2(186.55,9.49) 186.51,9.54 186.51,10.68 185.99,11.19 185.99,15.66 v2(185.87,15.79)
+RTC_CELL_VBAT: length 4.2
  TOP w0.254: C4245.1 178.35,25.87 RE106.2 178.35,25.04 v2(178.65,24.73)
  IN1 w0.508: v2(178.65,24.73) 178.65,24.45 177.53,23.33 v2(177.53,22.59)
+RTCVCC: length 50.1
  TOP w0.254: RH64.2 170.16,36.89 171.69,38.42 171.69,38.45 172.48,39.24 v1(173.37,39.24) 174.43,39.24 174.44,39.24
  TOP w0.508: RC696.2 175.16,42.53 174.44,41.8 174.44,39.24 175.2,38.48 175.2,34.26 176.9,32.55 180.59,32.55 183.41,35.37 186.58,35.37 v2(186.95,35)
  IN1 w0.508: v2(186.95,35) 187.59,34.36 189.41,34.36 189.64,34.14 189.64,33.56 191.45,31.74 191.45,30.93 192.11,30.27 193.38,30.27 v4(194.91,28.75)
  BOTTOM w0.254: Q349.1 198.92,28.03 199.78,27.17 199.78,24.35 R5768.1
  BOTTOM w0.508: C1040.1 196.22,28.48 196.66,28.03 Q349.1 ; C1040.1 R2751.1 ; C1040.1 195.49,28.43 195.23,28.43 v4(194.91,28.75)
+RTCVCC_R: length 253.2
  TOP w0.254: v5(173.33,33.72) 172.47,32.86 v1(170.91,32.86) 170.7,32.86 RH573.1 ; RE244.2 RE137.2 RE142.2 179.81,25.3 179.74,25.37 v3(179.21,25.37)
  IN1 w0.254: v4(171.51,21.1) 171.51,20.99 171.47,20.95 171.47,20.71 v2(171.49,20.69)
  IN1 w0.508: v3(103.46,23.58) 106.62,26.74 v3(106.64,26.74) ; v3(14.21,33.72) 14.21,35.09 10.33,38.97 10.07,38.97 8.41,40.63 v4(4.99,40.63)
  IN2 w0.508: 174.86,24.98 175.25,25.37 v3(179.21,25.37) 179.39,25.19 179.39,23.51 179.8,23.11 180.63,23.11 181.57,22.17 v4(185.46,22.17) ; 174.86,24.98 174.8,24.98 174.44,25.34 174.44,25.66 173.86,26.23 172.38,26.23 171.84,26.76 170.38,26.76 169.56,27.58 163.54,27.58 162.04,29.08 115.09,29.08 113.56,27.55 110.32,27.55 109.94,27.17 107.07,27.17 v3(106.64,26.74) ; 174.86,24.98 174.86,23.1 174.49,22.73 174.49,22.49 174.39,22.4 v4(174.29,22.4) ; v3(33.82,20.34) 34.23,19.93 36.31,19.93 37.94,18.31 39.76,18.31 43.77,14.29 67.9,14.29 68.18,14.57 74.18,14.57 88.66,29.05 91.1,29.05 95.65,24.5 99.62,24.5 100.55,23.58 v3(103.46,23.58)
  IN3 w0.254: v3(179.21,25.37) 178.88,25.37 177.92,26.33 v4(177.92,27.2)
  IN3 w0.508: v3(33.82,20.34) 33.82,20.61 29.83,24.6 29.83,25.39 28.74,26.48 26.51,26.48 26.18,26.81 21.68,26.81 18.53,29.96 18.53,30.88 15.69,33.72 v3(14.21,33.72) ; v4(190.67,23.31) 190.67,23.81 v4(193.57,26.71)
  BOTTOM w0.254: v4(174.29,22.4) 174.29,21.79 174.21,21.71 172.23,21.71 171.62,21.1 v4(171.51,21.1) ; v5(173.33,33.72) 173.33,33.7 173.36,33.67 173.62,33.67 174.33,32.96 RH572.1 174.72,32.83 175.55,32 175.79,32 176.33,31.46 177.06,31.46 177.38,31.14 177.38,27.6 177.79,27.2 v4(177.92,27.2)
  BOTTOM w0.508: RTCD3.1 5.88,42.59 5.86,42.56 5.79,42.56 C112.1 5.06,40.69 v4(4.99,40.63) RTCD5.1 RTCD2.1 ; v4(185.46,22.17) 186.6,23.31 v4(190.67,23.31) ; v4(193.57,26.71) 193.57,26.68 193.64,26.61 195.11,26.61 195.29,26.79 R2751.2 196.38,25.95 Q349.3
+SD_VDD1: length 3.5
  TOP w0.069: 19.19,46.17 v1(20.71,46.17)
  BOTTOM w0.508: CR25.2 18.23,55.79 JP1.4
  vias: v2(11.44,45.13) v2(11.44,44.72) v2(18.25,55.44) v2(18.25,55.19) v2(18.51,55.44) v2(18.51,55.19) v2(18.53,54.5) v3(11.44,45.13) v3(11.44,44.72) v3(18.3,55.77) v3(18.28,54.75) v4(11.9,45.1) v4(11.9,44.85) v4(11.9,44.59) v4(18.3,55.77) v4(18.28,54.75)
+SD_VDD2: length 13.8
  IN3 w0.762: 12.92,45.53 12.97,45.59 12.97,46.55 12.54,46.98 8.75,46.98 8.01,46.25 6.82,46.25 6.8,46.22 v4(6.21,46.22)
  BOTTOM w0.127: v1(7.3,45.97) 7.05,46.22 v4(6.21,46.22)
  BOTTOM w0.381: JP1.10 3.3,47.02
  BOTTOM w0.762: 3.3,47.02 4.1,46.22 CR24.1 v4(6.21,46.22)
  vias: v4(12.36,44.98) v4(12.36,44.67)
+TBT_L_SVR_IND:
  vias: v1(24.25,52.6)
+TBT_R_SVR_IND:
  vias: v1(264.15,49.55)
+TBT_VBUS_L: length 7.8
  TOP w0.127: v6(14.49,65.35) 13.17,66.67 v6(12.82,66.67) 11.34,66.67 v5(11.01,66.34) ; v6(11.47,64.94) 11.47,65.24 v5(11.01,65.7)
  TOP w0.254: v5(8.88,75.3) 9.01,75.3 9.25,75.54 CT312.2 CT313.2 ; CT310.2 9.42,78.02 8.95,78.02 v5(8.85,78.12)
  TOP w0.356: CT310.2 10.07,77.96 CT311.2
  vias: v3(8.35,77.18) v3(8.35,76.55) v3(8.35,75.94) v3(9.34,75.58) v3(9.39,78.1) v3(9.84,75.58) v3(9.89,78.1) v3(19.62,42.51) v3(19.62,42) v3(19.62,41.5) v3(19.62,40.99) v3(20,42.26) v3(20,41.75) v3(20,41.24) v3(27.27,24.83) v3(27.27,24.33) v3(27.27,23.82) v3(27.27,23.31) v3(28.03,24.83) v3(28.03,23.82) v3(28.03,23.31) v3(28.06,25.39) v4(9.34,75.58) v4(9.39,78.1) v4(9.84,75.58) v4(9.89,78.1) v4(27.27,24.83) v4(27.27,24.33) v4(27.27,23.82) v4(27.27,23.31) v4(28.03,24.83) v4(28.03,23.82) v4(28.03,23.31) v4(28.06,25.39) v5(10.38,66.34) v5(10.38,65.7)
+TBT_VBUS_L_PD:
  vias: v1(30.19,30.24) v3(23.98,32.82) v3(23.98,32.31) v3(24.37,33.06) v3(24.37,32.55) v3(24.37,32.05) v3(24.55,33.6) v3(25.48,32.93) v3(29.22,32.04) v3(29.22,31.47) v3(29.22,30.96) v3(29.67,31.72) v3(29.67,31.22) v3(29.67,30.71) v3(30.17,31.79) v4(24.6,31.37) v4(24.77,33.04) v4(24.77,32.73) v4(24.77,32.41) v4(24.77,32.09) v4(24.9,31.37) v4(25.09,33.04) v4(25.09,32.73) v4(25.09,32.41) v4(30.04,31.39) v4(30.04,31.08) v4(30.04,30.76) v4(30.36,31.39) v4(30.36,31.08) v4(30.36,30.76) v4(30.67,31.08) v4(30.67,30.76)
+TBT_VBUS_R:
  vias: v2(266.41,23.06) v2(266.66,23.44) v2(266.66,22.67) v2(266.92,23.06) v2(267.17,23.44) v2(267.17,22.67) v2(267.4,23.06) v3(266.41,23.06) v3(266.66,23.44) v3(266.66,22.67) v3(266.92,23.06) v3(267.17,23.44) v3(267.17,22.67) v3(267.4,23.06) v3(284.62,65.96) v3(284.62,65.42) v5(281.45,58.97) v5(281.45,58.34) v5(281.62,66.85) v5(281.8,63.8) v5(282.03,66.41) v5(282,58.97) v5(282,58.34) v5(282.11,64.28) v5(284.04,66.82) v5(284.06,64.36) v6(261.51,23.49) v6(263.26,23.92) v6(264.1,22.27)
+TBT_VBUS_R_PD:
  vias: v1(260.21,32.45) v2(259.73,33.42) v2(259.73,33.1) v2(260.05,33.74) v2(260.05,33.42) v2(260.05,33.1) v2(260.36,33.74) v2(260.36,33.42) v2(260.36,33.1) v2(265.32,35.39) v2(265.32,35.07) v2(265.32,34.75) v2(265.5,33.71) v2(265.63,35.39) v2(265.63,35.07) v2(265.63,34.75) v2(265.63,34.44) v2(265.8,33.71) v3(260.74,34.61) v3(260.74,34.07) v3(260.74,33.56) v3(260.74,33.05) v3(261.18,34.38) v3(261.18,33.81) v3(261.18,33.3) v3(263.41,35.1) v3(263.92,35.1) v3(264.4,35.2) v3(264.43,34.74) v3(264.93,35.2) v3(264.91,34.69) v3(265.16,34.31)
+UA2_VBAT: length 0.8
  TOP w0.069: v1(27.33,29.31) 27.19,29.18 27.19,28.59
+UA3_VBAT:
  vias: v1(271.03,34.28)
+VNN_BYPASS: length 0.7
  IN1 w0.254: v3(160.94,42.6) 161.2,42.35 v2(161.2,42.34)
  IN3 w0.254: v3(160.94,42.6) 160.95,42.6 v4(161.21,42.86)
+VR_CAP: length 16.2
  TOP w0.254: UE1.J1 176.48,15.94 v2(174.5,15.94)
  IN1 w0.254: v3(183.93,21.35) v2(183.93,20.99) ; v2(174.5,15.94) 175.41,16.86 v3(175.41,18.79)
  IN3 w0.254: v3(175.41,18.79) 175.41,19.26 176.42,20.26 180.03,20.26 180.56,19.73 181.7,19.73 182.57,20.6 183.18,20.6 v3(183.93,21.35)
A#: length 4.1
  TOP w0.069: PU600.1 109.96,3.34 PR607.2 PR606.2 v1(109.87,5.15)
AC_DIS: length 168.7
  TOP w0.069: v2(32.84,3.31) 33.5,3.31 33.76,3.05 PR223.1
  IN1 w0.061: v3(185.53,16.57) v2(185.53,16.99) ; v2(32.84,3.31) 32.84,3.46 32.02,4.28 31.61,4.28 31.38,4.51 31.38,5.48 31.79,5.89 v3(31.79,6.75)
  IN2 w0.051: v3(31.79,6.75) 31.79,6.8 32.09,7.1 34.89,7.1 35.27,7.49 37.36,7.49 38.61,6.24 39.79,6.24 40.07,6.52 40.07,6.94 41.34,8.21 41.69,8.21 41.83,8.35 62.7,8.35 63.16,7.89 63.97,7.89 64.61,8.53 68.2,8.53 68.84,7.89 73.68,7.89 74.24,8.45 80.55,8.45 81.06,7.94 93.57,7.94 94.89,6.62 104.34,6.62 107.32,9.59 123.01,9.59 123.06,9.64 136.19,9.64 136.7,10.15 140.78,10.15 141.06,9.87 165.81,9.87 168.2,12.26 171.05,12.26 171.76,12.97 176.26,12.97 176.72,13.43 180.61,13.43 180.96,13.07 182.83,13.07 183.56,13.81 183.62,13.81 185.53,15.72 v3(185.53,16.57)
AC_DISC#: length 90.6
  IN1 w0.061: v3(107.53,8.96) 106.61,8.96 106.38,9.18 105.3,9.18 v2(104.36,10.13) ; v2(186.33,19.39) v3(186.33,19.74)
  IN2 w0.051: v3(186.33,19.74) 186.2,19.61 186.2,19.02 186.38,18.83 186.38,17.24 186.01,16.88 186.01,14.84 184.68,13.51 183.69,13.51 182.95,12.77 180.84,12.77 180.48,13.12 176.85,13.12 176.39,12.67 171.89,12.67 171.15,11.93 168.3,11.93 165.94,9.57 140.93,9.57 140.65,9.85 136.82,9.85 136.31,9.34 123.19,9.34 123.14,9.29 107.86,9.29 v3(107.53,8.96)
AC_PRESENT: length 33.6
  TOP w0.069: v3(182.41,15.77) 182.41,15.47 UE1.K8
  IN1 w0.061: v3(168.82,26.89) 168.82,27.09 167.17,28.75 164.71,28.75 164.38,29.08 v4(164.38,31.51)
  IN2 w0.051: v3(182.41,15.77) 182.41,17.27 181.09,18.59 177.9,18.59 177.14,19.35 173.65,19.35 173.49,19.19 171.62,19.19 170.91,19.9 170.91,24.41 168.82,26.49 v3(168.82,26.89)
  BOTTOM w0.069: v4(164.38,31.51) v1(164.09,31.81) 163.96,31.93 162.87,31.93 162.36,32.44 RH297.1 RH312.2
AC_PRESENT_R: length 4.5
  BOTTOM w0.069: UC1.DE46 163.48,36.71 163.01,36.24 162.75,36.24 162.52,36.01 162.52,34.89 162.12,34.49 162.12,33.62 161.79,33.29 RH312.1
ACAV_IN: length 224.2
  TOP w0.069: UE1.C7 181.95,20.57 182.51,20.57 v2(182.56,20.62) ; PR219.2 30.19,5.58 v1(30.19,6.16)
  TOP w0.203: PR225.1 30.06,1.93 PQ205.1 30.14,2.63 31.24,3.73 31.24,3.73 31.57,4.06 PR220.1 31.44,4.4 31.32,4.4 30.6,5.12 PR219.2 31.06,5.64 v3(31.06,5.74)
  IN1 w0.061: v3(182.75,20.17) 182.72,20.21 182.72,20.46 v2(182.56,20.62)
  IN2 w0.051: v3(190.73,12.16) 190.51,12.39 186.51,12.39 184.46,10.33 179.98,10.33 179.14,9.49 177.71,9.49 176.63,8.41 174.34,8.41 174.19,8.56 171,8.56 169.95,7.51 115.2,7.51 114.52,6.84 108.93,6.84 108,5.91 105.17,5.91 104.97,5.71 94.51,5.71 93.19,7.03 80.68,7.03 80.17,7.54 74.62,7.54 74.06,6.98 62.78,6.98 62.32,7.44 42.21,7.44 40.99,6.21 40.99,6.14 40.17,5.33 39.03,5.33 38.42,4.72 36.36,4.72 35.83,5.25 33.81,5.25 33.33,4.77 32.13,4.77 31.67,5.22 31.58,5.22 v3(31.06,5.74)
  IN3 w0.061: v4(222.15,10.44) 221.85,10.14 216.8,10.14 216.41,10.54 196.85,10.54 196.38,10.08 193.58,10.08 193.21,10.45 192.22,10.45 190.73,11.94 v3(190.73,12.16) 190.49,12.16 189.3,13.35 188.4,13.35 187.06,14.69 187.06,17.16 186.55,17.67 186.55,18.4 185.47,19.48 185.47,19.94 185,20.41 184.41,20.41 184.12,20.12 182.81,20.12 v3(182.75,20.17)
  BOTTOM w0.069: D481.1 222.59,13.18 222.59,11.93 222.34,11.68 222.34,10.63 v4(222.15,10.44)
ACC1_INT2#: length 88.3
  IN2 w0.051: v4(183.45,43.4) 183.45,42.51 184.34,41.62 184.34,41.15 185.17,40.32 185.17,38.8 186.51,37.46 186.51,36.31 186.76,36.06 188.57,36.06 189.28,35.35 191.57,35.35 192.03,35.81 193.1,35.81 194.65,34.26 194.65,33.7 197.47,30.88 197.47,30 200.27,27.21 200.27,24.1 206.69,17.67 211.53,17.67 212.14,17.06 222.8,17.06 v4(223.18,16.68)
  IN3 w0.061: v4(168.09,44.04) 168.12,44 168.82,44 169.07,43.76 173.55,43.76 173.7,43.91 176.89,43.91 177.01,44.02 177.74,44.02 177.97,44.24 181.78,44.24 182.07,43.95 182.9,43.95 v4(183.45,43.4)
  BOTTOM w0.069: UC1.DW36 170.81,42.1 170.52,42.38 169.13,42.38 168.9,42.61 168.9,42.62 168.34,43.18 168.34,43.78 v4(168.09,44.04) ; JIO1.21 221.15,9.85 221.76,10.46 221.76,11.4 222.42,12.07 222.42,14.15 223.61,15.33 223.61,15.79 223.18,16.22 v4(223.18,16.68) ; v1(183.45,44.26) v4(183.45,43.4) 183.45,43.38 183.22,43.14 183.22,43.14 183.14,43.06 183.14,43.06 183.07,42.99 183.07,42.99 182.97,42.89 182.49,42.89 RC742.1
ADCIN1_L_PD: length 5.4
  BOTTOM w0.069: UPD1.6 v1(28.61,31.62) 28.61,29.45 27.82,28.66 RPD91.1 RPD92.2
ADCIN1_R_PD: length 4.3
  TOP w0.069: UPD2.6 261.8,31.52 RPD101.1 261.95,31.36 RPD102.2
ADCIN2_L_PD: length 8.5
  TOP w0.069: v2(22.85,30.83) 22.84,30.84 RPD100.1 22.84,31.89 v1(23.18,32.22)
  IN1 w0.061: v2(22.85,30.83) 23.08,30.6 v3(23.33,30.6)
  IN3 w0.061: v4(22.85,31.28) 22.85,31.08 v3(23.33,30.6) 23.74,31.01 25.03,31.01 25.24,31.21 25.24,31.77 25.73,32.26 26.77,32.26 v4(27.01,32.03)
  BOTTOM w0.069: UPD1.10 v4(27.01,32.03)
ADCIN2_R_PD: length 8.4
  TOP w0.069: v2(265.29,32.3) 265.32,32.28 265.98,32.28 v1(266.38,31.87) 266.44,31.87 RPD89.1 RPD99.2
  TOP w0.081: UPD2.10 v2(263.4,34.37)
  IN1 w0.061: v2(265.29,32.3) 263.41,32.3 263.11,32.61 263.11,33.88 263.4,34.16 v2(263.4,34.37)
ALLSYS_PWRGD: length 101
  TOP w0.069: D475.2 D474.2 ; D474.2 174.41,10.2 173.85,10.2 D438.2 173.03,10.71 172.74,10.41 RE464.1 ; D474.2 175.18,9.5 175.84,10.16 RE448.2 175.6,10.6 v3(175.6,10.94) 175.6,11.24 175.13,11.72 RE1.1 ; v1(172.51,9.54) 172.42,9.63 RE464.1 ; D487.2 171.48,11.36 RE464.1
  IN2 w0.051: v3(248.91,17.09) 248.91,15.07 246.99,13.16 244.8,13.16 241.31,9.67 234.12,9.67 233.81,9.36 228.58,9.36 227.77,8.55 222.82,8.55 222.61,8.34 216.27,8.34 215.79,8.82 210.82,8.82 210.31,8.3 205.56,8.3 204.48,9.39 201.31,9.39 198.64,12.06 195.59,12.06 194.94,12.71 192.88,12.71 192.14,13.45 186.07,13.45 184.37,11.75 176.93,11.75 176.11,10.94 v3(175.6,10.94)
  IN3 w0.061: v3(248.91,17.09) 248.91,17.61 251.94,20.64 252.66,20.64 253.68,21.66 v4(253.68,21.68)
  BOTTOM w0.069: v4(253.68,21.68) 252.94,22.43 LED1.1
ALLSYS_PWRGD_R: length 38.5
  TOP w0.069: v1(170.5,12.41) 170.68,12.59 172.2,12.59 172.51,12.29 v5(172.51,11.75) 172.51,11.08 RE464.2
  BOTTOM w0.069: 155.87,31.84 154.78,31.84 154.66,31.73 QE18.6 ; 155.87,31.84 155.87,31.67 155.39,31.18 155.39,29.18 160.24,24.33 170.24,24.33 171,23.57 171,19.72 171.64,19.08 171.64,15.21 172.51,14.34 v5(172.51,11.75) ; 155.87,31.84 RE93.1
ALS_ALERT#: length 18.5
  TOP w0.069: v4(159.73,61.49) 159.73,61.03 163.01,57.75 v1(163.01,57.37) 163.01,56.63 163.59,56.05 v3(163.59,56.02)
  IN2 w0.051: v3(163.59,56.02) 164.07,56.02 165.12,54.98 168.34,54.98 168.65,55.29 168.65,55.52 168.86,55.74 169.23,55.74 170.38,54.59 170.38,53.41 v4(169.51,52.55)
  BOTTOM w0.069: R6118.1 159.47,61.08 159.73,61.33 v4(159.73,61.49)
ALS_ALERT#_R: length 4.9
  TOP w0.069: TP138.1 157.52,63.82 v3(158.08,64.38)
  IN3 w0.061: v3(158.08,64.38) 159.2,64.38 v4(159.25,64.33)
  BOTTOM w0.069: v4(159.25,64.33) 159.25,64.1 159.37,63.97 159.37,62.83 159.09,62.55 R6118.2
ALW_PWRGD_3V_5V: length 174.9
  TOP w0.069: v5(105.07,67.28) 105.12,67.28 105.14,67.3 105.24,67.3 106.17,66.37 108.06,66.37 108.17,66.26 108.17,65.22 108.57,64.81 108.57,61.13 112.1,57.61 112.1,55.56 112.29,55.36 113.15,55.36 v3(113.45,55.67) ; D438.1 175.05,10.91 174.64,11.32 v2(172.96,11.32)
  IN1 w0.061: v2(172.96,11.32) 172.96,11.42 173.17,11.63 173.17,11.95 173.71,12.5 174.11,12.5 175.32,13.71 175.32,15.63 176.14,16.45 176.14,23.06 176.05,23.15 176.05,24.14 176.11,24.2 176.11,24.99 175.78,25.32 175.78,26.66 v3(175.5,26.94)
  IN2 w0.051: v3(113.45,55.67) 112.1,54.32 108.7,54.32 107.58,55.44 101.56,55.44 99.48,53.36 97.65,53.36 92.09,47.8 92.09,33.43 95.99,29.53 99.53,29.53 100.8,28.26 109.49,28.26 109.87,28.64 112.59,28.64 114.39,30.45 162.65,30.45 164.43,28.67 170.54,28.67 170.97,28.24 172,28.24 172.38,27.86 173.78,27.86 174.39,27.25 175.2,27.25 v3(175.5,26.94)
  IN3 w0.061: v3(175.5,26.94) 176.19,27.63 v4(176.61,27.63)
  BOTTOM w0.069: UC2.2 105.46,67.09 105.3,67.25 105.09,67.25 v5(105.07,67.28) 105.04,67.25 104.69,67.25 104.48,67.05 103.21,67.05 102.99,66.82 v1(102.66,66.82) 102.52,66.95 RC704.2 R6204.1 RC702.2 RC703.2 ; v4(176.61,27.63) 176.62,27.64 DC2.1
ALWON: length 305.5
  TOP w0.069: v2(167.25,8.25) 167.07,8.25 166.26,7.43 165.29,7.43 164.81,6.95 164.81,5.02 v1(164.61,4.82) 164.47,4.68 RE312.1 164.66,3.61 RE305.1 ; RE417.1 272.66,15.31 272.51,15.16 v2(269.58,15.16)
  IN1 w0.061: v3(167.98,8.18) 167.91,8.25 v2(167.25,8.25) ; v3(245.41,11.02) 245.72,10.71 247.58,10.71 247.68,10.8 256.64,10.8 257.24,11.41 257.24,12.29 257.57,12.62 257.57,13.84 258.24,14.5 258.58,14.5 259.47,13.61 261.35,13.61 262.62,14.88 263.06,14.88 263.79,15.61 264.43,15.61 264.89,15.16 v2(269.58,15.16) ; v2(179.93,22.59) 179.71,22.37 v3(179.59,22.37)
  IN2 w0.051: v3(30.93,20.16) 32.37,18.71 32.37,15.77 31.28,14.67 31.28,11.99 30.67,11.39 30.67,7.03 31.66,6.04 35.28,6.04 35.64,6.39 37.7,6.39 38.3,5.78 39.98,5.78 40.53,6.33 40.53,6.75 41.53,7.75 41.88,7.75 42.02,7.9 62.51,7.9 62.97,7.43 73.87,7.43 74.43,7.99 80.36,7.99 80.87,7.49 93.38,7.49 94.7,6.16 104.78,6.16 104.98,6.37 107.81,6.37 108.8,7.36 111.67,7.36 112.28,7.97 167.78,7.97 167.98,8.17 v3(167.98,8.18) 168.05,8.25 169.86,8.25 171.18,9.57 175.95,9.57 177.53,11.14 184.62,11.14 186.32,12.84 191.45,12.84 192.78,11.51 v3(193.05,11.51)
  IN3 w0.061: v3(179.59,22.37) 179.74,22.52 180.81,22.52 180.99,22.34 184.71,22.34 185.77,21.27 186.69,21.27 187.7,20.26 187.7,18.04 188.36,17.38 188.36,16.3 193.05,11.61 v3(193.05,11.51) 193.13,11.44 193.93,11.44 194.2,11.71 194.86,11.71 195.22,11.35 212.87,11.35 213.85,12.33 220.16,12.33 220.68,12.85 236.36,12.85 236.93,13.41 243.79,13.41 244.72,12.49 244.72,11.62 245.32,11.02 v3(245.41,11.02) ; v4(29.55,21.68) 29.55,20.74 30.29,20.01 30.77,20.01 v3(30.93,20.16)
  BOTTOM w0.069: v4(29.55,21.68) 28.51,21.68 28.16,22.04 27.4,22.04 RE405.1
ALWON_3VALW: length 155.8
  TOP w0.069: v2(163.23,4.46) 163.23,2.72 CE312.1 v2(164.66,2.18)
  IN1 w0.061: v3(102.99,9.21) 102.68,9.52 100.5,9.52 96.74,13.28 96.74,19.8 97.09,20.16 v2(97.35,20.16) ; v5(209.89,2.05) 208.73,3.22 200.29,3.22 200.12,3.04 199.17,3.04 198.63,3.58 197.08,3.58 196.08,2.58 172.71,2.58 172.19,3.11 172.19,4.1 171.95,4.34 171.44,4.34 170.49,3.39 165.87,3.39 v2(164.66,2.18) ; v2(163.23,4.46) 163.21,4.46 162.56,5.11 159.65,5.11 157.75,7.02 146.62,7.02 145.99,6.39 130.02,6.39 128.42,4.79 126.33,4.79 125.77,5.35 121.91,5.35 121.53,4.97 119.99,4.97 118.85,3.84 113.86,3.84 113.43,3.4 107.61,3.4 v2(107.09,3.92) 106.9,4.11 v3(106.9,4.9)
  IN3 w0.061: v3(106.9,4.9) 104.76,7.03 104.76,7.61 103.16,9.21 v3(102.99,9.21)
  BOTTOM w0.069: PR302.1 219.75,17.29 219.88,17.16 219.88,15.49 219.17,14.78 216.99,14.78 216.73,14.52 216.73,13.73 213.54,10.54 213.54,3.93 212.45,2.84 211.28,2.84 210.49,2.05 v5(209.89,2.05)
ALWON_5VALW: length 88.6
  TOP w0.203: v5(28.36,17.21) 28.74,16.83 28.74,12.11 29.96,10.89 31.97,10.89 32.32,10.53 32.32,10.3 34.18,8.45 34.18,7.66 34.63,7.21 35.67,7.21 36.28,6.6 61.58,6.6 62.19,5.99 91.61,5.99 95.04,9.42 95.04,10.15 97.35,12.46 PJTAG2.2
  BOTTOM w0.069: 26.91,20.64 26.84,20.64 v1(25.87,21.61)
  BOTTOM w0.203: PU400.15 27.73,16.28 28.36,16.91 v5(28.36,17.21) 28.23,17.34 28.23,20.18 CE413.1 26.91,20.64 RE405.2
ALWON_5VALWB: length 4.4
  TOP w0.069: v4(274.23,16.22) v1(273.14,16.22)
  BOTTOM w0.069: v4(274.23,16.22) 273.75,16.71 273.75,18.05 273.08,18.72 PU401.15
AMP_I2C_CLK: length 348.6
  TOP w0.069: v3(260.92,57.83) 260.81,57.94 UA1.7 ; UA2.23 24.52,22.85 v3(24.22,22.55) ; v5(272.57,31.3) 272.57,31.3 271.94,31.93 UA3.23 271.94,33.56 272.6,34.22 273.41,34.22 274.05,34.87 274.72,34.87 274.74,34.89 RA71.2
  IN2 w0.051: v3(276.57,54.55) 275.98,55.14 275.98,56.79 273.98,58.79 261.88,58.79 v3(260.92,57.83)
  IN3 w0.061: v3(276.57,54.55) 278.09,53.03 278.09,36.46 v4(277.51,35.88) ; v5(272.57,31.3) 271.68,31.3 268.09,27.7 266.08,27.7 266,27.63 266,27.04 265.93,26.97 265.83,26.97 265.76,27.04 265.76,27.76 265.69,27.83 265.59,27.83 265.52,27.76 265.52,27.01 265.45,26.94 265.34,26.94 265.27,27.01 265.27,27.73 265.2,27.81 265.1,27.81 265.03,27.73 265.03,26.99 264.96,26.92 264.86,26.92 264.79,26.99 264.79,27.78 264.71,27.86 264.61,27.86 264.54,27.78 264.54,26.96 264.47,26.89 264.37,26.89 264.3,26.96 264.3,27.71 264.23,27.78 264.12,27.78 264.05,27.71 264.05,27.01 263.98,26.94 263.88,26.94 263.81,27.01 263.81,27.63 263.74,27.7 263.18,27.7 259.04,23.56 256.53,23.56 256.42,23.45 255.61,23.45 255.26,23.11 255.26,22.6 255.49,22.36 255.49,21.16 255.28,20.95 254.07,20.95 253.64,20.52 253.35,20.52 252.45,19.62 251.67,19.62 249.91,17.86 249.91,17.1 249.18,16.37 248.02,16.37 247.06,15.4 247.06,14.77 247.51,14.32 247.51,10.99 246.62,10.09 246.62,9.13 245.91,8.43 244.06,8.43 243.64,8.01 243.08,8.01 240.02,4.95 199.21,4.95 198.14,3.87 197.61,3.87 196.8,3.07 v4(193.05,3.07) 181.69,3.07 180.1,4.65 174.6,4.65 171.94,7.31 167.54,7.31 167.31,7.54 151.92,7.54 151.44,7.06 129.81,7.06 127.58,4.83 122.58,4.83 122.11,4.36 114.52,4.36 113.18,3.01 97.39,3.01 93.45,6.95 81.44,6.95 80.93,7.46 74.49,7.46 74.15,7.12 58.18,7.12 57.62,7.69 41.89,7.69 40.98,8.6 38.64,8.6 38.23,9 35.17,9 34.85,9.31 33.24,9.31 32.78,9.77 32.21,9.77 31.44,10.53 31.44,15.46 31.6,15.62 31.6,17.11 31.24,17.47 31.24,18.5 27.81,21.94 25.47,21.94 24.86,22.55 v3(24.22,22.55)
  BOTTOM w0.069: v4(193.05,3.07) 193.05,4.47 192.36,5.17 192.36,5.9 v1(192.52,6.06) 192.52,6.47 192.37,6.62 Q352.1 ; v5(272.57,31.3) 272.56,31.31 272.56,32.07 272.73,32.25 273.75,32.25 277.39,35.88 v4(277.51,35.88)
AMP_I2C_DAT: length 352.7
  TOP w0.069: v3(24.7,22.19) 24.78,22.19 25.04,22.45 UA2.22 ; v2(272.94,31.79) 272.91,31.79 272.34,32.37 UA3.22 272.34,33.48 272.71,33.85 273.57,33.85 274.05,34.33 274.99,34.33 RA72.2 ; UA1.6 260.41,57.85 v3(260.36,57.8)
  IN1 w0.061: v2(272.94,31.79) 273.01,31.87 273.27,31.87 v3(273.62,32.22)
  IN2 w0.051: v3(260.36,57.8) 261.65,59.09 274.11,59.09 276.57,56.63 v3(276.57,55.19)
  IN3 w0.061: v3(276.57,55.19) 278.5,53.26 278.5,36.29 v4(277.48,35.27) ; v3(273.62,32.22) v4(273.62,31.54) 273.62,31.43 272.84,30.65 272.46,30.65 271.77,29.96 271.77,26.85 272.21,26.4 272.21,18.36 268.6,14.76 268.6,6.47 265.25,3.12 260.12,3.12 258.94,4.3 250.77,4.3 249.89,3.41 235.58,3.41 234.41,4.58 199.37,4.58 198.28,3.5 197.75,3.5 196.95,2.7 192.71,2.7 v4(192.7,2.71) 192.69,2.7 181.54,2.7 179.95,4.29 174.45,4.29 172.28,6.45 167.88,6.45 167.15,7.18 152.07,7.18 151.57,6.67 149.32,6.67 148.88,6.24 148.52,6.24 148.08,6.67 129.94,6.67 127.73,4.47 122.8,4.47 122.32,3.99 114.67,3.99 113.33,2.65 97.24,2.65 93.3,6.59 81.29,6.59 80.78,7.09 74.64,7.09 74.3,6.76 58.03,6.76 57.47,7.32 41.74,7.32 40.83,8.23 38.48,8.23 38.08,8.63 34.92,8.63 34.85,8.56 33.47,8.56 32.63,9.41 32.05,9.41 31.08,10.38 31.08,15.61 31.24,15.77 31.24,16.95 30.87,17.32 30.87,18.35 27.66,21.57 25.13,21.57 24.7,22 v3(24.7,22.19)
  BOTTOM w0.069: Q352.4 191.67,7.93 191.58,7.84 191.48,7.84 191.39,7.76 191.39,5.6 192.67,4.32 192.67,2.74 v4(192.7,2.71) ; v4(277.48,35.27) 277.31,35.27 v1(276.95,34.92) 273.62,31.59 v4(273.62,31.54)
AMP_I2S_BCLK: length 2
  TOP w0.069: UA1.10 262.01,58.06 262.19,57.88 262.35,57.88 262.5,57.73 262.73,57.73 RA76.1
AMP_I2S_BCLK_R: length 347.4
  TOP w0.069: UA3.13 272.85,29.19 273.9,28.14 v3(273.9,28.11) ; v2(263.23,55.95) RA76.2
  IN1 w0.061: v2(263.23,55.95) 263.67,56.38 264.48,56.38 265.01,55.85 265.01,55.57 265.37,55.21 271.74,55.21 274.05,52.9 276.44,52.9 276.52,52.82 278.88,52.82 v3(279.34,52.37)
  IN3 w0.061: v3(279.34,52.37) 278.87,51.89 278.87,34.75 273.9,29.79 v3(273.9,28.11) 273.57,27.78 273.57,17.8 269.97,14.19 269.97,5.89 265.82,1.74 258.33,1.74 257.67,2.41 253.49,2.41 253.13,2.05 235.01,2.05 233.85,3.22 214.01,3.22 213.23,2.44 209.57,2.44 208.79,3.22 200.17,3.22 198.29,1.34 180.97,1.34 179.39,2.93 169.48,2.93 166.59,5.82 152.64,5.82 152.13,5.31 149.88,5.31 149.44,4.87 147.95,4.87 147.58,5.25 130.44,5.25 128.3,3.11 126.2,3.11 124.38,1.29 96.59,1.29 92.68,5.2 42.61,5.2 41.31,3.9 41.31,2.96 39.69,1.34 32.48,1.34 30.27,3.55 30.27,6.26 29.66,6.87 29.66,12.01 29.69,12.04 29.69,12.84 29.35,13.17 29.35,17.78 26.92,20.21 23.41,20.21 22.27,21.35 22.27,21.89 v3(22.32,21.94)
AMP_I2S_IN: length 4.4
  TOP w0.069: UA1.8 261.21,57.34 CA116.1 RA78.1 261.51,55.49 v1(261.51,54.55)
AMP_I2S_IN_R: length 351.2
  TOP w0.069: UA2.12 21.53,22.34 v3(21.46,22.41) ; v2(272.71,30.27) 272.45,30.01 UA3.12 ; v3(261.96,55.36) v1(262.8,54.53)
  IN1 w0.061: v3(272.86,29.54) 272.86,30.12 v2(272.71,30.27)
  IN2 w0.051: v3(276.57,53.92) 275.6,54.88 275.6,56.46 273.85,58.21 266.59,58.21 266.15,57.78 263.85,57.78 261.96,55.89 v3(261.96,55.36)
  IN3 w0.061: v3(21.46,22.41) 21.55,22.32 22.49,22.32 22.77,22.04 22.77,21.38 23.58,20.58 27.07,20.58 29.72,17.93 29.72,13.33 30.05,12.99 30.05,11.89 30.02,11.85 30.02,7.02 30.63,6.41 30.63,3.7 32.63,1.7 39.5,1.7 40.93,3.14 40.93,4.06 42.47,5.59 92.8,5.59 96.74,1.65 124.23,1.65 126.05,3.47 128.14,3.47 130.29,5.62 147.73,5.62 148.1,5.24 149.29,5.24 149.73,5.68 151.98,5.68 152.48,6.18 166.74,6.18 169.63,3.29 179.54,3.29 181.12,1.7 198.13,1.7 200.01,3.58 208.94,3.58 209.35,3.17 210.5,3.17 210.87,2.8 213.03,2.8 213.82,3.58 234,3.58 235.17,2.42 252.98,2.42 253.34,2.78 257.82,2.78 258.48,2.11 265.67,2.11 269.6,6.04 269.6,14.34 273.21,17.95 273.21,27 273.07,27.14 273.07,29.32 v3(272.86,29.54) 273.14,29.54 277.08,33.48 277.08,36.54 277.72,37.18 277.72,52.76 v3(276.57,53.92)
AMP_I2S_LRCK: length 1.8
  TOP w0.069: RA75.1 263.01,58.08 262.88,58.08 262.81,58.15 UA1.12
AMP_I2S_LRCK_R: length 346.5
  TOP w0.069: v2(276.85,39.08) 276.77,39.01 276.77,35.68 v3(276.44,35.35) 276.44,32.2 275.94,31.7 275.71,31.7 275.05,31.03 275.05,30.85 274.71,30.52 274.71,29.74 274.64,29.66 v1(274.61,29.66) 274.46,29.66 274.36,29.76 274.36,30.09 274.2,30.25 UA3.14 ; v3(24.17,22.01) 23.79,22.4 23.1,22.4 22.9,22.19 UA2.14 ; RA75.2 v2(263.87,55.95)
  IN1 w0.061: v2(276.85,39.08) 277.33,39.57 279.46,39.57 279.74,39.84 279.74,49.8 277.15,52.39 273.38,52.39 271.15,54.63 267.25,54.63 266.82,54.2 265.16,54.2 264.45,54.91 264.45,55.59 264.1,55.95 v2(263.87,55.95)
  IN3 w0.061: v3(24.17,22.01) 24.17,21.79 24.75,21.21 27.5,21.21 30.35,18.36 30.35,13.86 30.71,13.5 30.71,10.23 32.75,8.2 34.85,8.2 35.11,7.94 37,7.94 37.34,7.6 40.94,7.6 41.59,6.96 57.31,6.96 57.88,6.39 74.46,6.39 74.79,6.73 80.63,6.73 81.14,6.22 93.15,6.22 97.09,2.28 113.48,2.28 114.82,3.62 122.52,3.62 123,4.1 127.88,4.1 130.09,6.31 147.93,6.31 148.36,5.87 149.03,5.87 149.47,6.31 151.72,6.31 152.22,6.81 167,6.81 169.89,3.92 179.8,3.92 181.39,2.33 197.87,2.33 199.75,4.21 209.2,4.21 209.62,3.8 210.76,3.8 211.13,3.43 212.74,3.43 213.52,4.21 234.26,4.21 235.43,3.05 250.06,3.05 250.94,3.93 258.79,3.93 259.98,2.74 265.39,2.74 268.97,6.32 268.97,14.6 272.58,18.21 272.58,26.56 272.13,27 272.13,29.81 272.61,30.28 272.99,30.28 276.43,33.72 276.43,35.34 v3(276.44,35.35)
AMP_I2S_OUT: length 1.8
  TOP w0.069: UA1.9 261.61,57.93 262.04,57.5 262.2,57.5 262.48,57.22 RA77.1
AMP_I2S_OUT_R: length 342.9
  TOP w0.069: RA77.2 v3(262.6,55.95) ; UA3.11 272.05,29.18 v1(272.68,28.54)
  IN1 w0.061: v3(272.51,29.15) v2(272.05,29.61)
  IN2 w0.051: v3(276.57,53.41) 275.38,54.6 275.38,56.36 273.76,57.98 266.69,57.98 266.26,57.55 264.2,57.55 v3(262.6,55.95)
  IN3 w0.061: v3(276.57,53.41) 277.46,52.52 277.46,37.29 276.8,36.63 276.8,33.57 273.14,29.92 272.76,29.92 272.51,29.66 v3(272.51,29.15) 272.5,29.14 272.5,27.15 272.94,26.71 272.94,18.06 269.34,14.45 269.34,6.17 265.54,2.37 258.59,2.37 257.93,3.04 253.23,3.04 252.87,2.68 235.28,2.68 234.11,3.85 213.67,3.85 212.89,3.07 210.98,3.07 210.61,3.44 209.46,3.44 209.05,3.85 199.9,3.85 198.03,1.97 181.23,1.97 179.65,3.56 169.74,3.56 166.85,6.45 152.38,6.45 151.87,5.94 149.62,5.94 149.18,5.5 148.21,5.5 147.84,5.88 130.18,5.88 128.03,3.74 125.94,3.74 124.29,2.09 120.86,2.09 120,2.94 114.74,2.94 113.71,1.92 96.85,1.92 92.91,5.85 57.77,5.85 57.04,6.59 41.44,6.59 40.79,7.24 37.19,7.24 36.89,7.54 35.02,7.54 34.75,7.27 34.75,7.25 30.97,7.25 30.35,7.87 30.35,13.27 29.98,13.63 29.98,18.21 27.35,20.84 23.72,20.84 23.06,21.49 23.06,22.36 22.68,22.74 v3(22.32,22.74)
AUD_PWR_EN: length 177.1
  TOP w0.069: v2(267.02,44.11) 267.45,44.11 268.81,42.76 v1(268.93,42.76) UC25.3
  IN1 w0.061: v2(267.02,44.11) v3(266.36,44.77)
  IN2 w0.051: v4(258.03,42.28) 258.03,41.98 256.63,40.58 256.63,35.4 258.27,33.76 258.27,29.26 257.86,28.85 256.42,28.85 256.08,28.52 254.98,28.52 252.06,25.6 252.06,24.78 250.25,22.98 250.25,20.03 247.41,17.18 246.95,17.18 245.78,16.02 245.78,16.01 241.47,11.7 236.31,11.7 235.79,11.19 233.77,11.19 233.27,10.69 224.34,10.69 223.53,9.87 222.26,9.87 222.05,9.66 216.82,9.66 216.34,10.14 210.99,10.14 210.26,10.86 201.92,10.86 195.44,17.34 189.74,17.34 188.81,18.27 188.81,21.35 188.61,21.55 188.61,22.75 187.3,24.07 186.09,24.07 185.43,24.73 182.22,24.73 179.78,27.17 178.78,27.17 178.14,27.81 178.14,28.31 177.84,28.62 174.82,28.62 174.27,29.17 171.39,29.17 169.12,31.44 164.81,31.44 164.56,31.18 164.19,31.18 163.48,31.89 158.76,31.89 157.98,32.68 157.98,34.94 157.75,35.17 157.75,35.84 157.54,36.05 157.54,36.56 157.13,36.97 156.66,36.97 155.72,36.03 155.59,36.03 155.21,36.42 155.21,38.27 v3(154.95,38.52)
  IN3 w0.061: v4(153.47,36.91) 153.47,37.22 153.96,37.71 154.45,37.71 154.95,38.22 v3(154.95,38.52) ; v4(258.03,42.28) 258.23,42.49 259.09,42.49 260.15,43.55 260.33,43.55 260.5,43.72 261.34,43.72 262.15,44.52 263.77,44.52 264.02,44.77 v3(266.36,44.77)
  BOTTOM w0.069: R600.2 254.22,50.31 254.22,49.86 255.16,48.92 255.16,43.81 255.79,43.17 255.79,42.33 255.94,42.18 257.93,42.18 v4(258.03,42.28) ; R600.2 254.87,50.96 U36.3 ; R600.2 R232.2
AUX_EN_WOWL: length 52.7
  TOP w0.069: UE1.D3 178.33,20.41 178.22,20.52 v2(178.22,20.6)
  IN1 w0.061: v3(177.05,21.58) 177.24,21.58 v2(178.22,20.6) ; v3(172.18,15.99) 172.18,17.37 172.43,17.62 172.43,18.38 172.61,18.56 172.61,20.67 172.43,20.85 172.43,21.15 v3(172.3,21.28)
  IN2 w0.051: v3(177.05,21.58) 172.51,21.58 172.3,21.38 v3(172.3,21.28)
  IN3 w0.061: v4(192.62,5.28) 192.3,5.6 189.95,5.6 188.51,7.05 188.51,7.22 187.88,7.85 187.61,7.85 187.03,7.27 186.35,7.27 183.61,10.01 182.91,10.01 180.96,11.96 177.28,11.96 173.87,15.36 172.81,15.36 v3(172.18,15.99)
  BOTTOM w0.069: D23.3 200.29,12.23 RE322.1 200.09,12.03 R617.2 199.81,11.17 199.81,9.24 v1(199.49,8.92) 197.74,7.17 195.92,7.17 195.24,7.3 194.25,7.71 194.02,7.94 193,7.94 192.92,7.86 192.92,5.57 v4(192.62,5.28)
B: length 3.5
  TOP w0.069: v1(108.34,5.11) 108,4.78 PR608.2
  TOP w0.254: PR608.2 108,3.15 PR601.2 108.37,3.14 108.68,2.83 PU600.2
B+: length 141.1
  TOP w0.254: PR218.2 34.54,13.03 35.65,14.14 36.97,14.14 38.19,12.92 84.8,12.92 85.56,13.68 85.56,16.6 85.33,16.83 85.33,19.83 85.74,20.24 v5(86.15,20.24)
  IN1 w0.508: 39.71,1.85 39.56,1.69 39.53,1.73 26.47,1.73 25.36,2.84 25.36,3.73 25.64,4.01 28.18,4.01 28.59,4.41 28.59,10.51 29.88,11.8 29.88,16.86 30.43,17.41 v5(31.98,17.41)
  IN2 w1.016: 260.82,12.01 264.07,15.26 264.07,18 263.84,18.23 263.84,22.22 270.37,28.75 270.37,33.42 272.56,35.6 272.56,36.92 274.05,38.42
  BOTTOM w0.254: v5(86.15,20.24) 77.66,20.24 77.33,20.57
  BOTTOM w0.381: QV18.3 110.58,70.78 110.61,70.78 v5(110.99,70.4)
  BOTTOM w0.508: QZ10.4 181.65,70.95 182.11,70.5 C3314.1 183.35,70.5 R5867.1
  vias: v2(33.77,24.99) v2(33.82,24.33) v2(34.08,24.66) v2(34.28,23.82) v2(34.43,24.35) v2(34.68,23.41) v2(34.81,23.94) v2(40.22,2.1) v2(40.22,1.72) v2(103.03,3.91) v2(274.66,39.44) v2(274.66,38.93) v3(33.77,24.99) v3(33.82,24.33) v3(34.08,24.66) v3(34.28,23.82) v3(34.43,24.35) v3(34.68,23.41) v3(34.81,23.94) v3(76.97,22.13) v3(77.35,22.52) v3(77.73,22.9) v3(77.65,22.16) v3(78.03,22.54) v3(78.11,23.28) v3(78.41,22.92) v3(78.36,22.21) v3(78.49,23.63) v3(78.74,22.59) v3(78.8,23.28) v3(78.87,24.01) v3(79.13,22.95) v3(79.2,24.83) v3(79.18,23.66) v3(79.25,24.39) v3(79.51,23.33) v3(79.58,25.18) v3(79.63,24.75) v3(79.56,24.04) v3(79.94,24.39) v3(79.89,23.71) v3(79.99,25.59) v3(80.04,25.16) v3(80.34,24.8) v3(80.27,24.06) v3(80.37,25.97) v3(80.42,25.54) v3(80.75,26.35) v3(80.73,25.18) v3(80.67,24.47) v3(80.8,25.92) v3(81.13,26.73) v3(81.11,25.56) v3(81.06,24.85) v3(81.18,26.3) v3(81.44,25.23) v3(81.49,25.94) v3(81.61,27.39) v3(81.56,26.68) v3(81.82,25.61) v3(81.94,27.04) v3(81.87,26.33) v3(81.97,27.77) v3(82.25,26.68) v3(82.2,26) v3(82.35,28.15) v3(82.33,27.42) v3(82.63,27.06) v3(82.58,26.35) v3(82.73,28.54) v3(82.71,27.8) v3(83.01,27.44) v3(82.96,26.73) v3(83.11,28.92) v3(83.09,28.18) v3(83.34,27.11) v3(83.39,27.82) v3(83.52,29.32) v3(83.47,28.56) v3(83.57,30.08) v3(83.72,27.49) v3(83.77,28.2) v3(83.95,30.47) v3(83.9,29.7) v3(83.88,28.97) v3(84.1,27.87) v3(84.18,28.61) v3(84.33,30.85) v3(84.28,30.08) v3(84.26,29.35) v3(84.51,28.28) v3(84.64,29.73) v3(84.56,28.99) v3(84.66,30.47) v3(84.94,29.37) v3(84.89,28.66) v3(85.02,30.11) v3(85.07,30.8) v3(85.32,29.75) v3(85.27,29.04) v3(85.42,30.44) v3(92.77,72.86) v3(93.27,72.88) v3(103.03,3.91) v3(202.68,32.4) v3(202.68,31.89) v3(202.68,31.39) v3(202.68,30.88) v3(207.77,13.12) v3(208.03,13.51) v3(208.28,13.12) v3(208.54,13.51) v3(208.75,13.12) v3(209.01,13.51) v3(209.26,13.12) v3(209.51,13.51) v3(209.77,13.12) v3(243.13,7.13) v3(243.42,7.41) v3(243.72,7.13) v3(244.02,7.42) v3(244.32,7.13) v3(244.74,7.16) v3(245.1,7.36) v3(260.31,11.17) v3(260.82,11.17) v3(274.66,39.44) v3(274.66,38.93) v4(33.77,24.99) v4(33.82,24.33) v4(34.08,24.66) v4(34.28,23.82) v4(34.43,24.35) v4(34.68,23.41) v4(34.81,23.94) v4(76.9,22.95) v4(77.1,22.75) v4(77.18,23.06) v4(77.38,22.85) v4(77.46,23.16) v4(77.56,23.46) v4(77.69,22.55) v4(77.76,23.26) v4(77.86,23.54) v4(78.02,22.19) v4(78.14,23.61) v4(78.07,22.93) v4(78.22,23.92) v4(78.45,23.28) v4(78.37,22.55) v4(78.53,24) v4(78.63,24.27) v4(78.83,23.67) v4(78.78,22.93) v4(78.91,24.35) v4(79.21,24.05) v4(79.16,23.31) v4(79.54,23.69) v4(80,24.78) v4(80.33,24.43) v4(80.38,25.16) v4(80.71,24.83) v4(80.76,25.57) v4(81.14,25.93) v4(81.07,25.21) v4(81.4,27.07) v4(81.47,25.6) v4(82.28,27.04) v4(82.61,26.71) v4(82.67,27.45) v4(83.05,27.83) v4(83,27.09) v4(83.17,29.25) v4(83.28,29.56) v4(83.43,28.21) v4(83.38,27.45) v4(83.53,29.71) v4(83.73,27.86) v4(83.94,30.12) v4(83.88,29.33) v4(84.21,28.97) v4(84.29,30.47) v4(84.27,29.74) v4(84.52,28.64) v4(84.6,29.38) v4(84.7,30.85) v4(84.67,30.09) v4(84.93,29.02) v4(84.98,29.74) v4(85.08,30.45) v4(92.77,72.86) v4(93.27,72.88) v4(210.48,13.11) v4(210.58,13.35) v4(210.73,13.11) v4(210.86,13.37) v4(210.99,13.11) v4(211.16,13.37) v4(211.29,13.09) v4(211.42,13.37) v4(211.55,13.09) v4(217.03,13.76) v4(217.39,13.76) v4(244.41,7.94) v4(244.51,7.64) v4(244.74,7.94) v4(244.9,7.66) v4(245.1,7.94) v4(245.3,7.64) v4(245.43,7.94) v5(86.47,18.57) v5(86.48,17.29) v5(86.7,20.26) v5(87.09,20.77) v5(87.34,21.28) v5(87.34,20.26) v5(87.72,21.79) v5(87.72,20.77) v5(87.72,19.75) v5(87.95,18.36) v5(87.95,17.3) v5(87.97,21.28) v5(87.97,20.26) v5(88.1,22.29) v5(88.36,21.79) v5(88.36,20.77) v5(88.36,19.75) v5(88.51,22.93) v5(88.61,21.28) v5(88.61,20.26) v5(88.74,22.29) v5(88.99,21.79) v5(88.99,20.77) v5(88.99,19.75) v5(89.12,22.8) v5(89.24,21.28) v5(89.24,20.26) v5(89.37,22.29) v5(89.5,23.31) v5(89.75,22.8) v5(89.88,23.82) v5(90.13,23.31) v5(90.26,24.33) v5(90.51,23.82) v5(90.59,24.78) v5(90.97,25.24) v5(95.09,8.45) v5(95.72,8.45) v5(97.7,7.21) v5(98.34,7.21) v5(186.88,72.51) v5(187.49,72.48) v5(201,51.25) v5(201.04,50.61) v5(201.74,66.67) v5(201.74,66.11) v5(201.77,68.19) v5(202.07,65.6) v5(202.4,68.19) v5(202.38,66.67) v5(202.38,66.11) v5(202.68,65.6) v5(203.04,68.19) v5(203.01,66.67) v5(203.01,66.11) v5(203.65,66.67) v5(203.67,68.19) v5(204.31,68.19) v5(204.28,66.67) v5(204.94,68.19) v5(204.97,66.31) v5(204.97,65.75) v5(205.09,67.58) v5(205.09,67.02) v6(88.89,19.17)
B+_1.1V_MEM: length 1.7
  BOTTOM w0.069: v1(102.43,6.29) 101.78,6.29 PL701.2
B+_3V:
  vias: v1(215.36,14.04)
B+_CAM: length 1.3
  TOP w0.069: RV75.2 v1(168.7,64.08)
  vias: v5(166.21,65.16) v5(166.78,65.16)
B+_CAM_R:
  vias: v1(171.13,63.87) v5(179.9,69.33) v5(179.92,68.6)
B+_FLAG: length 102.3
  TOP w0.069: v1(118.21,5.06) 118.3,5.15 v3(118.3,5.68) 118.48,5.68 R6222.2
  IN2 w0.051: v4(215.36,7.66) 211.3,7.66 210.97,7.33 199.45,7.33 198.4,8.37 197.27,8.37 196.81,7.92 187.18,7.92 187.06,7.8 187.06,7.69 186.73,7.36 186.37,7.36 186.04,7.69 186.04,7.69 185.76,7.98 181.85,7.98 179.86,5.98 171.8,5.98 171.27,6.52 150.75,6.52 150.37,6.14 118.76,6.14 v3(118.3,5.68)
  BOTTOM w0.069: JIO1.3 215.75,8.23 215.75,8.06 v4(215.36,7.66)

# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRIM_PWRGD: length 5.1
  TOP w0.069: UE1.L7 181.85,14.27 181.85,12.02 183.11,10.76 RE461.1 RE245.1
PROCHOT#_R1: length 2.4
  TOP w0.069: UE1.H13 187.31,16.99 187.62,16.68 RE158.1
PROM_BIOS_R: length 124
  TOP w0.069: v3(147.59,67.68) 147.33,67.94 v1(116.57,67.94) 116.01,67.94 115.26,68.68 115.26,71.05 114.92,71.39 112.56,71.39 112.21,71.04 112.21,69.5 109.75,67.04 108.96,67.04 108.46,66.54 106.24,66.54 105.6,67.18 105.6,67.26 105.22,67.64 104.28,67.64 104.09,67.46 v3(104.09,67.43)
  IN2 w0.051: v3(147.59,67.68) 147.87,67.96 172.43,67.96 175.01,65.38 175.01,62.26 177.89,59.38 180.65,59.38 187.19,52.84 187.19,47.29 192.35,42.13 192.35,39.89 194.99,37.25 v4(194.99,37.05)
  IN3 w0.061: v4(103.34,66.71) 104.03,67.39 104.05,67.39 v3(104.09,67.43)
  BOTTOM w0.069: v4(103.34,66.71) 103.28,66.64 R466.1 ; v4(194.99,37.05) 194.99,36.52 195.27,36.25 195.27,33.5 194.8,33.03 JSPI1.6
PS2_CLK1B_TP: length 38.2
  TOP w0.069: v2(190.39,9.57) 190.9,9.05 190.9,7.19 190.02,6.3 v1(190.02,6.05) 190.02,5.9 v3(189.32,5.2)
  IN1 w0.061: v2(190.39,9.57) 190.56,9.74 190.56,11.41 191.07,11.93 191.07,12.69 190.56,13.21 190.56,15.68 189.83,16.41 189.83,18.71 189.29,19.25 189.29,20.8 v2(189.09,21)
  IN3 w0.061: v3(189.32,5.2) 189.63,4.89 190.1,4.89 190.49,5.28 192.03,5.28 192.45,4.85 193.5,4.85 193.71,5.07 196.36,5.07 v4(196.61,5.32)
  BOTTOM w0.069: JTP1.8 202.71,9.62 203.26,9.07 203.26,6.92 201.46,5.12 199.11,5.12 D482.3 198.59,4.39 198.36,4.15 196.87,4.15 C4235.1 196.41,4.62 R6217.2 196.41,5.12 v4(196.61,5.32)
PS2_DAT1B_TP: length 39.8
  TOP w0.069: v3(189.85,5.22) 191.3,6.67 v1(191.3,7.21) 191.3,9.03 v2(190.77,9.57)
  IN1 w0.061: v2(189.09,21.64) 189.54,21.19 189.54,19.28 190.01,18.81 190.01,16.46 190.8,15.66 190.8,13.19 191.23,12.76 191.23,11.86 190.82,11.45 190.82,9.62 v2(190.77,9.57)
  IN3 w0.061: v4(195.14,5.33) 193.64,5.33 193.33,5.02 192.51,5.02 192.09,5.44 190.07,5.44 v3(189.85,5.22)
  BOTTOM w0.069: JTP1.7 203.21,10.57 203,10.77 202.71,10.77 202.42,10.47 202.42,9.46 203.09,8.79 203.09,6.99 201.55,5.45 198.87,5.45 198.71,5.61 D482.2 198.36,5.38 197.98,5.38 197.52,5.83 197,5.83 R6218.2 196.68,6.16 194.7,6.16 C4234.1 194.65,5.81 v4(195.14,5.33)
PTP_DIS#: length 39
  TOP w0.069: v3(195.37,6.27) 195.34,6.27 194.86,5.78 v1(194.86,5.15)
  IN1 w0.061: v2(179.13,18.59) v3(179.13,18.92)
  IN3 w0.061: v3(179.13,18.92) 179.13,18.61 179.16,18.59 181.95,18.59 182.66,17.88 182.66,16.41 182.74,16.32 182.74,14.17 182.31,13.73 182.31,13.3 183.45,12.15 184.41,12.15 185.93,10.64 187.27,10.64 188.17,9.74 188.17,9.17 190.3,7.04 190.78,7.04 191.26,6.56 193.31,6.56 193.61,6.27 v3(195.37,6.27) 195.45,6.18 196.47,6.18 196.85,6.56 197.6,6.56 197.66,6.62 198.47,6.62 198.65,6.8 203.77,6.8 v4(203.87,6.9)
  BOTTOM w0.069: v4(203.87,6.9) 203.71,7.07 JTP1.6
PWM1: length 19.2
  TOP w0.203: v5(95.39,60.34) 94.32,60.34 93.89,59.91 v2(93.89,47.41)
  IN1 w0.203: v3(94.3,45.59) 94.2,45.69 94.2,46.86 93.89,47.16 v2(93.89,47.41)
  IN3 w0.203: v4(93.59,45.59) v3(94.3,45.59)
  BOTTOM w0.069: v4(93.59,45.59) 93.03,45.59 v1(92.95,45.66)
  BOTTOM w0.203: PU1201.9 93.71,45.47 v4(93.59,45.59) ; v5(95.39,60.34) 95.56,60.51 PU1100.24
PWM2: length 32.2
  TOP w0.203: v5(95.21,59.76) 95.21,59.5 94.91,59.2 94.91,47.16 94.68,46.93 94.45,46.93 94.17,46.65 93.05,46.65 92.93,46.77 91.17,46.77 89.96,45.56 89.96,42.22 93.7,38.47 94.58,38.47 94.73,38.32 94.73,37.76 94.4,37.43 94.4,37.28 v2(94.37,37.25)
  IN1 w0.203: v4(94.14,36.47) 94.14,36.97 94.37,37.2 v2(94.37,37.25)
  BOTTOM w0.203: v5(95.21,59.76) 95.47,59.76 95.82,60.11 PU1100.23 ; PU1200.9 v4(94.14,36.47)
PWM_FAN1: length 127.7
  IN1 w0.061: v2(183.93,14.59) v3(183.93,15.03) ; v2(72.35,8.4) 72.08,8.68 v4(71.41,8.68)
  IN2 w0.051: v4(71.41,8.68) 71.69,8.96 80.47,8.96 81.18,8.25 93.69,8.25 94.35,7.59 101.93,7.59 102.66,8.32 105.58,8.32 107.15,9.9 122.89,9.9 122.94,9.95 136.06,9.95 136.57,10.46 140.9,10.46 141.18,10.18 165.69,10.18 168.07,12.57 170.92,12.57 172.7,14.34 176.74,14.34 177.4,13.68 179.94,13.68 180.09,13.83 183.17,13.83 183.93,14.59 v3(183.93,15.03)
  BOTTOM w0.069: JFAN1.2 66.95,8.66 67.27,8.98 68.72,8.98 70.42,7.28 R36.1 71.6,7.97 71.41,8.16 v4(71.41,8.68)
PWM_FAN2: length 56.5
  IN1 w0.061: v2(184.73,14.59) v3(184.73,14.24)
  IN3 w0.061: v3(184.73,14.24) 184.73,12.57 186.17,11.13 187.68,11.13 191.28,7.53 191.28,7.47 191.52,7.23 195.63,7.23 195.96,6.9 196.26,6.9 196.59,7.23 197.12,7.23 198.21,8.31 199.85,8.31 200.36,7.81 203.51,7.81 203.56,7.86 205.59,7.86 206,7.45 214.33,7.45 215.04,8.16 215.64,8.16 216.02,7.78 220.25,7.78 220.52,7.51 225.2,7.51 225.53,7.84 232.89,7.84 v4(233.15,8.09)
  BOTTOM w0.069: R39.1 233.95,6.9 233.77,7.08 233.39,7.08 233.15,7.32 JFAN2.2
PWRBTN#: length 221.1
  TOP w0.069: v2(186.07,22.93) 186.2,23.06 186.83,23.06 188.79,25.01 190.45,25.01 v6(191.78,26.35) JAPS1.11 195.81,26.35 196.87,25.28 196.87,22.69 194.02,19.84 194.02,17.26 193.43,16.68 193.43,12.95 v3(194.01,12.38) ; PD600.1 117.34,2.3 117.87,1.77 120.13,1.77 120.28,1.92 120.28,3.22 120.42,3.36 120.42,5.2 120,5.62 v2(120,6.27) ; v3(171.49,20.1) CE68.2
  IN1 w0.061: v3(171.49,20.1) 171.49,19.87 171.44,19.81 171.44,15.44 171.87,15.01 171.87,12.92 170.03,11.09 168.85,11.09 168.04,10.28 166.98,10.28 165.92,9.22 148.34,9.22 147.82,8.69 146.17,8.69 145.37,7.89 129.39,7.89 128.46,6.95 120.69,6.95 v2(120,6.27) ; v2(186.07,22.93) 185.94,23.06 185.43,23.06 184.95,22.57 184.95,21.97 185.56,21.36 v3(185.56,18.23)
  IN2 w0.051: v3(194.01,12.38) 194.81,11.57 198.91,11.57 201.24,9.24 204.41,9.24 205.5,8.15 210.37,8.15 210.89,8.67 215.72,8.67 216.2,8.19 222.67,8.19 222.89,8.4 227.83,8.4 228.64,9.21 233.88,9.21 234.18,9.52 240.32,9.52 v3(240.63,9.21) 241.07,9.21 244.86,13 247.06,13 249.26,15.21 249.26,17.59 251.32,19.65 251.32,22.43 253.65,24.76 254.66,24.76 257.97,28.07 257.97,28.31 258.73,29.07 258.73,33.95 257.09,35.59 257.09,40.39 258.12,41.42 259.75,41.42 v3(259.81,41.47) ; v3(185.56,18.23) 182.44,18.23 180.09,20.57 171.58,20.57 171.49,20.49 v3(171.49,20.1)
  IN3 w0.061: v4(241.39,9.49) 240.91,9.49 v3(240.63,9.21) ; v4(260.92,41.75) 260.64,41.47 v3(259.81,41.47)
  BOTTOM w0.069: R208.2 263.06,42.54 QF1.1 262.17,41.88 262.04,41.75 v4(260.92,41.75) ; v4(241.39,9.49) SW1.3
PWRBTN#_FPR: length 10.5
  BOTTOM w0.069: QF1.3 262.66,43.24 262.75,43.15 R208.1 ; JFP1.7 257.74,39.94 258.72,40.91 260.41,40.91 260.9,41.39 263.18,41.39 263.46,41.67 263.46,42.77 R208.1 ; R208.1 263.31,43.38 v1(263.92,43.38)
REF_1.1V_MEM: length 2.9
  BOTTOM w0.069: v1(94.55,12.79) 94.71,12.79 PC714.1 95.78,13.65 PU700.7
REM_DIODE1_N: length 245.4
  TOP w0.127: v3(137.49,56.85) 137.49,56.89 137.36,57.01 135.95,57.01 v1(135.85,56.91) 135.68,56.91 133.88,55.11 131.92,55.11 131.23,54.42 131.23,53.88 v2(131.37,53.74) ; QE4.3 136.69,43.62 137.11,43.62 CE57.2 137.58,43.78 137.74,43.62 138.58,43.62 v2(138.72,43.76) ; UE1.A8 182.05,22.87 182.05,23.71 182.36,24.02 182.36,24.63 v2(182.66,24.93)
  IN1 w0.127: v3(140.93,61.77) 140.93,61.77 140.83,61.87 140.83,62.45 142.22,63.83 146.68,63.83 149.23,66.38 171.69,66.38 171.84,66.23 171.84,66.05 v3(171.81,66.01) ; v3(182.2,27.13) 182,26.93 182,25.17 182.24,24.93 v2(182.66,24.93) ; v2(131.37,53.74) 131.26,53.62 131.26,53.36 130.95,53.05 130.01,53.05 129.79,53.27 115.22,53.27 114.23,52.28 106.14,52.28 103.57,49.71 103.57,33.19 104.87,31.89 114.64,31.89 120.51,37.76 120.51,39.31 124.37,43.17 127.39,43.17 128.54,44.32 134.25,44.32 134.95,43.62 138.34,43.62 138.48,43.76 v2(138.72,43.76)
  IN2 w0.127: v3(190.95,37.64) 190.95,38.42 190.54,38.83 190.54,41.01 188.84,42.72 187.19,42.72 185.92,43.99 185.92,53.21 180.41,58.72 177.7,58.72 174.41,62.01 174.41,64.28 174.05,64.64 174.05,65.48 172.96,66.57 172.4,66.57 171.85,66.01 v3(171.81,66.01)
  IN3 w0.127: v3(171.81,66.01) 172.28,66.49 174.31,66.49 175.73,67.91 176.39,67.91 180.33,71.85 187.86,71.85 191.36,75.35 194.96,75.35 200.6,69.72 200.6,65.65 v5(200.76,65.49) ; v3(182.2,27.13) 182.2,27.39 183.08,28.27 184.13,28.27 184.59,27.8 185.64,27.8 186.12,27.32 187.59,27.32 188.26,27.99 188.46,27.99 190.11,29.64 190.11,30.7 190.31,30.9 190.9,30.9 191.4,31.41 191.4,36.87 190.95,37.33 v3(190.95,37.64) ; v3(140.93,61.77) 140.81,61.64 140.81,61.28 138.09,58.56 138.09,57.29 137.86,57.06 137.71,57.06 v3(137.49,56.85)
  BOTTOM w0.127: QE14.1 200.47,67.18 200.7,66.95 QE14.2 200.7,66.07 CE58.2 200.6,65.84 200.6,65.65 v5(200.76,65.49)
REM_DIODE1_P: length 244.3
  TOP w0.127: UE1.A7 181.79,22.85 181.79,23.81 182.11,24.13 182.11,24.57 v2(181.74,24.93) ; QE4.1 136.11,43.28 QE4.2 136.59,43.28 136.67,43.36 137.11,43.36 CE57.1 137.58,43.2 137.74,43.36 138.58,43.36 v2(138.72,43.22) ; v3(137.49,57.41) 137.35,57.27 135.67,57.27 133.77,55.36 131.81,55.36 130.98,54.53 130.98,53.88 v2(130.84,53.74)
  IN1 w0.127: v3(172.42,66.01) 171.8,66.63 149.12,66.63 146.58,64.09 142.11,64.09 140.58,62.55 140.58,61.94 v3(140.4,61.77) ; v3(181.67,27.32) 181.74,27.25 v2(181.74,24.93) ; v2(138.72,43.22) 138.48,43.22 138.34,43.36 134.85,43.36 134.15,44.06 128.64,44.06 127.5,42.92 124.48,42.92 120.77,39.21 120.77,37.66 114.75,31.64 104.76,31.64 103.32,33.08 103.32,49.82 106.04,52.54 114.13,52.54 115.11,53.52 129.9,53.52 130.11,53.31 130.85,53.31 131,53.46 131,53.57 v2(130.84,53.74)
  IN2 w0.127: v3(172.42,66.01) 172.42,66.22 172.51,66.31 172.86,66.31 173.8,65.37 173.8,64.54 174.16,64.18 174.16,61.9 177.6,58.46 180.3,58.46 185.66,53.1 185.66,43.88 187.09,42.46 188.73,42.46 190.29,40.91 190.29,38.19 190.46,38.02 v3(190.51,38.02)
  IN3 w0.127: v3(181.67,27.32) 181.77,27.32 182.97,28.52 184.23,28.52 184.7,28.06 185.74,28.06 186.23,27.57 187.48,27.57 188.16,28.25 188.36,28.25 189.85,29.74 189.85,30.8 190.21,31.16 190.79,31.16 191.15,31.51 191.15,36.77 190.47,37.45 190.47,37.69 190.51,37.74 v3(190.51,38.02) ; v3(172.42,66.01) 172.42,66.06 172.59,66.24 174.41,66.24 175.84,67.66 176.5,67.66 180.43,71.59 187.97,71.59 191.47,75.1 194.85,75.1 200.34,69.61 200.34,65.65 v5(200.18,65.49) ; v3(137.49,57.41) 137.58,57.32 137.75,57.32 137.83,57.4 137.83,58.67 140.55,61.39 140.55,61.61 v3(140.4,61.77)
  BOTTOM w0.127: v5(200.18,65.49) 200.34,65.65 200.34,65.84 CE58.1 200.25,66.07 QE14.3
REM_DIODE2_N: length 211
  TOP w0.127: UE1.A10 183.69,22.83 183.69,23.04 183.88,23.23 184.14,23.23 184.54,23.64 185.33,23.64 185.89,24.2 185.89,24.61 v2(186.21,24.93) ; QE8.1 141.44,56.76 QE8.2 140.26,56.76 CE55.2 140.02,56.63 139.6,56.63 139.24,56.28 v7(138,56.28) 137.69,56.28 137.64,56.23 135.9,56.23 134.46,54.78 134.46,54.15 v2(134.29,53.99) ; QE17.3 139.09,11.24 139.13,11.19 CE69.2 139.13,10.67 138.94,10.48 138.94,9.15 v5(139.11,8.98)
  IN1 w0.127: v2(134.29,53.99) 134.43,54.13 134.43,54.14 134.3,54.27 133.85,54.27 133.39,53.81 132.01,53.81 131.53,54.3 129.82,54.3 129.48,54.64 121.92,54.64 121.44,54.16 114.66,54.16 113.67,53.17 105.77,53.17 102.6,50 102.6,32.43 104.05,30.98 109.72,30.98 110.12,30.57 110.12,28.67 106.52,25.06 106.52,24.07 102.3,19.86 102.3,15.82 105.78,12.34 106.79,12.34 108.99,10.14 112.95,10.14 113.26,9.82 114.81,9.82 115.26,9.37 136.85,9.37 137.05,9.57 138.72,9.57 139.11,9.18 v5(139.11,8.98) ; v3(186.34,6.25) 186.2,6.39 186.2,6.62 187.72,8.15 188.18,8.15 188.43,8.39 189.42,8.39 189.96,8.93 189.96,15.38 188.69,16.65 188.69,22.15 188.91,22.37 188.91,23.87 188.23,24.55 186.05,24.55 185.92,24.69 185.92,24.86 185.99,24.93 v2(186.21,24.93)
  IN3 w0.127: v5(139.11,8.98) 138.95,9.14 138.95,9.32 139.07,9.45 141.08,9.45 141.25,9.27 150.79,9.27 151.57,10.05 166.45,10.05 167.06,10.66 169.81,10.66 170.08,10.39 173.86,10.39 174.84,11.37 175.73,11.37 176.6,10.51 179.74,10.51 182.05,8.2 183.75,8.2 184.42,7.53 184.42,6.75 185.51,5.66 185.94,5.66 186.2,5.91 186.2,6.11 v3(186.34,6.25)
REM_DIODE2_P: length 211.2
  TOP w0.127: v2(185.3,24.93) 185.64,24.59 185.64,24.3 185.23,23.89 184.44,23.89 184.03,23.49 183.78,23.49 183.44,23.15 183.44,22.9 UE1.A9 ; QE17.1 138.64,12.04 QE17.2 138.64,11.21 138.55,11.12 CE69.1 138.55,10.63 138.69,10.5 138.69,9.14 v5(138.53,8.98) ; v2(134.82,53.99) 134.71,54.1 134.71,54.67 136.01,55.97 137.75,55.97 137.8,56.02 139.35,56.02 139.7,56.38 140.05,56.38 CE55.1 140.27,56.31 QE8.3
  IN1 w0.127: v2(185.3,24.93) 185.57,24.93 185.66,24.83 185.66,24.58 185.94,24.3 188.12,24.3 188.66,23.76 188.66,22.48 188.44,22.25 188.44,16.54 189.7,15.28 189.7,9.03 189.31,8.65 188.32,8.65 188.08,8.4 187.61,8.4 185.94,6.73 185.94,6.39 v3(185.8,6.25) ; v5(138.53,8.98) 138.53,9.16 138.37,9.31 137.15,9.31 136.95,9.11 115.16,9.11 114.7,9.57 113.16,9.57 112.84,9.89 108.88,9.89 106.69,12.08 105.68,12.08 102.05,15.71 102.05,19.96 106.26,24.18 106.26,25.17 109.87,28.77 109.87,30.47 109.61,30.73 103.95,30.73 102.35,32.32 102.35,50.11 105.67,53.43 113.57,53.43 114.55,54.41 121.34,54.41 121.81,54.89 129.59,54.89 129.92,54.55 131.63,54.55 132.12,54.07 133.29,54.07 133.75,54.53 134.41,54.53 134.68,54.25 134.68,54.09 134.79,53.99 v2(134.82,53.99)
  IN3 w0.127: v3(185.8,6.25) 185.94,6.11 185.94,6.02 185.84,5.91 185.62,5.91 184.67,6.86 184.67,7.64 183.86,8.45 182.16,8.45 179.85,10.76 176.7,10.76 175.84,11.63 174.74,11.63 173.76,10.65 170.18,10.65 169.91,10.91 166.95,10.91 166.34,10.3 151.47,10.3 150.69,9.53 141.36,9.53 141.18,9.7 138.97,9.7 138.69,9.43 138.69,9.14 v5(138.53,8.98)
REM_DIODE3_N: length 257.1
  TOP w0.069: UE1.B9 182.94,21.79 182.82,21.91 182.82,23 182.87,23.06
  TOP w0.127: 182.87,23.06 182.87,23.33 183.55,24.02 183.86,24.02 184.14,24.3 184.14,24.63 CE39.1 184.95,25.44 186.98,25.44 187.62,26.08 187.62,26.56 v2(187.68,26.62) ; v5(36.59,62.1) 36.42,61.93 35.9,61.93 35.55,61.58 v7(35.55,46.93) 35.55,41.9 37.53,39.92 37.53,31.79 37.13,31.39 37.13,25.92 38.8,24.25 38.8,21.02 37.4,19.63 37.4,18.56 37.69,18.27 37.69,18.18 v2(37.72,18.15)
  IN1 w0.127: v3(187.47,6.23) 187.34,6.37 187.34,6.5 187.72,6.89 188.18,6.89 188.8,7.5 189.95,7.5 191.71,9.26 191.71,9.85 192.67,10.81 192.67,11.47 192.39,11.75 192.39,12.84 191.66,13.58 191.66,20.44 191.24,20.86 190.78,20.86 190.46,21.18 190.46,21.91 189.8,22.57 189.8,24.33 187.64,26.49 187.64,26.58 v2(187.68,26.62) ; v2(37.72,18.15) 37.8,18.15 43.67,12.29 43.97,12.29 47.05,9.2 69.96,9.2 70.81,10.05 76.75,10.05 77.74,11.04 92.47,11.04 94.32,9.19 95.9,9.19 96.76,8.32 106.03,8.32 106.49,7.87 108.82,7.87 109,7.69 113.09,7.69 113.17,7.61 113.17,7.43 v3(113.06,7.32)
  IN3 w0.127: v4(104.43,13.15) 104.56,13.28 104.97,13.28 109.1,9.14 110.26,7.98 112.9,7.98 113.13,7.75 113.13,7.39 v3(113.06,7.32) 113.2,7.18 113.2,6.85 113.43,6.62 127.09,6.62 128.72,8.25 151.03,8.25 151.94,9.16 166.84,9.16 167.45,9.77 169.05,9.77 169.92,8.9 172.17,8.9 172.69,9.42 175.52,9.42 176.72,8.22 179.01,8.22 182.46,4.77 186.31,4.77 187.31,5.77 187.31,6.07 v3(187.47,6.23)
  BOTTOM w0.127: QE3.1 34.86,61.76 QE3.2 35.45,61.76 35.55,61.66 35.83,61.66 CE60.2 36.26,62.1 v5(36.59,62.1) ; v4(104.43,13.15) 104.46,13.13 QE10.3
REM_DIODE3_P: length 257.7
  TOP w0.069: 182.61,23.06 182.64,23.03 182.64,21.89 182.54,21.79 UE1.B8
  TOP w0.127: v2(37.99,18.42) 37.9,18.42 37.66,18.67 37.66,19.52 39.05,20.92 39.05,24.35 37.38,26.02 37.38,31.29 37.78,31.69 37.78,40.03 35.8,42.01 35.8,61.47 36.01,61.68 36.42,61.68 v5(36.59,61.51) ; v2(187.3,26.62) 187.36,26.56 187.36,26.18 186.88,25.7 184.84,25.7 184.58,25.43 184.02,25.43 CE39.2 183.88,24.57 183.88,24.4 183.75,24.27 183.45,24.27 182.61,23.44 182.61,23.06
  IN1 w0.127: v3(113.59,7.32) 113.42,7.49 113.42,7.71 113.19,7.95 109.1,7.95 108.93,8.12 106.59,8.12 106.14,8.58 96.86,8.58 96,9.44 94.43,9.44 92.57,11.3 77.63,11.3 76.64,10.3 70.71,10.3 69.86,9.45 47.16,9.45 44.07,12.54 43.78,12.54 37.99,18.33 v2(37.99,18.42) ; v3(186.94,6.23) 187.08,6.37 187.08,6.61 187.61,7.14 188.08,7.14 188.69,7.76 189.85,7.76 191.45,9.36 191.45,9.95 192.42,10.92 192.42,11.37 192.14,11.65 192.14,12.74 191.4,13.48 191.4,20.33 191.13,20.6 190.68,20.6 190.21,21.07 190.21,21.81 189.55,22.47 189.55,24.22 187.39,26.38 187.39,26.53 v2(187.3,26.62)
  IN3 w0.127: v3(186.94,6.23) 187.06,6.11 187.06,5.88 186.21,5.02 182.57,5.02 179.11,8.48 176.82,8.48 175.63,9.67 172.58,9.67 172.06,9.15 170.03,9.15 169.15,10.03 167.34,10.03 166.73,9.42 151.83,9.42 150.92,8.51 128.62,8.51 126.98,6.88 113.53,6.88 113.45,6.96 113.45,7.18 v3(113.59,7.32) 113.38,7.53 113.38,7.86 113.01,8.24 110.37,8.24 109.21,9.39 105.07,13.53 104.23,13.53 v4(103.85,13.15)
  BOTTOM w0.127: v5(36.59,61.51) 36.34,61.51 36.11,61.28 CE60.1 35.95,61.28 35.83,61.41 35.55,61.41 35.45,61.31 QE3.3 ; QE10.1 104.01,11.98 QE10.2 104.01,12.99 v4(103.85,13.15)
REM_DIODE4_N: length 4.5
  TOP w0.127: UE1.A11 184.61,22.71 184.61,22.77 184.84,23 185.69,23 186.4,23.72 186.93,23.72 187.54,24.33 187.54,24.73 CE86.1
REM_DIODE4_P: length 5.4
  TOP w0.127: UE1.B10 184.35,22.21 184.35,22.88 184.73,23.26 185.59,23.26 186.3,23.97 186.83,23.97 187.29,24.43 187.29,24.8 CE86.2
RESET_IN#: length 2.2
  TOP w0.069: RE247.2 175,21.12 175.13,20.99 UE1.C1
RING2: length 11.8
  IN3 w1.016: 270.54,63.7 269.3,63.7 265.05,67.95 261.77,67.95 261.2,67.38
  BOTTOM w0.069: v1(260.41,68.07) 260.74,67.73 260.77,67.73
  vias: v4(271.57,62.66) v4(271.57,61.64) v5(260.93,66.49) v5(260.93,65.92)
RING2_CONN: length 9.1
  BOTTOM w0.127: JHP1.6 273.63,64.54 v1(275.38,64.54)
  BOTTOM w0.508: L15.2 272.42,63.33 JHP1.6 274.59,62.72 274.59,62.22 274.59,62.22 DA3.1 274.59,61.66 274.56,61.64 273.91,61.64 CA59.1
RREF: length 5.1
  BOTTOM w0.069: RR1.2 8.45,45.56 8.22,45.79 v1(8.22,46.93)
  BOTTOM w0.203: UCR1.9 10.72,44.31 10.51,44.51
  BOTTOM w0.305: 10.51,44.51 9.34,44.51 8.88,44.98 RR1.2
RSVD_1: length 0.9
  IN1 w0.061: v3(126.56,58.39) 126.56,58.26 v4(126.34,58.04)
  IN3 w0.061: v3(126.56,58.39) 126.56,58.26 v4(126.34,58.04)
RSVD_AA35: length 1
  IN1 w0.061: v2(132.9,42.76) 132.9,42.73 v3(132.47,42.3)
  IN3 w0.061: v3(132.47,42.3) 132.46,42.3 v4(132.14,42.3)
RSVD_L34: length 3.3
  TOP w0.069: v5(127.39,42.37) 127.01,41.98 125.23,41.98 TP67.1
  BOTTOM w0.069: UC1.L34 127.05,42.71 v5(127.39,42.37)
RSVD_M34: length 1.1
  TOP w0.069: v5(128.03,42.37) 128.03,42.23 TP68.1
  BOTTOM w0.069: UC1.M34 127.7,42.69 v5(128.03,42.37)
RSVD_W35: length 0.9
  IN1 w0.061: v2(130.46,41.97) 130.52,41.97 v3(130.9,42.35)
  IN3 w0.061: v3(130.9,42.35) 130.95,42.3 v4(131.22,42.3)
RSVD_Y34: length 1
  IN1 w0.061: v2(131.59,42.61) 131.68,42.7 v3(131.68,43.15)
  IN3 w0.061: v4(131.68,42.76) v3(131.68,43.15)
RT_FORCE_PWR: length 367.8
  TOP w0.069: v2(256.77,41.79) 256.16,41.79 v1(255.84,42.11)
  IN1 w0.061: v3(109.13,30.19) 108.45,29.51 106.85,29.51 104.86,27.52 91.46,27.52 75.5,11.56 70.42,11.56 69.4,10.54 47.61,10.54 38.21,19.94 35.5,19.94 33.47,21.98 33.47,22.28 32.08,23.67 32.08,26.14 30.94,27.28 30.94,30.69 31.51,31.26 31.51,34.43 v3(32.07,34.99) ; v3(257.77,44.52) 256.77,43.51 v2(256.77,41.79)
  IN2 w0.051: v3(162.57,44.09) 161.51,44.09 160.14,42.72 160.14,41.7 158.43,40 157.9,40 156.86,38.96 154.9,38.96 154.45,38.5 154.26,38.5 153.86,38.11 153.86,35.57 149.99,31.69 113.41,31.69 111.91,30.19 v3(109.13,30.19) ; v3(257.77,44.52) 255.77,42.51 255.77,34.99 257.21,33.55 257.21,31.29 255.67,29.75 251.81,29.75 242.57,20.5 241.56,20.5 239.79,18.73 238.35,18.73 236.8,17.18 228.3,17.18 226.92,18.56 212.72,18.56 212.14,19.14 207.3,19.14 201.86,24.59 201.86,27.75 198.97,30.63 198.97,32.56 196.66,34.87 195.52,34.87 191.58,38.8 191.58,40.82 190.59,41.81 190.59,42.37 189.18,43.78 187.62,43.78 187.62,43.78 v3(187.62,43.78)
  IN3 w0.061: v4(270.98,54.04) 270.98,52.09 271.24,51.83 271.24,49.09 270.45,48.3 265.67,48.3 263.73,46.36 259.01,46.36 257.77,45.13 v3(257.77,44.52) ; v3(162.57,44.09) 162.83,43.83 162.83,43.68 163.36,43.15 164.3,43.15 164.53,42.92 165.6,42.92 166.1,43.43 166.54,43.43 167.02,43.91 167.59,43.91 168.05,44.37 168.26,44.37 v4(168.37,44.26) 168.45,44.17 168.93,44.17 169.56,44.8 170.91,44.8 171.19,45.08 172.43,45.08 172.92,44.59 173.18,44.59 173.37,44.4 175.9,44.4 176.38,44.87 176.67,44.87 176.85,44.69 176.85,44.53 177.03,44.35 177.61,44.35 177.83,44.57 180.76,44.57 181.5,45.31 182.35,45.31 183.04,44.63 184.13,44.63 184.97,43.78 v3(187.62,43.78) ; v3(32.07,34.99) 32.93,34.99 34.08,36.14 34.08,39.03 33.71,39.39 v4(33.63,39.39) 33.63,40.92 37.75,45.04 37.75,50.36 38.22,50.82 38.22,59.07 36.67,60.62 32.5,60.62 32.07,60.19 31.26,60.19 v4(31,60.45) 30.87,60.33 30.87,59.81 31.43,59.25 31.43,59 30.1,57.66 29.69,57.66 v4(29.47,57.43)
  BOTTOM w0.069: v4(168.37,44.26) 168.47,44.15 168.47,44.01 168.54,43.93 168.54,43.3 169.13,42.72 UC1.DT34 ; RT6.1 RT109.1
  BOTTOM w0.076: v4(270.98,54.04) 270.92,53.98 270.27,53.98 URT2.B10 ; v4(29.47,57.43) 30.05,57.43 URT1.B10
RT_L_FORCE_PWR: length 1.9
  BOTTOM w0.069: UPD1.43 32.36,38.72 33.04,39.39 RPD130.2
RT_R_FORCE_PWR: length 3
  TOP w0.069: v1(257.01,42.66) 257.01,42.13 RPD138.2 257.37,41.79 257.64,41.51 257.64,41.46 258.04,41.06 UPD2.43
RTCRST_ON: length 24.4
  TOP w0.069: v2(185.15,18.76) 185.05,18.76 184.87,18.59 UE1.F11
  IN1 w0.061: v4(186.73,16.22) 186.71,16.24 185.39,16.24 185.15,16.47 v2(185.15,18.76)
  BOTTOM w0.069: v4(186.73,16.22) 186.73,21.07 187.96,22.3 190.2,22.3 v1(190.29,22.22) 191.42,22.22 191.47,22.17 192.69,22.17 192.85,22.33 193.5,22.33 193.79,22.04 193.79,20.59 193.87,20.52 194.93,20.52 195.07,20.38 197.14,20.38 197.43,20.67 Q3.2 197.43,22.44 RTCR4.1
RTCRST_ON_POWER: length 26.8
  TOP w0.069: v2(184.11,13.38) 183.93,13.2 UE1.N10
  IN1 w0.061: v2(184.11,13.38) 184.32,13.58 184.32,22.67 184.9,23.26 v3(184.9,23.56)
  IN3 w0.061: v4(190.02,26.24) 189.86,26.24 188.83,25.21 187.99,25.21 186.66,23.89 185.23,23.89 v3(184.9,23.56)
  BOTTOM w0.069: R5779.2 196.88,23.93 195.5,23.93 195.25,24.17 194.2,24.17 193.76,24.6 v1(192.57,24.6) 192.55,24.63 192.33,24.63 190.85,26.11 190.15,26.11 v4(190.02,26.24)
RTCRST_ON_R: length 6
  BOTTOM w0.069: v1(200.12,18.97) 200.12,19.42 199.94,19.59 D116.2
  BOTTOM w0.254: Q348.2 202.02,18.97 202.02,20.31 C1132.1 R5769.1 200.38,20.44 199.98,20.03 D116.2
RUN_ON#: length 3.6
  BOTTOM w0.069: QE18.2 154.01,29.18 153.94,29.1 153.43,29.1 153.36,29.17 QE18.3 152.49,29.67 RE87.1 152.4,28.78 v1(152.34,28.72)
RUN_ON_EC: length 20.1
  TOP w0.069: UE1.E8 182.68,19.04 183.3,19.04 183.55,18.79 183.55,18.36 183.81,18.1 187.5,18.1 RE475.2 189.17,18.72 v3(189.17,18.38) 189.4,18.38 v1(189.62,18.16)
  IN3 w0.061: v4(191.88,25.7) 191.85,25.7 189.22,23.07 189.22,18.41 189.19,18.38 v3(189.17,18.38)
  BOTTOM w0.069: v4(191.88,25.7) 191.9,25.72 RE15.1 192.41,25.72 192.88,26.19 193.22,26.19 193.77,25.65 UC4.2
RUN_ON_P: length 414.1
  TOP w0.069: v2(101.16,18.46) 101.16,15.82 102.13,14.85 102.2,14.85 107.15,9.9 v3(107.15,7.43) 107.51,7.43 108.14,6.8 120.33,6.8 120.82,6.32 v1(120.82,5.96) 120.82,3.72 120.79,3.7 R6169.1 120.46,3.04 120.46,1.91 v2(120.55,1.82) ; UZ6.1 173.23,6.13 173.32,6.22 RZ2.1 173.32,7.36 173.04,7.64 173.04,8.61 171.77,9.87 v2(171.77,10.51) ; RC731.1 142.58,65.98 142.33,65.73 142.33,63.67 v2(142.79,63.21)
  IN1 w0.061: v2(97.37,18.81) 97.73,18.46 v2(101.16,18.46) ; v2(142.79,63.21) 143.12,63.21 145.02,61.31 148.05,61.31 148.58,61.84 148.58,62.4 150.38,64.2 153.98,64.2 154.88,65.1 157.01,65.1 157.37,64.74 159.72,64.74 160.12,65.14 163.46,65.14 163.66,64.95 164.71,64.95 165.49,65.72 165.88,65.72 165.93,65.67 167.43,65.67 167.48,65.72 170.35,65.72 v3(170.78,65.3) ; v2(120.55,1.82) 120.42,1.68 95.93,1.68 92.4,5.21 42.6,5.21 41.58,4.19 40.58,4.19 40.11,3.73 39.71,3.73 39.31,3.32 38.7,3.32 37.9,2.52 30.91,2.52 30.32,3.12 v4(26.13,3.12) ; v3(175.73,24.58) 175.73,23.24 175.98,22.99 175.98,16.57 175.1,15.69 175.1,13.72 174.04,12.66 173.64,12.66 172.86,11.88 172.86,11.63 v3(172.26,11.03) 172.26,11 v2(171.77,10.51)
  IN2 w0.051: v3(172.26,11.03) 171.95,10.71 168.36,10.71 166.23,8.58 111.95,8.58 111.42,8.04 107.76,8.04 v3(107.15,7.43) ; v4(220.35,16.68) 220.25,16.78 212.2,16.78 211.47,17.52 206.63,17.52 200.12,24.03 200.12,27.14 197.01,30.25 197.01,30.81 v4(197.01,30.82) 197.01,31.01 197.02,31.01 197.02,31.12 194.5,33.63 194.5,34.19 193.04,35.65 192.1,35.65 191.64,35.2 189.22,35.2 188.5,35.91 186.7,35.91 186.36,36.25 186.36,37.4 185.02,38.74 185.02,40.26 184.19,41.09 184.19,41.56 183.12,42.63 183.12,45.34 183.58,45.8 183.58,50.1 182.28,51.4 182.28,55.13 179.85,57.56 177.22,57.56 173.25,61.53 173.25,62.82 v3(170.78,65.3)
  IN3 w0.061: v3(172.26,11.03) 171.77,11.52 171.77,16.38 171.3,16.85 v4(171.3,18.2) ; v4(196.79,29.51) 196.68,29.61 196.68,30.68 196.82,30.82 v4(197.01,30.82) ; v4(189.83,27.5) 189.68,27.35 189.3,27.35 188.9,26.95 188.7,26.95 188,26.25 187.64,26.25 186.7,25.31 186.12,25.31 185.84,25.03 182.58,25.03 182.49,24.93 178.43,24.93 178.11,25.25 176.4,25.25 v3(175.73,24.58)
  BOTTOM w0.069: R6170.1 197.71,37.23 197.71,34.82 197.5,34.61 196.31,34.61 195.78,34.08 195.78,32.38 195.82,32.33 195.82,32.01 v4(197.01,30.82) ; 193.03,26.64 193.03,26.94 193.12,27.03 UC4.4 193.52,27.84 193.52,28.74 193.79,29.01 193.79,29.18 194.12,29.51 v4(196.79,29.51) ; 193.03,26.64 193.49,26.18 194.83,26.18 195.04,25.98 195.04,25.68 RE14.2 195.54,24.88 195.31,24.66 RE460.2 ; 193.03,26.64 192.57,26.64 RE15.2 192.24,26.31 192.02,26.54 191.98,26.54 191.97,26.54 191.75,26.54 191.74,26.54 190.45,26.54 189.83,27.16 v4(189.83,27.5) ; v4(220.35,16.68) 220.52,16.85 R6199.1 ; QE18.5 154.01,30.88 154.32,30.57 154.9,30.57 155.16,30.32 155.16,29.16 160.28,24.04 170.29,24.04 170.83,23.5 170.83,19.65 171.3,19.19 v4(171.3,18.2)
RUN_ON_P_1P8VS: length 1.2
  BOTTOM w0.069: UC24.3 197.48,38.05 R6170.2
RUN_ON_P_3VS: length 2.4
  TOP w0.069: v1(120.99,1.69) 120.99,2.26 120.79,2.46 R6169.2 121.11,3.11 UC30.3
RUN_ON_P_5VBS: length 1.5
  BOTTOM w0.069: U60.3 221.88,18.16 R6199.2
RUN_ON_P_5VS: length 1.4
  BOTTOM w0.203: UC28.3 26.85,2.97 R6181.2
RUN_ON_P_R: length 5.7
  TOP w0.069: UZ6.4 174.85,4.83 174.23,5.45 RZ2.2 ; UZ6.4 174.98,4.46 175.01,4.44 175.01,4.22 175.25,3.98 175.25,3.8 R81.2 ; UZ6.4 175.47,4.83 175.55,4.75 175.64,4.75 175.8,4.91 175.82,4.91 176.2,5.29 US1.3
RUN_ON_R: length 1.7
  TOP w0.069: RC730.2 RC731.2 143.03,65.59 UC10.2
RUNPWROK: length 8.6
  TOP w0.069: RE448.1 176.04,11.78 177.18,12.92 177.18,13.1 177.43,13.35 177.53,13.35 177.84,13.66 177.84,13.94 178.09,14.19 178.35,14.19 178.35,14.19 178.5,14.19 178.65,14.34 178.65,17.57 178.43,17.79 UE1.G3
S_BIO: length 5.2
  TOP w0.069: v3(165.01,65.73) 165.03,65.74 RH750.1 164.71,66.21 164.48,66.44 v1(164.12,66.44)
  IN3 w0.061: v4(162.55,65.09) 162.73,64.91 164.2,64.91 v3(165.01,65.73)
  BOTTOM w0.069: v4(162.55,65.09) 162.75,64.89 JUFC1.15
SBIOS_TX: length 105.5
  IN2 w0.051: v4(235.29,18.84) 234.43,17.98 227.72,17.98 226.99,18.71 212.79,18.71 212.2,19.3 207.37,19.3 202.01,24.66 202.01,27.81 199.12,30.7 199.12,32.62 196.37,35.37 195.23,35.37 191.73,38.87 191.73,40.88 190.74,41.88 190.74,42.44 189.02,44.15 v3(187.25,44.15)
  IN3 w0.061: v4(168.49,44.95) 168.98,45.43 170.42,45.43 170.98,45.99 172.52,45.99 172.9,45.61 177.32,45.61 177.73,45.2 180.38,45.2 180.96,45.78 182.83,45.78 183.59,45.02 184.69,45.02 184.99,44.72 186.99,44.72 187.26,44.45 187.26,44.15 v3(187.25,44.15)
  BOTTOM w0.069: v4(235.29,18.84) 235.24,18.79 235.24,16.98 237.06,15.17 243.26,15.17 244.13,14.29 244.13,12.79 244.46,12.46 v1(244.46,12.18) 244.4,12.12 RE206.1 ; UC1.DK21 166.08,49.04 166.38,48.73 168.11,48.73 168.49,48.35 v4(168.49,44.95)
SD3_RCOMP: length 0.4
  IN1 w0.305: v2(156.04,38.2) 155.93,38.31 v4(155.72,38.31)
SD_CD#: length 32.2
  IN3 w0.061: v4(18.2,59.81) 19.93,58.08 19.93,44.47 19.43,43.97 19.43,42.95 19.12,42.65 19.12,40.56 18.52,39.96 15.19,39.96 13.83,38.6 12.76,38.6 12.2,39.16 v4(11.65,39.16)
  BOTTOM w0.069: v4(11.65,39.16) 11.52,39.29 UCR1.30 ; v4(18.2,59.81) 18.2,60.19 v1(18.1,60.29) 17.6,59.79 JP1.9
SD_CLK: length 18.1
  IN3 w0.061: v4(18.53,57.29) 17.64,56.41 17.64,51.94 17.71,51.87 17.71,47.53 17.31,47.13 17.31,44.08 v4(17.03,43.8)
  BOTTOM w0.069: RR4.2 v4(17.03,43.8) ; JP1.5 17.06,56.59 17.77,57.29 v4(18.53,57.29) 18.33,57.5 v1(18.33,57.9)
SD_CLK_L: length 5.7
  TOP w0.069: v1(18.8,43.91) 18.69,43.8 v5(15.02,43.8)
  BOTTOM w0.069: RR4.1 v5(15.02,43.8) 14.51,43.29 UCR1.17
SD_CMD: length 17.4
  IN3 w0.061: v4(17.03,42.53) 17.03,43.35 17.58,43.89 17.58,46.94 17.97,47.34 17.97,52.02 17.91,52.09 17.91,54 17.97,54.07 18.25,54.07 18.4,53.92 v4(18.4,53.18)
  BOTTOM w0.069: RR6.2 v4(17.03,42.53) ; v4(18.4,53.18) 17.9,53.18 17.62,53.46 17.62,54.48 17.1,54.99 JP1.3
SD_CMD_L: length 1.7
  BOTTOM w0.069: RR6.1 15.73,42.49 UCR1.19
SD_D2: length 18.6
  IN3 w0.061: v4(17.03,41.26) 17.96,41.26 18.1,41.4 18.1,41.62 18.01,41.71 17.73,41.71 17.64,41.8 17.64,41.93 17.73,42.03 18.01,42.03 18.1,42.12 18.1,42.25 18.01,42.34 17.73,42.34 17.64,42.43 17.64,42.56 17.73,42.66 18.01,42.66 18.1,42.75 18.1,42.88 18.01,42.97 17.73,42.97 17.64,43.06 17.64,43.19 17.73,43.29 18.01,43.29 18.1,43.38 18.1,44.22 18.5,44.61 18.5,52.27 v4(18.43,52.34)
  BOTTOM w0.069: v1(17.33,40.41) 17.03,40.71 v4(17.03,41.26) RR9.2 ; JP1.1 16.77,53.39 17.82,52.34 v4(18.43,52.34)
SD_D2_L: length 1.9
  BOTTOM w0.069: RR9.1 15.33,41.69 UCR1.21
SD_D3: length 17
  IN3 w0.061: v4(18.43,52.75) 18.17,52.49 18.17,52.19 18.23,52.13 18.23,46.86 18.13,46.75 17.94,46.75 17.84,46.65 17.84,46.51 17.93,46.42 18.13,46.42 18.23,46.33 18.23,46.2 18.13,46.11 17.93,46.11 17.84,46.02 17.84,45.88 17.93,45.79 18.13,45.79 18.23,45.7 18.23,45.57 18.13,45.48 17.93,45.48 17.84,45.39 17.84,45.25 17.93,45.16 18.14,45.16 18.23,45.07 18.23,44.94 18.14,44.85 17.93,44.85 17.84,44.76 17.84,43.78 17.34,43.28 17.34,42.2 v4(17.03,41.89)
  BOTTOM w0.069: v4(18.43,52.75) v1(18.05,52.75) 17.91,52.75 17.32,53.34 17.32,53.81 16.94,54.19 JP1.2 ; RR8.2 v4(17.03,41.89)
SD_D3_L: length 1.8
  BOTTOM w0.069: UCR1.20 15.56,42.09 RR8.1
SD_LN0_M: length 20.7
  IN3 w0.056: v4(4.19,44.42) 4.28,44.51 4.28,44.78 4.48,44.98 5.81,44.98 6.19,45.36 8.04,45.36 10.05,43.35 10.05,41.2 10.92,40.33 12.79,40.33 13.43,39.69 13.43,39.28 v4(13.52,39.18)
  BOTTOM w0.058: v4(13.52,39.18) 13.43,39.28 13.43,39.46 13.52,39.56 UCR1.25 ; JP1.14 0.5,47.56 0.8,47.26 0.8,47.03 3.11,44.72 4.22,44.72 4.28,44.66 4.28,44.51 v4(4.19,44.42)
SD_LN0_P: length 19.9
  IN3 w0.056: v4(4.57,44.42) 4.48,44.51 4.48,44.7 4.56,44.77 5.89,44.77 6.27,45.15 7.96,45.15 9.84,43.27 9.84,41.11 10.83,40.12 12.71,40.12 13.22,39.61 13.22,39.27 v4(13.14,39.18)
  BOTTOM w0.058: UCR1.26 13.12,39.57 13.22,39.46 13.22,39.27 v4(13.14,39.18) ; v4(4.57,44.42) 4.48,44.51 4.48,44.75 4.31,44.92 3.19,44.92 1,47.11 1,47.31 1.2,47.51 JP1.13
SD_LN1_M: length 45.7
  IN3 w0.056: v4(1.21,63.85) 1.23,63.85 1.44,64.05 1.44,64.25 1.74,64.56 4.55,64.56 4.83,64.84 16.25,64.84 17.79,63.3 17.79,59.61 19.06,58.34 19.06,43.22 18.76,42.91 18.76,41.17 18.25,40.66 16.02,40.66 15.7,40.98 15.01,40.98 v4(14.91,40.87)
  BOTTOM w0.058: v4(14.91,40.87) 14.82,40.96 14.64,40.96 14.57,40.89 UCR1.23
SD_LN1_P: length 44.8
  IN3 w0.056: v4(14.91,41.25) 14.99,41.18 15.78,41.18 16.1,40.86 18.17,40.86 18.56,41.25 18.56,42.99 18.86,43.3 18.86,58.25 17.59,59.52 17.59,63.21 16.17,64.64 4.92,64.64 4.64,64.36 1.83,64.36 1.64,64.17 1.64,63.97 1.77,63.85 v4(1.89,63.85)
  BOTTOM w0.058: v4(14.91,41.25) 14.82,41.17 14.64,41.17 14.52,41.29 UCR1.22
SD_PWR_EN: length 211.2
  IN1 w0.061: v4(20.44,43.6) 19.85,43.02 19.6,43.02 18.84,42.26 18.84,37.58 22.39,34.03 22.39,32.4 22.12,32.14 22.12,30.38 25.35,27.16 28.96,27.16 31.84,24.27 31.84,23.39 v3(32.53,22.7)
  IN2 w0.051: v3(167.63,53.15) 162.32,53.15 160.49,54.98 156.33,54.98 154.24,57.07 148.71,57.07 146.81,55.16 141.76,55.16 140.76,56.16 140.76,57.05 139.57,58.23 127.39,58.23 125.89,59.73 121.65,59.73 119.49,57.57 111.44,57.57 111.04,57.98 106.66,57.98 104.99,59.66 101.26,59.66 100.55,60.37 98.82,60.37 97.7,59.25 95.14,59.25 92.27,56.38 92.27,53.88 87.92,49.53 87.92,29.93 73.71,15.72 67.71,15.72 67.43,15.44 44.24,15.44 40.23,19.45 38.41,19.45 36.79,21.07 35.48,21.07 34.79,21.76 33.05,21.76 32.53,22.28 v3(32.53,22.7)
  IN3 w0.061: v4(169.61,53.48) 169.28,53.15 v3(167.63,53.15)
  BOTTOM w0.069: UC1.DU12 169.84,53.26 v4(169.61,53.48) ; R6171.1 20.09,43.5 20.19,43.6 v4(20.44,43.6) 21.83,43.6 v1(21.91,43.53)
SD_PWR_EN_R: length 3.3
  BOTTOM w0.069: UC31.4 19.02,42.16 18.72,42.45 18.66,42.45 18.51,42.61 R666.2 R667.2 20.09,42.92 20.22,43.05 v1(20.64,43.05)
SD_RCLK_M: length 17.6
  IN3 w0.056: v4(17.52,58.81) 17.61,58.72 17.9,58.72 18.15,58.47 18.15,57.6 17.16,56.61 17.16,51.86 17.34,51.68 17.34,47.74 16.73,47.13 16.73,45 16.75,44.98 16.82,44.98 v4(17.03,45.19)
  BOTTOM w0.058: v4(17.52,58.81) 17.43,58.72 17.26,58.72 16.99,58.99 JP1.8 ; RR2.2 16.54,45 16.84,45 v4(17.03,45.19)
SD_RCLK_M_L: length 3.6
  BOTTOM w0.058: RR2.1 v7(14.59,45.19) 13.72,45.19 13.22,44.7 13.22,44.42 13.12,44.31 UCR1.15
SD_RCLK_P: length 17.7
  IN3 w0.056: v4(17.52,58.43) 17.61,58.51 17.81,58.51 17.94,58.38 17.94,57.68 16.96,56.69 16.96,51.77 17.14,51.59 17.14,47.83 16.52,47.21 16.52,44.92 16.67,44.78 16.82,44.78 v4(17.03,44.56)
  BOTTOM w0.058: JP1.7 16.91,58.19 17.24,58.51 17.43,58.51 v4(17.52,58.43) ; v4(17.03,44.56) 17.03,44.57 16.8,44.8 16.58,44.8 RR3.2
SD_RCLK_P_L: length 3.5
  BOTTOM w0.058: RR3.1 15.33,44.99 13.8,44.99 13.43,44.61 13.43,44.42 13.52,44.32 UCR1.16
SD_REG2: length 2.9
  BOTTOM w0.069: CR19.1 15.76,39.29 v1(16.04,39.01)
  BOTTOM w0.203: 14.97,40.3 14.78,40.49 UCR1.24
  BOTTOM w0.508: CR19.1 15.42,39.86 14.97,40.3
SECURE_BIO: length 18.5
  TOP w0.069: RH750.2 165.61,65.97 165.8,65.78 166.71,65.78 166.94,66.01 v3(167.12,66.01)
  IN3 w0.061: v3(167.12,66.01) 167.46,66.01 v4(167.79,65.68)
  BOTTOM w0.069: UC1.DU16 169.51,51.85 169.18,52.19 169.18,52.75 168.44,53.48 168.44,58.97 169.13,59.66 169.13,61.41 167.79,62.75 v4(167.79,65.68)
SIO_EXT_WAKE#: length 80.6
  TOP w0.069: v2(196.03,30.7) 196.05,30.7 196.24,30.51 196.24,27.88 198.27,25.86 198.27,22.12 195.64,19.5 195.64,15.87 v1(196.22,15.3) 196.74,14.78 196.74,11.23 193.25,7.74 193.25,7.21 192.31,6.27 191.27,6.27 189.92,4.92 189.19,4.92 189.06,5.05 189.06,5.37 189.22,5.53 189.22,6.32 188.57,6.97 188.57,9.16 188,9.73 188,9.87 RE482.1 ; RC671.2 165.91,48.33 v3(165.74,48.5)
  IN1 w0.061: v2(196.03,30.7) 195.9,30.7 195.53,31.07 195.53,31.73 194.63,32.63 194.63,34.23 193.1,35.76 191.97,35.76 190.79,36.93 190.6,36.93 189.89,37.64 189.21,37.64 188.57,38.28 187.93,38.28 187.67,38.54 185.19,38.54 183.84,39.88 183.84,40.12 183.01,40.96 182.73,40.96 182.2,41.49 181.27,41.49 181.06,41.7 179.96,41.7 178.98,42.68 178.07,42.68 177.53,43.22 177.53,43.73 177.34,43.92 177.05,43.92 176.94,43.81 173.65,43.81 172.02,45.44 171.56,45.44 171.13,45.86 169.07,45.86 168.53,46.4 166.94,46.4 166.76,46.22 165.7,46.22 165.47,46.45 165.47,47.29 165.74,47.56 v3(165.74,48.5)
  IN3 w0.061: v4(166.08,48.16) v3(165.74,48.5)
SIO_EXT_WAKE#_EC: length 4
  TOP w0.069: RE482.2 187.72,11.14 186.02,12.85 186.02,13.3 UE1.M12
SIO_PWRBTN#: length 152.9
  IN1 w0.061: v3(160.82,37.58) 160.86,37.58 v2(161.12,37.32) 161.24,37.2 162.23,37.2 163,36.43 163,35.92 163.78,35.13 163.97,35.13 165.47,33.63 168.73,33.63 169.3,33.06 169.3,32.33 170.54,31.1 170.54,30.87 171.17,30.23 171.17,28.93 172.06,28.05 172.06,27.34 171.95,27.22 171.95,26.36 v3(171.7,26.11)
  IN2 w0.051: v3(171.7,26.11) 171.69,26.11 171.67,26.09 171.67,22.14 171.81,21.99 175.55,21.99 175.97,22.42 177.2,22.42 177.71,21.91 180.35,21.91 181.8,20.46 181.8,19.4 182.67,18.53 184.91,18.53 185.09,18.71 185.8,18.71 186.07,18.44 186.07,17.37 185.66,16.96 185.33,16.96 184.73,16.36 v3(184.73,15.39) ; v4(101.13,72.91) 101.06,72.83 101.06,70.02 102.22,68.86 102.22,65.18 103.37,64.03 103.37,63.51 107.6,59.28 111.73,59.28 112.14,58.87 118.35,58.87 121.23,61.75 133.69,61.75 133.73,61.71 138.88,61.71 139.31,61.28 141.83,61.28 141.98,61.43 148.08,61.43 149.32,60.19 158.12,60.19 159.49,58.82 163.91,58.82 164.33,58.4 167.09,58.4 167.71,57.78 168.98,57.78 171.61,55.15 171.61,50.52 170.88,49.79 170.88,48.23 168.59,45.94 168.59,45.07 167.41,43.88 167.22,43.88 165.14,41.8 163.4,41.8 161.94,40.34 161.94,39.59 161.46,39.11 161.46,38.52 161.1,38.17 161.1,37.86 v3(160.82,37.58)
  BOTTOM w0.069: v4(101.13,72.91) 101.34,73.12 101.99,73.12 102.15,73.27 R257.1
SIO_PWRBTN#_R: length 1.3
  IN1 w0.061: v3(160.81,38.56) 160.81,38.21 v2(161.12,37.91)
  IN3 w0.061: v4(161.21,38.96) v3(160.81,38.56)
SIO_SLP_A#: length 38
  TOP w0.069: v1(192.42,24.99) 192.75,24.66 193.39,24.66 v3(193.43,24.62) 193.43,24.36 193.94,23.85 JAPS1.6
  IN2 w0.051: v3(193.43,24.62) 193.39,24.66 192.86,24.66 190.6,26.92 188.19,26.92 186.72,28.39 185.57,28.39 184.43,29.54 180.58,29.54 179.97,30.14 176.18,30.14 174.94,31.39 172.43,31.39 v3(172.12,31.08)
  IN3 w0.061: v4(165.37,34.76) 166.05,34.76 167.38,33.43 169.85,33.43 171.37,31.92 171.72,31.92 v4(171.99,31.65) 172.12,31.51 v3(172.12,31.08)
  BOTTOM w0.069: v4(165.37,34.76) 165.57,34.97 165.57,35.43 165.49,35.5 165.49,35.7 165.57,35.78 165.57,36.33 UC1.DH47 ; v4(171.99,31.65) 171.99,31.04 RH685.2
SIO_SLP_S0#: length 72.1
  TOP w0.069: v3(170.98,40.48) v1(170.21,39.71) 168.74,39.71 165.07,36.04 162.04,36.04 161.61,36.48 158.23,36.48 157.31,37.4 RH689.2 v4(156.67,37.62) ; v3(193.34,34.69) 193.34,33.98 191.45,32.1 191.45,29.66 192.77,28.35 JAPS1.15
  IN2 w0.051: v3(193.34,34.69) 193.34,35.14 192.98,35.5 192.16,35.5 191.7,35.04 189.15,35.04 188.44,35.76 186.64,35.76 186.21,36.19 186.21,37.34 184.87,38.67 184.87,39.73 v4(184.37,40.24) 184.34,40.26 184.34,40.33 184.04,40.63 184.04,41.5 181.24,44.29 181.24,45.13 182.3,46.18 182.3,47.04 v4(182.23,47.11)
  IN3 w0.061: v3(170.98,40.48) 171,40.46 172.62,40.46 172.96,40.12 175.4,40.12 175.66,39.86 175.79,39.86 177.25,41.32 180.56,41.32 181.22,40.66 181.32,40.66 181.9,40.07 184.2,40.07 v4(184.37,40.24)
  BOTTOM w0.069: v4(184.37,40.24) 184.34,40.26 184.34,40.33 183.83,40.84 183.14,40.84 182.77,41.21 R649.2 182.84,41.67 R54.1 ; UC1.CL45 156.6,37.55 v4(156.67,37.62) ; R747.1 186.81,46.14 186.25,46.7 186.12,46.7 185.94,46.88 184.54,46.88 184.37,47.06 182.28,47.06 v4(182.23,47.11)
SIO_SLP_S3#: length 201
  TOP w0.069: JAPS1.2 194.79,21.85 194.91,21.96 194.91,23.87 195.42,24.38 v5(195.56,24.38) ; v2(120.06,65.29) 120.11,65.33 120.11,67.3 120.47,67.67 141.18,67.67 141.44,67.4 v3(141.44,67.23) 141.92,66.74 v1(142.41,66.74) 144.45,66.74 144.86,66.34 144.86,65 144.38,64.52 143.44,64.52 143.13,64.2 RC730.1
  IN1 w0.061: v3(109.95,61.92) 111.72,61.92 112.76,60.88 115.65,60.88 v2(120.06,65.29) ; v4(172.58,26.81) 172.39,27.01 172.39,28.18 171.5,29.07 171.5,30.37 170.86,31 170.86,31.48 v3(170.35,32)
  IN2 w0.051: v3(141.44,67.23) 141.87,67.66 146.15,67.66 146.65,67.15 148.7,67.15 149.21,67.66 168.97,67.66 173.41,63.23 173.41,61.59 177.29,57.71 179.92,57.71 182.61,55.02 v4(182.61,51.54) 182.61,51.43 184.42,49.62 184.42,45.66 183.66,44.9 183.66,43.96 184.01,43.6 184.01,42.79 184.49,42.31 184.49,41.22 184.99,40.72 185.64,40.72 186.74,39.62 187.86,39.62 188.38,39.1 188.38,38.09 189.62,36.85 v3(189.62,36.09)
  IN3 w0.061: v3(109.95,61.92) 109.95,61.54 v4(109.69,61.28) ; v4(163.75,35.15) 163.93,34.97 164.04,34.97 164.68,34.32 166.03,34.32 167.25,33.11 169.72,33.11 170.09,32.73 170.09,32.25 v3(170.35,32) 170.5,32 v4(170.85,31.65) 170.85,31.45 171.55,30.75 172.94,30.75 173.48,30.21 174.3,30.21 174.39,30.3 175,30.3 175.76,29.54 180.93,29.54 181.63,30.23 184.85,30.23 v4(184.88,30.21) 184.89,30.22 185.38,30.22 185.66,30.5 187.62,30.5 189.85,32.73 189.85,35.86 v3(189.62,36.09)
  BOTTOM w0.069: v4(172.58,26.81) 171.06,26.81 169.36,25.11 162.31,25.11 159.42,28 158.47,28 157.19,29.28 157.19,30.25 QE15.2 ; v4(163.75,35.15) 163.71,35.19 163.71,36.19 UC1.DF47 ; UC4.1 194.27,25.39 RE460.1 ; RE460.1 194.1,24.66 193.75,25.01 192.2,25.01 190.89,26.31 190.35,26.31 189.57,27.09 189.57,28.15 189.48,28.23 185.75,28.23 184.95,29.03 184.95,30.13 v4(184.88,30.21) ; RE460.1 194.27,24.58 194.51,24.34 195.52,24.34 v5(195.56,24.38) ; v4(170.85,31.65) 170.77,31.57 RH683.2 ; v4(182.61,51.54) 182.21,51.14 182.21,51 180.83,49.62 179.8,49.62 179.4,50.02 UC7.1
SIO_SLP_S4#: length 62.7
  TOP w0.069: JAPS1.5 193.75,23.35 193.48,23.62 192.53,23.62 v5(192.36,23.45) 192.12,23.69 v1(191.86,23.69) ; v2(187.14,11.24) 187.14,11.38 UE1.N12
  IN1 w0.061: v3(187.27,23.2) 187.11,23.04 187.11,18.79 186.68,18.36 186.68,17.68 187.16,17.2 187.16,16.01 188.05,15.11 188.05,12.16 v2(187.14,11.24)
  IN2 w0.051: v3(172.4,30.41) 172.41,30.41 172.9,30.9 174.99,30.9 176.05,29.84 179.84,29.84 180.99,28.69 184.84,28.69 185.45,28.08 186.59,28.08 188.06,26.61 189.68,26.61 189.95,26.34 v3(189.95,25.58) 190.86,25.58 192.36,24.08 v5(192.36,23.45)
  IN3 w0.061: v4(162.85,35.93) 162.85,35.08 163.19,34.73 163.65,34.73 164.39,34 165.9,34 167.11,32.78 168.6,32.78 v4(168.7,32.69) 169.16,32.69 171.33,30.51 172.03,30.51 172.13,30.41 v3(172.4,30.41) ; v3(189.95,25.58) 189.71,25.58 187.43,23.29 187.36,23.29 v3(187.27,23.2)
  BOTTOM w0.069: v5(192.36,23.45) 192.09,23.18 RC695.1 192.42,22.9 192.44,22.93 192.95,22.93 193.13,23.11 UC5.1 ; v4(168.7,32.69) 169.18,32.2 169.18,32.03 CH54.2
  BOTTOM w0.081: RH684.2 CH54.2
SIO_SLP_S5#: length 39.5
  TOP w0.069: JAPS1.4 193.67,22.85 v1(193.18,23.33) 193.08,23.33 192.86,23.12 v3(192.81,23.12)
  IN2 w0.051: v3(192.81,23.12) 192.81,24.32 190.36,26.76 188.13,26.76 186.65,28.24 185.51,28.24 184.36,29.39 180.51,29.39 179.91,29.99 176.12,29.99 174.87,31.23 173.01,31.23 172.53,30.75 171.99,30.75 171.67,31.07 v3(171.67,31.34)
  IN3 w0.061: v4(164.4,34.97) 164.4,34.89 164.81,34.49 166.1,34.49 167.32,33.27 169.78,33.27 171.41,31.65 v4(171.42,31.65) 171.42,31.59 v3(171.67,31.34)
  BOTTOM w0.069: RH691.2 171.42,31.04 v4(171.42,31.65) ; UC1.DF45 164.4,36.94 v4(164.4,34.97)
SIO_SLP_SUS#: length 372.9
  TOP w0.069: v1(254.45,53.59) 254.73,53.31 v3(254.73,52.52)
  IN1 w0.061: v3(174.08,30.55) 175.06,30.55 176.18,29.43 176.18,27.83 176.53,27.48 176.77,27.48 177.31,26.94 177.31,24.38 176.72,23.79 v4(176.72,23.49)
  IN2 w0.051: v3(246.74,16.07) 246.84,16.18 247.11,16.18 247.49,16.55 247.49,16.83 250.58,19.92 250.58,22.7 255.74,27.86 255.87,27.86 256.56,28.55 257.99,28.55 258.57,29.13 258.57,33.89 256.94,35.52 256.94,40.46 258.05,41.57 258.18,41.57 258.92,41.57 259.73,42.38 259.73,44.75 259.96,44.98 259.96,46.04 259.78,46.22 258.13,46.22 254.93,49.42 254.93,52.32 v3(254.73,52.52) ; v4(23.74,49) 24.35,48.39 24.35,46.75 27.89,43.21 29.59,43.21 31.46,41.34 31.46,39.64 33.08,38.02 33.08,31.51 30.01,28.44 30.01,19.75 30.98,18.79 30.98,17.61 31.59,17 31.59,15.78 30.98,15.17 30.98,12.12 30.37,11.51 30.37,6.9 32.35,4.92 33.27,4.92 33.75,5.4 35.95,5.4 36.49,4.87 38.33,4.87 38.94,5.48 40.11,5.48 40.84,6.21 40.84,6.63 41.65,7.45 42,7.45 42.15,7.59 62.38,7.59 62.84,7.13 74,7.13 74.55,7.69 80.23,7.69 80.74,7.18 93.25,7.18 94.57,5.86 104.9,5.86 105.11,6.06 107.94,6.06 108.86,6.99 114.46,6.99 115.13,7.66 169.71,7.66 171.09,9.05 173.92,9.05 174.4,8.56 176.56,8.56 177.85,9.85 v3(178.14,9.85)
  IN3 w0.061: v4(168.52,33.85) 168.56,33.85 168.82,33.6 169.92,33.6 171.43,32.08 172.12,32.08 v4(172.56,31.65) 173.63,30.57 174.05,30.57 v3(174.08,30.55) ; v3(246.74,16.07) 246.53,15.86 246.53,14.55 246.98,14.1 246.98,11.87 246.29,11.17 246.29,10.51 244.91,9.14 243.79,9.14 243.35,8.7 242.8,8.7 239.73,5.64 230.38,5.64 229.08,6.94 226.26,6.94 225.09,5.77 216.93,5.77 216.71,5.99 207.59,5.99 207.23,5.64 198.13,5.64 197.43,4.93 197.07,4.93 196.12,3.98 193.89,3.98 193.5,4.37 192.24,4.37 191.96,4.65 191.44,4.65 190.95,4.15 189.2,4.15 188.66,4.69 188.66,5.83 187.55,6.94 186.22,6.94 184.11,9.05 182.41,9.05 180.06,11.4 v4(177.81,11.4) ; v3(178.14,9.85) v4(177.81,9.85)
  BOTTOM w0.069: UC1.DM49 167.93,35.61 168.06,35.48 168.06,35.04 168.52,34.59 v4(168.52,33.85) ; v4(176.72,23.49) 176.72,16.32 177.05,15.99 177.05,11.07 176.37,10.38 176.37,9.8 176.62,9.54 177.51,9.54 v4(177.81,9.85) v4(177.81,11.4)
  BOTTOM w0.081: RC699.1 RH686.2 172.48,31.57 v4(172.56,31.65)
SIO_SLP_SUS#_EC: length 2.6
  TOP w0.069: RE115.2 178.14,10.97 179.13,11.95 UE1.N4
SIO_SLP_WLAN#: length 86.6
  TOP w0.069: v2(166.36,8.81) 166.38,8.79 166.38,8.61 165.77,8 164.69,8 164.63,8.06 163.2,8.06 162.7,7.56 162.27,7.56 v1(162.26,7.56) 161.74,7.03 161.74,5.86 161.99,5.61 163.08,5.61 163.16,5.68 163.16,5.95 Q350.3
  IN1 w0.061: v4(169.65,32.67) 170.01,32.31 170.01,31.86 170.7,31.16 170.7,30.94 171.34,30.3 171.34,29 172.23,28.11 172.23,26.59 172.58,26.23 173.54,26.23 173.86,25.91 173.86,20.93 173.31,20.38 173.31,17.68 173.04,17.42 v3(173.04,15.79) 172.19,14.94 172.19,12.79 170.17,10.76 169.7,10.76 168.61,9.67 167.53,9.67 166.64,8.78 166.38,8.78 v2(166.36,8.81)
  IN3 w0.061: v4(163.42,34.99) 163.54,34.99 163.64,34.9 163.72,34.9 164.45,34.16 165.97,34.16 167.18,32.95 169.43,32.95 169.65,32.72 v4(169.65,32.67) ; v4(193.16,5.38) 192.77,5.76 190.02,5.76 188.67,7.11 188.67,7.29 187.95,8.01 187.54,8.01 186.96,7.43 186.42,7.43 183.68,10.17 182.97,10.17 181.03,12.12 177.35,12.12 173.67,15.79 v3(173.04,15.79)
  BOTTOM w0.069: v4(193.16,5.38) 193.18,5.4 193.18,6.7 193.29,6.8 194.71,6.8 195.86,6.57 198.09,6.57 199.68,8.17 201.59,8.17 201.81,8.39 201.81,8.8 201.23,9.38 Q124.1 ; CH52.2 169.91,32.01 169.91,32.5 169.75,32.67 v4(169.65,32.67) ; v4(163.42,34.99) 163.42,35.56 UC1.DE49
  BOTTOM w0.081: RH682.2 170.27,31.04 CH52.2
SLEEVE: length 1
  BOTTOM w0.127: v1(259.43,66.81) 259.75,66.49 v5(260.29,66.49)
  vias: v3(274.9,68.18) v3(275.65,68.18) v4(274.9,68.18) v4(275.65,68.18) v5(260.29,65.92)
SLEEVE_CONN: length 3.2
  TOP w0.127: v1(278.91,68.12) 278.58,68.12 v5(278.16,68.53)
  BOTTOM w0.127: CA58.1 277.03,67.4 v5(278.16,68.53)
SLP_VCCST_MIPI60_OVRD: length 3.7
  TOP w0.069: v3(180.9,47.95) 180.86,47.98 180.86,48.31 181.01,48.46 RC626.1 RC623.2
  IN3 w0.061: v3(180.9,47.95) 180.68,47.73 180.64,47.73 v4(180.35,47.44)
  BOTTOM w0.069: v4(180.35,47.44) 180,47.08 179.67,47.08 179.52,46.93 UC9.1
SLP_VCCST_OVRD: length 2.5
  TOP w0.069: UC8.3 180.41,47.73 180.53,47.62 180.76,47.62 v2(181.19,47.19)
  IN1 w0.061: v2(181.19,47.19) v4(180.94,47.44)
  BOTTOM w0.069: UC7.4 180.7,47.68 v4(180.94,47.44)
SLP_WLAN#_GATE: length 26.5
  TOP w0.069: v2(186.09,9.73) 186.18,9.73 186.55,10.1 RE476.1
  IN1 w0.061: v2(186.09,9.73) 186.2,9.63 186.2,9.48 186.78,8.9 186.78,8.57 185.95,7.74 185.95,7.59 185.34,6.98 185.34,6.14 185.72,5.77 187.58,5.77 188.11,6.29 188.43,6.29 189.05,6.9 192.52,6.9 v4(193.18,7.56)
  BOTTOM w0.069: v4(193.18,7.56) v1(193.56,7.18) 194.42,7.18 195.11,6.9 195.88,6.74 197.95,6.74 199.55,8.34 201.47,8.34 201.64,8.51 201.64,8.73 200.71,9.66 200.71,10.25 R322.2 200.55,10.71 200.99,10.71 Q124.2
SLP_WLAN#_GATE_R: length 5.9
  TOP w0.069: RE476.2 186.55,10.97 185.76,11.75 185.53,11.75 184.42,12.87 184.42,14.9 UE1.K10
SLP_WLAN#_M: length 2.5
  BOTTOM w0.069: Q124.3 201.46,10.96 201.87,11.37 R616.2 201.87,12.03 RE321.1 201.59,12.31 D23.2
SMB_CLK: length 106.8
  IN1 w0.061: v3(100.93,58.87) 101.26,59.2 103.27,59.2 108.32,64.25 109.07,64.25 110.01,65.19 110.01,68.77 109.15,69.63 107.46,69.63 104.8,72.29 103.67,72.29 102.18,73.78 102.18,74.28 102.89,74.98 102.89,75.07 v4(102.71,75.25) ; v2(165.82,46.51) 165.9,46.59 v4(166.34,46.59)
  IN3 w0.061: v3(100.93,58.87) 101.28,58.51 101.28,56.81 106.29,51.8 111.39,51.8 111.62,51.57 124.16,51.57 124.51,51.22 127.08,51.22 127.53,50.77 134.39,50.77 136,52.38 138.63,52.38 139.06,52.8 164.26,52.8 164.9,52.17 166.14,52.17 167.52,50.78 167.77,50.78 168.05,50.5 168.05,49.91 168.42,49.55 168.42,49.01 168.72,48.7 168.72,48.3 167.58,47.16 167.17,47.16 166.94,46.93 166.68,46.93 v4(166.34,46.59)
  BOTTOM w0.069: UC1.DK27 v4(166.34,46.59)
SMB_CLK_MIPI60: length 3.5
  TOP w0.069: JMIPI60.48 102.38,72.72 102.54,72.87 102.54,73.2 102.88,73.55 102.88,73.88 v4(102.71,74.06)
  BOTTOM w0.069: R725.1 102.83,74.54 102.83,74.19 v4(102.71,74.06)
SMB_DATA: length 106.1
  IN1 w0.061: v4(103.26,75.25) 103.08,75.07 103.08,74.91 102.37,74.2 102.37,73.86 103.75,72.48 104.87,72.48 107.54,69.81 109.23,69.81 110.19,68.85 110.19,65.11 109.15,64.07 108.4,64.07 103.2,58.87 v3(101.56,58.87)
  IN3 w0.061: v3(101.56,58.87) 101.56,56.8 106.38,51.99 111.47,51.99 111.7,51.76 124.24,51.76 124.59,51.41 127.16,51.41 127.6,50.96 134.31,50.96 135.92,52.57 138.56,52.57 138.98,52.99 164.34,52.99 164.98,52.36 166.22,52.36 167.6,50.97 167.84,50.97 168.24,50.58 168.24,49.99 168.6,49.63 168.6,49.08 168.91,48.78 168.91,48.22 167.66,46.97 167.25,46.97 167.04,46.77 v4(167.04,46.63)
  BOTTOM w0.069: UC1.DP24 167.64,46.86 167.27,46.86 v4(167.04,46.63)
SMB_DATA_MIPI60: length 3.6
  TOP w0.069: v4(103.26,74.06) 103.08,73.87 103.08,73.47 102.73,73.12 102.73,72.86 102.88,72.71 JMIPI60.50
  BOTTOM w0.069: R726.1 103.11,74.52 103.11,74.21 v4(103.26,74.06)
SMC_ONOFF_MIPI60_N: length 4.3
  TOP w0.069: JMIPI60.40 100.38,72.73 v5(100.61,72.95)
  BOTTOM w0.069: v1(100.06,73.27) 100.29,73.27 v5(100.61,72.95) 100.98,73.32 C285.1 101.46,74.06 R267.1 R257.2
SML0_SMBCLK: length 372.8
  IN1 w0.061: v4(166.29,47.58) 166.29,47.26 v2(166.45,47.09)
  IN3 w0.061: v4(32.7,25.34) 32.61,25.25 32.61,23.47 35.44,20.64 36.26,20.64 44.24,12.65 75.41,12.65 81.73,18.98 82.73,18.98 91.75,28 91.75,46.06 94.61,48.92 95.91,48.92 96.53,48.3 100.64,48.3 102.17,49.84 115.84,49.84 115.93,49.93 121.48,49.93 122.33,49.09 123.87,49.09 124.35,48.61 134.9,48.61 136.99,50.7 163.13,50.7 164.62,49.22 164.62,48.46 165.19,47.88 165.76,47.88 166.06,47.58 v4(166.29,47.58) 165.93,47.22 165.93,46.53 166.21,46.25 167.15,46.25 167.4,46.5 168.89,46.5 169.37,46.98 174.46,46.98 174.85,46.59 176.94,46.59 177.53,47.19 177.72,47.19 v4(177.91,47.37) 178.1,47.18 178.22,47.18 178.43,46.97 178.43,46.07 178.66,45.84 180.13,45.84 180.68,46.39 183.09,46.39 183.85,45.64 185.55,45.64 185.85,45.33 187.25,45.33 188.74,43.84 188.74,43.05 188.86,42.92 189.68,42.92 191.08,41.52 191.92,41.52 195.56,37.87 195.56,37.67 198.74,34.49 198.74,31.76 198.27,31.28 198.27,23.7 195.08,20.51 195.08,15.76 195.03,15.71 195.03,14.92 196.33,13.62 204.28,13.62 206.6,15.94 223.38,15.94 224.09,16.65 237.61,16.65 241.23,20.26 241.66,20.26 243.97,22.57 244.39,22.57 244.78,22.96 245.11,22.96 250.17,28.02 253.59,28.02 254.63,29.06 255.97,29.06 257.87,30.96 257.87,33.69 256.17,35.4 256.17,45.95 257.8,47.58 257.8,52.77 258.33,53.31 261.37,53.31 261.46,53.4 261.46,54.11 262.22,54.87 263.87,54.87 264.27,54.47 264.27,54.06 264.85,53.48 266.07,53.48 267.17,54.59 271.19,54.59 272.39,53.38 272.39,52.99 v4(272.84,52.54)
  BOTTOM w0.069: UC1.DK24 166.08,47.38 v4(166.29,47.58) ; v4(32.7,25.34) 32.59,25.44 32.59,25.56 32.66,25.63 34.18,25.63 36.26,27.7 36.26,40.05 v7(37.1,40.89) 37.53,41.32 37.53,45.56 37.78,45.81 37.78,47.44 37.56,47.66 36.63,47.66 RT159.2
SML0_SMBDATA: length 373.1
  IN3 w0.061: v4(272.84,50.83) 272.15,51.51 272.15,53.36 271.11,54.4 267.25,54.4 266.15,53.3 264.77,53.3 264.08,53.98 264.08,54.39 263.79,54.68 262.29,54.68 261.64,54.03 261.64,53.32 261.45,53.12 258.41,53.12 257.99,52.7 257.99,47.5 256.36,45.87 256.36,35.47 258.06,33.77 258.06,30.88 256.05,28.87 254.71,28.87 253.67,27.83 250.24,27.83 245.19,22.78 244.85,22.78 244.46,22.39 244.05,22.39 241.74,20.07 241.3,20.07 237.69,16.46 224.17,16.46 223.45,15.75 206.68,15.75 204.36,13.43 196.26,13.43 194.84,14.84 194.84,15.79 194.89,15.84 194.89,20.59 198.08,23.77 198.08,31.36 198.55,31.84 198.55,34.42 195.38,37.59 195.38,37.8 191.84,41.33 191,41.33 189.6,42.73 188.78,42.73 188.55,42.97 188.55,43.77 187.17,45.15 185.77,45.15 185.47,45.45 183.77,45.45 183.01,46.21 180.76,46.21 180.2,45.65 178.59,45.65 178.25,45.99 178.25,46.89 178.14,46.99 178.1,46.99 v4(177.91,46.8) 177.71,47 177.61,47 177.02,46.4 174.77,46.4 174.38,46.79 169.45,46.79 168.96,46.31 167.48,46.31 167.22,46.06 166.13,46.06 165.74,46.45 165.74,47.45 v4(165.69,47.51) 165.5,47.69 165.11,47.69 164.43,48.38 164.43,49.14 163.06,50.51 137.07,50.51 134.98,48.42 124.27,48.42 123.79,48.9 122.25,48.9 121.4,49.75 116.01,49.75 115.92,49.65 102.25,49.65 100.71,48.12 96.46,48.12 95.84,48.73 94.69,48.73 91.94,45.98 91.94,27.92 82.8,18.79 81.81,18.79 75.48,12.46 44.17,12.46 36.18,20.45 35.36,20.45 32.42,23.39 32.42,25.24 v4(32.32,25.34)
  BOTTOM w0.069: UC1.DJ24 v4(165.69,47.51) ; RT160.2 36.63,47.47 37.48,47.47 37.59,47.36 37.59,45.9 37.33,45.64 v7(37.33,44.11) 37.33,41.4 36.06,40.13 36.06,27.78 34.1,25.82 32.58,25.82 32.4,25.64 32.4,25.42 v4(32.32,25.34)

# Allegro board LAH811PR10-1121.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LINE2-L: length 9.2
  TOP w0.127: v2(260.62,69.39) 260.08,69.39 v1(258.59,67.89)
  TOP w0.203: v2(258.13,65.22) 258.41,64.95 UA1.36
  IN1 w0.381: v2(258.13,65.22) 258.13,65.96 259.04,66.87 259.04,68.57 259.86,69.39 v2(260.62,69.39)
LINE2-R: length 9
  TOP w0.127: v1(263.89,68.85) 263.39,69.36 v2(262.65,69.36)
  TOP w0.203: v2(258.83,65.48) 258.81,65.45 UA1.35
  IN1 w0.381: v2(262.65,69.36) 262.01,68.72 260.26,68.72 259.68,68.14 259.68,66.32 v2(258.83,65.48)
LX_0.6V: length 1
  TOP w0.508: PR804.1 203.42,43.63 v5(203.93,44.14)
LX_5V: length 12.6
  TOP w0.508: PR410.1 18.92,18.27 v5(18.94,18.25)
  IN1 w0.203: v5(18.94,18.25) 20.23,16.96 25.69,16.96 v4(26,17.26)
  BOTTOM w0.508: PC400.2 20.75,16.44 v5(18.94,18.25)
LX_5VB:
  vias: v5(270.57,22.75) v5(271.18,22.75)
M_0_ALERT_N: length 4.1
  BOTTOM w0.069: UC1.BD46 143.73,36.64 143.73,36.38 143.85,36.26 143.85,33.16 RH11.1
M_1_ALERT_N: length 2.2
  BOTTOM w0.069: RH13.2 127.77,33.17 UC1.M49
M_BIST: length 68.2
  TOP w0.069: UE1.N8 182.33,12.04 183.11,11.26 184.01,11.26 184.18,11.09 184.18,10.09 184.77,9.51 185.6,9.51 185.82,9.28 185.82,9 186.32,8.5 187.24,8.5 187.44,8.3 187.44,7.08 188.62,5.9 188.62,4.4 v1(188.84,4.18) 188.84,4.03 189.09,3.78 189.65,3.78 189.9,3.52 v2(189.98,3.52)
  IN1 w0.061: v3(190.46,3.45) 190.06,3.45 v2(189.98,3.52)
  IN2 w0.051: v3(190.46,3.45) 190.56,3.55 192.01,3.55 192.42,3.95 196.21,3.95 198.06,5.8 198.63,5.8 198.89,6.06 225.32,6.06 225.98,6.72 226.84,6.72 v3(227.27,6.29)
  IN3 w0.061: v3(227.27,6.29) v4(228.99,6.29)
  BOTTOM w0.069: R273.1 226.91,14.88 230.19,14.88 230.52,14.55 230.52,13.48 229.66,12.62 229.66,6.95 v4(228.99,6.29)
M_BITS_R: length 6.6
  BOTTOM w0.069: R283.2 225.82,14.52 225.41,14.11 225.41,13.8 D481.2 ; R283.2 226,14.55 R273.2 225.95,15.21 225.88,15.28 R272.2 C92.1 225.49,16.38 225.33,16.21 224.86,16.21 224.84,16.19 QE25.2 ; R283.2 v1(228,14.52)
MBP2#: length 2.1
  TOP w0.069: v5(129.39,54.13) 129.1,54.42 v1(129.1,54.55) 129.28,54.74 RC723.2
  BOTTOM w0.069: UC1.T10 129.8,54.39 129.54,54.13 v5(129.39,54.13)
MBP3#: length 0.9
  IN1 w0.061: v2(130.05,56.49) 130.03,56.49 v4(129.76,56.76)
  BOTTOM w0.069: UC1.T6 129.76,56.43 v4(129.76,56.76)
ME_FWP: length 37.7
  TOP w0.069: v2(160.97,32.54) v1(162.45,32.54)
  IN1 w0.061: v2(160.97,32.54) 164.4,32.54 165.19,31.74 167.71,31.74 168.77,30.68 168.77,28.85 169.69,27.93 169.69,26.63 v3(169.63,26.56) ; v2(185.53,17.79) v3(185.53,17.44)
  IN2 w0.051: v3(169.63,26.56) 169.63,26.12 171.31,24.43 171.31,22.14 171.61,21.84 175.61,21.84 175.93,22.17 177.24,22.17 178.61,20.79 180.09,20.79 182.5,18.38 184.98,18.38 185.15,18.56 185.74,18.56 185.92,18.38 185.92,17.83 v3(185.53,17.44)
ME_FWP_PCH: length 1.6
  TOP w0.069: RH218.2 160.99,33.15 RH217.1 161.71,33.81 v1(161.84,33.68)
ME_RESET#: length 3
  TOP w0.069: UC29.2 171.56,54.44 171.29,54.17 170.65,54.17 170.4,54.42 170.4,54.5 RC434.2 RC433.2
MEC_XTAL1: length 5.5
  TOP w0.069: UE1.A1 175.3,24.02 CE66.1 173.22,24.02 172.78,23.59 YE2.1
MEC_XTAL2: length 4.1
  TOP w0.069: RE178.2 CE89.1 175.12,24.73 173.35,24.73 YE2.2
MEC_XTAL2_R: length 3
  TOP w0.069: UE1.A3 178.33,23 177.38,23.94 RE178.1
MEDIACARD_IRQ#: length 3.1
  TOP w0.069: RH645.2 155.99,33.42 RC682.2 156.08,34.69 v3(156.2,34.69)
  IN3 w0.061: v3(156.2,34.69) 156.05,34.69 155.45,35.28 v4(155.34,35.28)
MEDIACARD_IRQ#_R: length 173.7
  TOP w0.069: v2(156.54,34.23) 156.32,34.01 RH645.1
  IN1 w0.061: v3(156.91,34.23) v2(156.54,34.23) ; v3(107.63,28.8) 106.92,28.08 105.88,28.08 104.99,27.19 91.6,27.19 75.64,11.23 70.32,11.23 69.47,10.38 47.54,10.38 38.31,19.62 35.36,19.62 33.9,21.07 33.07,21.07 31.5,22.65 31.5,24.38 28.89,26.99 25.26,26.99 21.96,30.29 21.96,32.21 22.22,32.47 22.22,33.87 19.55,36.54 14.92,36.54 12.03,39.44 11.56,39.44 v3(11.43,39.57)
  IN2 w0.051: v3(107.63,28.8) 108.01,28.41 109.43,28.41 109.81,28.8 112.03,28.8 113.83,30.6 151.58,30.6 155.21,34.23 v3(156.91,34.23)
  IN3 w0.061: v4(11.27,39.11) 11.27,39.4 v3(11.43,39.57)
  BOTTOM w0.069: RR12.1 10.69,39.03 10.78,39.11 v4(11.27,39.11)
MEM_CONFIG0: length 11.4
  TOP w0.069: RH612.2 RH129.1 v3(176.65,46.96)
  IN3 w0.061: v3(176.65,46.96) 176.19,46.96 175.45,47.7 174.63,47.7 174.3,47.36 169.21,47.36 168.72,46.88 v4(168.19,46.88)
  BOTTOM w0.069: UC1.DP27 v4(168.19,46.88)
MEM_CONFIG1: length 7.7
  TOP w0.069: RH613.2 RH139.1 174.79,44.9 v4(174.79,44.9) 174.79,44.62 v1(174.61,44.44)
  BOTTOM w0.069: v4(174.79,44.9) 174.79,45.2 174.34,45.65 171.76,45.65 171.13,45.03 169.85,45.03 UC1.DU30
MEM_CONFIG2: length 9.5
  TOP w0.069: RH614.2 176.68,45.41 RH145.1 176.37,45.09 v2(176.37,44.98)
  IN1 w0.061: v2(176.37,44.98) 176.36,44.97 v3(175.76,44.97)
  IN3 w0.061: v3(175.76,44.97) 175.76,45.15 175.64,45.27 172.78,45.27 172.56,45.49 171.09,45.49 170.59,44.99 169.55,44.99 169.51,44.95 v4(169.25,44.95)
  BOTTOM w0.069: UC1.DT30 v4(169.25,44.95)
MEM_CONFIG3: length 4.7
  TOP w0.069: RH185.1 RH615.2
  BOTTOM w0.069: v4(173.02,45.97) 172.97,45.97 172.95,45.99 v1(172.64,45.99) 171.39,45.99 171.11,45.72 169.57,45.72 UC1.DT29
MEM_CONFIG4: length 8.1
  TOP w0.069: RH616.2 177.21,44.51 RH665.1 v3(176.49,44.51)
  IN3 w0.061: v3(176.49,44.51) 176.21,44.23 173.31,44.23 173.11,44.43 172.59,44.43 172.45,44.28 170.17,44.28 170.14,44.31 v4(170.14,44.34)
  BOTTOM w0.069: UC1.DV30 170.16,44.36 v4(170.14,44.34)
MEM_INTERLEAVED: length 4.1
  BOTTOM w0.069: RH629.1 RH630.1 173.24,53.59 170.5,53.59 170.23,53.85 UC1.DV11
MERGED_TRST_PD: length 6.4
  TOP w0.069: JMIPI60.8 92.38,72.62 92.17,72.84 92.04,72.84 91.63,73.25 v3(91.61,73.25)
  IN3 w0.061: v4(89.8,74.54) 90.31,74.54 v3(91.61,73.25)
  BOTTOM w0.069: v4(89.8,74.54) 89.8,74.34 89.6,74.13 88.86,74.13 v1(88.36,73.63)
MIC2-VREFO-L: length 3.3
  TOP w0.203: v5(261.93,65.91) 261.93,65.75 261.61,65.43 UA1.28
  BOTTOM w0.381: v5(261.93,65.91) 262.09,66.07 v1(262.09,66.44) RA2.1
MIC2-VREFO-R:
  vias: v1(261.43,66.21)
MIPI60_CFG0#: length 92.5
  TOP w0.069: v2(97.12,70.05) 97.5,69.66 97.5,68.01 96.53,67.05 95.59,67.05 95.38,66.84 JMIPI60.19 95.38,64.9 94.01,63.52 94.01,62.95 93.7,62.64 R140.2 v2(93.69,61.96) 93.69,61 93.97,60.72 95.7,60.72 95.85,60.57 95.85,59.58 95.37,59.1 95.37,47.6 95.47,47.5 R160.2
  IN1 w0.061: v2(93.69,61.96) 93.69,61.94 94.02,61.61 v3(94.6,61.61) ; v2(97.12,70.05) 95.16,72 95.16,72.81 95.44,73.09 99.9,73.09 101.56,74.75 v4(101.56,75.25)
  IN3 w0.061: v4(134.86,55.67) 134.89,55.64 134.89,55.19 132.96,53.26 127.98,53.26 127.5,53.74 124.3,53.74 123.72,54.31 114.65,54.31 114.24,53.9 107.04,53.9 104.01,56.93 104.01,61.15 102.21,62.94 100.88,62.94 100.56,63.26 98.59,63.26 97.88,62.55 96,62.55 95.57,62.12 95.11,62.12 v3(94.6,61.61)
  BOTTOM w0.069: v4(134.86,55.67) 134.86,55.86 UC1.AG6 ; v1(99.07,75.35) 99.28,75.56 101.28,75.56 101.56,75.28 v4(101.56,75.25)
MIPI60_CFG1#: length 69.9
  TOP w0.069: JMIPI60.21 95.88,64.7 95.42,64.23 95.24,64.23 94.65,63.64 94.65,62.96 R141.2 v2(94.32,61.96) 94.32,61.08 94.43,60.98 95.82,60.98 96.08,60.72 96.08,59.52 95.57,59.01 95.57,48.12 96.03,47.67 R161.2
  IN1 w0.061: v2(94.32,61.96) 94.57,62.2 94.6,62.2 v3(94.6,62.2)
  IN3 w0.061: v3(94.6,62.2) 94.73,62.32 95.49,62.32 96.13,62.96 97.09,62.96 97.79,63.65 100.72,63.65 101.04,63.34 102.37,63.34 104.4,61.31 104.4,57.1 107.2,54.3 114.08,54.3 114.49,54.71 126.64,54.71 127.13,54.22 127.63,54.22 128.2,53.65 132.54,53.65 134.42,55.53 v4(134.42,55.69)
MIPI60_CFG2#: length 53.7
  TOP w0.069: v2(94.96,61.96) R142.2 95.28,62.96 95.28,63.71 96.38,64.82 JMIPI60.23
  IN1 w0.061: v2(94.96,61.96) 94.97,61.96 v3(95.21,61.71)
  IN3 w0.061: v3(95.21,61.71) 95.44,61.71 96.08,62.35 97.96,62.35 98.67,63.06 100.48,63.06 100.79,62.75 102.13,62.75 103.81,61.07 103.81,56.85 106.95,53.7 114.32,53.7 114.73,54.11 123.64,54.11 124.21,53.54 127.42,53.54 127.9,53.06 133.04,53.06 135.34,55.36 v4(135.34,55.69)
MIPI60_CFG3#: length 51.3
  TOP w0.069: v2(95.59,61.96) R143.2 95.91,62.96 95.91,63.86 96.88,64.83 JMIPI60.25
  IN1 w0.061: v3(96.51,63.38) 95.59,62.46 v2(95.59,61.96)
  IN3 w0.061: v4(133.51,55.04) 133.18,55.04 132.83,55.39 132.27,55.39 132.06,55.18 130.02,55.18 129.89,55.31 128.59,55.31 128.06,55.84 126.19,55.84 125.79,56.24 120.48,56.24 120.07,56.65 119.44,56.65 118.5,55.7 114.08,55.7 113.66,55.29 109.19,55.29 108.56,55.92 107.5,55.92 105.95,57.46 105.95,60.64 105.45,61.14 105.45,62.02 102.84,64.63 101.3,64.63 100.78,64.11 97.26,64.11 96.53,63.38 v3(96.51,63.38)
MIPI60_CFG4#: length 55.6
  TOP w0.069: v3(96.23,61.96) 96.23,62.64 96.54,62.96 96.54,63.63 97.38,64.47 JMIPI60.27
  IN1 w0.061: v3(96.23,61.96) 97.17,62.9 v3(97.54,62.9)
  IN2 w0.051: v3(96.23,61.96) 96.23,62.73 95.06,63.9 v4(95.01,63.9)
  IN3 w0.061: v4(134.02,54.75) 132.72,53.45 128.12,53.45 127.55,54.02 127.05,54.02 126.56,54.51 114.57,54.51 114.16,54.1 107.12,54.1 104.2,57.01 104.2,61.23 102.29,63.14 100.96,63.14 100.64,63.46 98.1,63.46 v3(97.54,62.9)
  BOTTOM w0.069: UC1.AE9 134.31,55.04 v4(134.02,54.75) ; v1(93.97,65.37) 94.22,65.12 R144.2 94.98,63.92 v4(95.01,63.9)
MIPI60_CFG5#: length 49.7
  TOP w0.069: JMIPI60.29 97.88,64.23 97.5,63.85 97.5,63.09 97.88,62.7 R145.2 v2(97.88,62.01)
  IN1 w0.061: v2(97.88,62.01) 97.88,63.31 v3(97.42,63.77)
  IN3 w0.061: v4(132.59,55.04) 132.54,54.98 129.94,54.98 129.81,55.11 128.4,55.11 128.01,55.5 114.16,55.5 113.75,55.09 108.29,55.09 108.14,55.24 108.14,55.64 108.06,55.72 106.9,55.72 106.54,56.08 106.54,56.21 106.66,56.33 106.66,56.46 106.57,56.55 106.44,56.55 106.32,56.43 106.19,56.43 106.1,56.52 106.1,56.65 106.22,56.78 106.22,56.91 106.13,57 106,57 105.87,56.88 105.74,56.88 105.2,57.42 105.2,62 102.76,64.43 101.39,64.43 100.81,63.85 97.5,63.85 v3(97.42,63.77)
MIPI60_CFG6#: length 51.2
  TOP w0.069: JMIPI60.31 98.38,63.95 98.26,63.82 98.26,63.09 98.64,62.7 R146.2 v2(98.64,62.01)
  IN1 w0.061: v3(99.25,62.56) 98.86,62.17 98.81,62.17 v2(98.64,62.01)
  IN3 w0.061: v3(99.25,62.56) 99.55,62.86 100.29,62.86 100.55,62.6 100.55,62.32 100.85,62.02 101.49,62.02 101.64,62.17 102.14,62.17 103.41,60.9 103.41,56.68 106.92,53.17 115.23,53.17 115.49,53.43 118.38,53.43 118.57,53.63 123.56,53.63 124.05,53.14 127.25,53.14 127.73,52.66 133.2,52.66 135.78,55.23 135.78,55.34 v4(135.8,55.36)
  BOTTOM w0.069: UC1.AJ6 135.8,55.89 v4(135.8,55.36)
MIPI60_CFG7#: length 49.7
  TOP w0.069: v2(100.04,61.96) R147.2 99.66,63.02 99.66,63.57 98.88,64.34 JMIPI60.33
  IN1 w0.061: v3(100.17,64.44) 100.04,64.32 v2(100.04,61.96)
  IN3 w0.061: v4(132.59,55.69) 132.16,55.69 131.86,55.38 130.1,55.38 129.97,55.51 128.67,55.51 128.14,56.04 126.27,56.04 125.88,56.44 122.72,56.44 122.62,56.53 122.62,56.9 122.53,56.99 122.4,56.99 122.31,56.9 122.31,56.53 122.22,56.44 122.09,56.44 121.99,56.53 121.99,56.9 121.9,56.99 121.77,56.99 121.68,56.9 121.68,56.53 121.59,56.44 121.46,56.44 121.36,56.53 121.36,56.9 121.27,56.99 121.14,56.99 121.05,56.9 121.05,56.53 120.96,56.44 120.68,56.44 120.26,56.86 119.38,56.86 118.42,55.9 114.75,55.9 114.52,56.12 107.57,56.12 106.15,57.55 106.15,60.72 105.65,61.22 105.65,62.1 104.32,63.43 104.32,64.11 103.61,64.83 101.22,64.83 100.84,64.44 v3(100.17,64.44)
MIPI60_CFG8#: length 70.1
  TOP w0.069: v1(108.93,49.18) 109.36,49.61 R168.2 110.02,50.81 104.06,56.77 103.41,56.77 100.39,59.78 100.39,61.87 100.67,62.15 v2(100.67,62.64) 100.67,62.66 100.36,62.98 100.36,63.53 99.38,64.5 JMIPI60.35
  IN1 w0.061: v2(100.67,62.64) 100.67,65.39 101.03,65.74 101.5,65.74 101.6,65.65 101.6,65.29 101.69,65.19 101.82,65.19 101.91,65.29 101.91,65.65 102,65.74 102.13,65.74 102.23,65.65 102.23,65.29 102.32,65.19 102.45,65.19 102.54,65.29 102.54,65.65 102.63,65.74 103.05,65.74 103.19,65.6 103.19,64.99 102.86,64.66 101.44,64.66 101.28,64.51 101.28,63.86 v3(101.18,63.75)
  IN3 w0.061: v3(101.18,63.75) 101.36,63.57 101.69,63.57 102.16,64.03 102.6,64.03 104.8,61.83 104.8,57.26 107.37,54.69 113.91,54.69 114.32,55.11 127.85,55.11 128.24,54.71 129.65,54.71 129.97,54.39 v4(130.76,54.39)
MIPI60_CFG9#: length 66.4
  TOP w0.069: JMIPI60.37 99.88,64.61 101,63.5 101,62.96 R149.2 101.31,62.2 v2(101.06,61.94) 100.62,61.51 100.62,59.84 103.5,56.97 104.15,56.97 110.66,50.46 R169.2
  IN1 w0.061: v3(101.06,62.37) v2(101.06,61.94)
  IN3 w0.061: v4(135.73,56.86) 135.73,55.67 135.54,55.48 135.54,55.27 133.12,52.86 127.81,52.86 127.33,53.34 124.13,53.34 123.64,53.83 115.47,53.83 115.15,53.51 106.87,53.51 103.61,56.77 103.61,60.98 102.22,62.37 101.06,62.37 v3(101.06,62.37)
  BOTTOM w0.069: v4(135.73,56.86) 135.85,56.99 UC1.AJ5
MIPI60_CFG10#: length 68.6
  TOP w0.069: v1(112.36,49.8) 112.17,49.61 R170.2 111.29,50.12 104.23,57.18 103.58,57.18 100.83,59.93 100.83,61.21 101.94,62.32 v2(101.94,62.64) 101.62,62.96 101.62,63.51 100.38,64.75 JMIPI60.39
  IN1 w0.061: v3(101.63,63.98) 101.69,63.92 101.69,63.44 101.92,63.21 102.43,63.21 102.73,63.52 102.73,63.86 103.67,64.79 103.92,64.79 104.34,64.38 104.34,64.04 103.38,63.09 102.93,63.09 102.49,62.64 v2(101.94,62.64)
  IN3 w0.061: v3(101.63,63.98) 101.88,64.23 102.68,64.23 105,61.91 105,57.34 107.3,55.04 107.53,55.04 107.63,55.14 107.63,55.37 107.72,55.47 107.85,55.47 107.94,55.37 107.94,55.14 108.19,54.89 113.83,54.89 114.24,55.3 127.93,55.3 128.32,54.91 129.73,54.91 129.94,54.7 131.21,54.7 131.53,54.39 v4(131.68,54.39)
MIPI60_CFG11#: length 49.8
  TOP w0.069: v2(102.58,61.96) R151.2 102.26,62.97 102.26,62.98 102.26,62.98 102.26,63.47 102.03,63.7 101.82,63.7 100.88,64.63 JMIPI60.41
  IN1 w0.061: v3(101.92,61.79) 102.08,61.96 v2(102.58,61.96)
  IN3 w0.061: v3(101.92,61.79) 102.24,61.79 103.21,60.82 103.21,56.6 106.84,52.98 115.31,52.98 115.57,53.24 118.46,53.24 118.66,53.43 119.02,53.43 119.11,53.34 119.11,53.27 119.2,53.18 119.33,53.18 119.43,53.27 119.43,53.34 119.52,53.43 119.65,53.43 119.74,53.34 119.74,53.27 119.83,53.18 119.96,53.18 120.06,53.27 120.06,53.34 120.15,53.43 120.28,53.43 120.37,53.34 120.37,53.27 120.46,53.18 120.59,53.18 120.69,53.27 120.69,53.34 120.78,53.43 120.91,53.43 121,53.34 121,53.27 121.09,53.18 121.22,53.18 121.32,53.27 121.32,53.34 121.41,53.43 123.48,53.43 123.97,52.95 127.02,52.95 128.13,51.83 133.01,51.83 135.05,53.87 135.05,54.11 135.95,55.02 135.95,55.13 136.25,55.43 v4(136.25,55.69)
MIPI60_CFG12#: length 70.4
  TOP w0.069: R172.2 117.68,55.33 116.24,53.89 v1(115.46,53.89) 115.18,53.61 110.33,53.61 104.79,59.15 104.64,59.15 103.21,60.58 v2(103.21,62.64) 102.9,62.96 102.9,63.48 102.48,63.9 102.09,63.9 101.38,64.61 JMIPI60.43
  IN1 w0.061: v3(102.3,63.7) 103.59,64.99 104,64.99 104.53,64.46 104.53,63.96 v2(103.21,62.64)
  IN3 w0.061: v3(102.3,63.7) 102.69,63.31 102.94,63.31 103.04,63.21 103.04,62.96 103.13,62.86 103.39,62.86 103.48,62.76 103.48,62.51 103.58,62.41 103.83,62.41 103.93,62.32 103.93,62.07 104.03,61.97 104.28,61.97 104.38,61.87 104.38,61.62 104.6,61.39 104.6,57.18 107.28,54.5 113.99,54.5 114.41,54.91 127.02,54.91 127.12,54.81 127.12,54.52 127.21,54.42 127.34,54.42 127.43,54.52 127.43,54.81 127.52,54.91 127.76,54.91 128.16,54.51 128.6,54.51 128.69,54.42 128.69,53.96 128.79,53.87 128.89,53.87 128.98,53.96 128.98,54.4 129.1,54.51 129.57,54.51 130.04,54.04 130.28,54.04 130.44,53.89 130.6,53.89 130.75,54.04 130.91,54.04 131.07,53.89 131.23,53.89 131.38,54.04 131.54,54.04 131.7,53.89 132.1,53.89 v4(132.59,54.39)
MIPI60_CFG13#: length 72
  TOP w0.069: JMIPI60.45 101.88,64.57 102.27,64.18 102.53,64.18 102.99,63.72 103.32,63.72 103.53,63.51 103.53,62.96 R153.2 v2(103.85,61.96) 103.42,61.53 103.42,60.66 104.73,59.36 104.87,59.36 110.41,53.82 114.54,53.82 115.22,54.5 116.36,54.5 v1(116.53,54.67) 117.67,55.8 118.76,55.8 119.11,55.45 R173.2
  IN1 w0.061: v3(102.12,61.28) 102.45,61.28 103.13,61.96 v2(103.85,61.96)
  IN3 w0.061: v3(102.12,61.28) 102.54,60.86 102.54,56.71 106.77,52.48 111.68,52.48 111.9,52.26 124.53,52.26 124.85,51.94 127.29,51.94 127.8,51.42 133.41,51.42 135.55,53.56 136.09,53.56 136.28,53.76 136.28,54.4 136.67,54.78 v4(136.67,55.19)
  BOTTOM w0.069: UC1.AL7 v4(136.67,55.19)
MIPI60_CFG14#: length 51.3
  TOP w0.069: v2(104.48,61.96) R154.2 104.16,62.96 104.16,63.48 103.7,63.95 103.16,63.95 102.71,64.41 102.58,64.41 102.38,64.6 JMIPI60.47
  IN1 w0.061: v2(104.48,61.96) 104,61.47 103.08,61.47 102.33,60.72 102.29,60.72 v3(102.21,60.64)
  IN3 w0.061: v3(102.21,60.64) 102.21,56.77 106.69,52.29 111.6,52.29 111.82,52.06 124.44,52.06 124.76,51.74 127.2,51.74 127.71,51.23 133.49,51.23 135.6,53.33 136.62,53.33 137.17,53.89 v4(137.17,55.04)
MIPI60_CFG15#: length 50.7
  TOP w0.069: JMIPI60.49 102.88,64.64 103.34,64.18 103.76,64.18 104.37,63.57 104.7,63.57 104.81,63.46 104.81,62.96 R155.2 R175.1 105.45,61.63 105.45,60.88 105.4,60.83 v2(104.18,60.83)
  IN1 w0.061: v3(102.88,60.57) 103.14,60.83 v2(104.18,60.83)
  IN3 w0.061: v3(102.88,60.57) 102.88,56.66 106.85,52.68 111.76,52.68 111.98,52.46 117.96,52.46 118.46,52.95 121.48,52.95 121.76,53.23 123.38,53.23 123.87,52.75 126.94,52.75 128.06,51.62 133.08,51.62 135.24,53.79 135.24,54.03 v4(136.25,55.04)
MIPI60_CFG_STB0_DN: length 0.8
  IN1 w0.061: v3(130.5,56.61) 130.62,56.48 v2(130.9,56.48)
  IN3 w0.061: v3(130.5,56.61) v4(130.76,56.34)
MIPI60_CFG_STB0_DP: length 49.2
  TOP w0.069: JMIPI60.13 93.88,64.37 v2(93.77,64.25)
  IN1 w0.061: v3(95.77,63.87) 95.39,64.25 v2(93.77,64.25)
  IN3 w0.061: v4(130.76,55.69) 130.64,55.81 129.85,55.81 129.35,56.3 126.39,56.3 125.29,57.4 125.18,57.4 125.11,57.33 125.11,56.8 125.02,56.71 124.89,56.71 124.8,56.8 124.8,57.28 124.68,57.4 123.98,57.4 123.89,57.3 123.89,56.8 123.8,56.71 123.67,56.71 123.58,56.8 123.58,57.3 123.48,57.4 119.44,57.4 118.21,56.16 114.92,56.16 114.7,56.39 107.69,56.39 106.41,57.66 106.41,60.83 105.92,61.33 105.92,62.21 104.59,63.54 104.59,64.23 103.72,65.09 99.46,65.09 98.88,64.52 97.3,64.52 96.65,63.87 v3(95.77,63.87)
MIPI60_CFG_STB1_DN: length 2
  TOP w0.069: v2(131.66,56.53) 131.66,56.61 v1(132.3,57.24)
  IN1 w0.061: v3(131.28,56.71) 131.46,56.53 v2(131.66,56.53)
  IN3 w0.061: v3(131.28,56.71) 131.41,56.58 131.43,56.58 v4(131.68,56.34)
MIPI60_CFG_STB1_DP: length 49.5
  TOP w0.069: JMIPI60.59 105.38,64.83 105.93,64.28 v2(106.24,64.28)
  IN1 w0.061: v2(106.24,64.28) 106.24,63.63 106.15,63.54 106.02,63.54 105.65,63.91 105.52,63.91 105.42,63.82 105.42,63.69 105.8,63.32 105.8,63.19 104.91,62.3 104.23,62.3 103.95,62.58 103.95,62.78 104.21,63.04 104.34,63.04 104.65,62.74 104.78,62.74 104.87,62.84 104.87,62.97 104.57,63.27 104.57,63.4 104.66,63.49 104.79,63.49 105.09,63.19 105.22,63.19 105.31,63.28 105.31,63.41 105.01,63.71 105.01,64.12 v3(105.12,64.23)
  IN3 w0.061: v4(131.68,55.69) 131.29,56.08 129.96,56.08 129.45,56.58 127.09,56.58 126.91,56.76 126.91,56.94 126.58,57.27 125.79,57.27 125.39,57.68 119.34,57.68 118.32,56.65 117.66,56.65 117.63,56.62 117.63,56.5 117.57,56.43 117.39,56.43 117.32,56.5 117.32,56.59 117.25,56.65 117.08,56.65 117,56.58 117,56.5 116.93,56.43 116.75,56.43 116.69,56.5 116.69,56.59 116.62,56.65 116.44,56.65 116.37,56.58 116.37,56.51 116.3,56.43 116.14,56.43 116.06,56.52 116.06,56.59 115.99,56.65 115.63,56.65 115.56,56.59 115.56,56.52 115.47,56.43 115.34,56.43 115.25,56.52 115.25,56.59 115.19,56.65 107.8,56.65 106.68,57.77 106.68,60.94 106.18,61.44 106.18,61.66 106.27,61.75 106.8,61.75 106.9,61.85 106.9,61.98 106.8,62.07 106.27,62.07 106.18,62.16 106.18,62.29 106.27,62.38 106.8,62.38 106.9,62.48 106.9,62.61 106.8,62.7 106.27,62.7 106.18,62.79 106.18,63.34 105.92,63.6 105.79,63.6 105.53,63.34 105.4,63.34 105.31,63.43 105.31,63.56 105.57,63.83 105.57,63.96 105.3,64.23 v3(105.12,64.23)
MIPI60_CPU_JTAG_TCLK: length 47.5
  TOP w0.069: v6(130.54,57.55) 130.29,57.55 130.11,57.73 129.25,57.73 v2(128.87,57.35)
  IN1 w0.061: v2(89.88,62.64) 92.1,64.86 97.06,64.86 v3(97.45,65.24) ; v2(128.87,57.35) v3(128.61,57.6)
  IN3 w0.061: v4(128.81,58.04) 128.81,57.8 v3(128.61,57.6) 128.06,58.16 127.72,58.16 126.36,59.52 112.21,59.52 111.96,59.77 110.32,59.77 108.74,61.35 108.74,62.44 106.82,64.36 106.82,64.78 105.62,65.98 104.47,65.98 104.43,66.02 97.92,66.02 97.45,65.55 v3(97.45,65.24)
MIPI60_CPU_JTAG_TDI: length 40.8
  TOP w0.069: R191.2 90.51,61.1 v2(90.31,60.9) ; v6(127.12,56.66) 126.91,56.86 v5(126.43,56.86) 126.43,56.66 RC146.1
  IN1 w0.061: v3(99.71,59.25) 99.69,59.24 92.02,59.24 90.35,60.9 v2(90.31,60.9)
  IN2 w0.051: v3(99.71,59.25) 100.47,58.49 105.51,58.49 106.47,57.52 110.85,57.52 111.25,57.12 121.62,57.12 122,57.5 125.79,57.5 v5(126.43,56.86)
  BOTTOM w0.069: v5(126.43,56.86) 126.63,57.06 UC1.K5
MIPI60_CPU_JTAG_TDO: length 51.3
  IN1 w0.061: v3(107.63,64.66) 106.62,65.67 106.62,66.91 106.47,67.06 105.93,67.06 105.39,67.61 104.99,67.61 104.67,67.93 102.77,67.93 102.63,67.8 99.2,67.8 97.94,69.05 96.56,69.05 94.21,71.41 90.24,71.41 89.09,72.56 89.09,74.15 v2(88.84,74.4)
  IN3 w0.061: v3(107.63,64.66) 107.66,64.69 107.88,64.69 112.45,60.11 126.69,60.11 127.11,59.69 128.08,59.69 v4(128.1,59.67)
  BOTTOM w0.069: RC150.1 128.1,59.67 v4(128.1,59.67) 127.53,59.67 127.19,59.33 127.19,58 UC1.K3
MIPI60_CPU_JTAG_TMS: length 52.6
  IN1 w0.061: v3(104.43,67.05) 102.96,67.05 102.55,67.46 99.08,67.46 97.81,68.73 96.43,68.73 94.07,71.09 90.1,71.09 87.67,73.52 v2(87.67,74.4)
  IN3 w0.061: v3(104.43,67.05) 104.84,66.64 105.8,66.64 107.44,65 107.8,65 112.52,60.28 126.75,60.28 127.1,59.93 128.62,59.93 128.66,59.89 v4(128.84,59.89)
  BOTTOM w0.069: RC181.1 129.82,61.57 129.07,60.83 129.07,60.11 v4(128.84,59.89) 129.07,59.66 129.07,58.23 129.15,58.16 129.15,57.9 128.81,57.57 UC1.P4
MIPI60_CPU_JTAG_TRST#: length 44
  IN1 w0.061: v3(94.63,62.91) 93.05,62.91 92.47,62.32 92.1,62.32 v2(91.78,62.64)
  IN3 w0.061: v3(94.63,62.91) 94.65,62.93 94.65,65.06 97,67.41 97.61,67.41 97.96,67.76 101.56,67.76 102.88,66.45 104.6,66.45 104.64,66.41 105.8,66.41 107.25,64.95 107.25,64.53 107.62,64.17 108.17,64.17 112.39,59.95 126.62,59.95 127.04,59.52 127.88,59.52 128.25,59.15 v4(128.25,59.02)
MIPI60_DBRESET#: length 3.5
  TOP w0.069: R236.2 90.78,73.02 91.17,73.02 91.35,72.84 91.66,72.84 91.88,72.61 JMIPI60.6
MIPI60_DBRESET#_R: length 104
  TOP w0.069: v1(174.18,55.85) 174.18,55.54 v2(174.08,55.44) RC430.1 171.03,55.44 170.91,55.31 UC29.1
  IN1 w0.061: v2(174.08,55.44) 173.34,56.18 170.66,56.18 170.02,56.82 168.6,56.82 v3(168.44,56.66) ; v3(100.9,68.29) 100.57,68.62 98.83,68.62 98.08,69.38 96.7,69.38 94.34,71.74 90.38,71.74 89.88,72.23 89.88,72.89 89.98,72.99 v2(89.98,74.4) 89.52,74.86 v3(89.52,74.87)
  IN2 w0.051: v3(100.9,68.29) 101.54,67.66 101.54,65.14 102.86,63.82 102.86,63.3 107.39,58.78 111.52,58.78 111.93,58.36 118.68,58.36 121.56,61.24 128.98,61.24 129.02,61.21 138.61,61.21 139.04,60.77 142.04,60.77 142.19,60.93 147.66,60.93 148.91,59.68 153.26,59.68 153.96,58.99 156.99,58.99 157.74,58.23 163.18,58.23 165.14,56.28 168.06,56.28 v3(168.44,56.66)
  IN3 w0.061: v3(89.52,74.87) 89.19,74.54 v4(89.19,74.53)
  BOTTOM w0.069: R176.2 v4(89.19,74.53)
MIPI60_HOOK2_CPU_BOOT_STALL: length 5.9
  TOP w0.069: v5(100.8,75.18) 100.74,75.12 100.74,74.14 R246.2 100.42,73.65 99.88,73.12 JMIPI60.38
  BOTTOM w0.069: R230.1 101.06,75.18 v5(100.8,75.18) 100.72,75.18 v1(100.14,74.59)
MIPI60_MBP0#: length 29.2
  TOP w0.069: R195.2 R274.2 107.06,61.96 107.68,61.33 107.68,60.6 110.71,57.58 110.71,55.68 111.45,54.93 116.27,54.93 v1(117.26,55.92) 117.51,56.18 v3(119.94,56.18)
  IN3 w0.061: v4(125.69,55.87) 120.25,55.87 v3(119.94,56.18)
  BOTTOM w0.069: UC1.T9 129.7,55.19 125.92,55.19 125.69,55.42 v4(125.69,55.87)
MIPI60_MBP0#_R: length 4.3
  TOP w0.069: JMIPI60.55 104.38,64.68 104.61,64.46 105.42,64.46 105.78,64.1 105.98,64.1 106.42,63.66 106.59,63.66 R195.1
MIPI60_MBP1#: length 30.1
  TOP w0.069: v2(109.64,54.96) 109.64,57.19 106.08,60.76 106.08,61.76 106.27,61.96 R178.2 R194.2
  IN1 w0.061: v2(109.64,54.96) 109.73,54.96 109.74,54.95 113.73,54.95 114.15,55.38 120.39,55.38 120.93,55.92 v2(123.64,55.92) v4(129.02,55.92)
  BOTTOM w0.069: v4(129.02,55.92) 129.61,55.92 UC1.T7
MIPI60_MBP1#_R: length 4.2
  TOP w0.069: JMIPI60.53 103.88,64.65 104.48,64.05 105.46,64.05 105.74,63.77 105.84,63.77 R194.1
MIPI60_OVERRIDE#: length 110.7
  TOP w0.069: v2(177.69,47.29) 178.22,47.82 178.22,48.1 UC8.6 ; UC11.6 144.03,60.73 v1(144.32,60.44) v3(144.87,59.89) ; v3(93.05,61.96) R335.1
  IN1 w0.061: v3(169.25,50.31) 169.3,50.31 169.76,49.85 170.86,49.85 172.51,48.2 174.11,48.2 174.7,47.61 175.34,47.61 175.61,47.34 177.64,47.34 v2(177.69,47.29)
  IN2 w0.051: v3(93.05,61.96) 93.73,61.28 95.49,61.28 95.9,60.88 97.3,60.88 97.88,61.46 98.79,61.46 99.58,60.67 100.67,60.67 101.39,59.96 105.11,59.96 106.79,58.29 111.16,58.29 111.56,57.89 119.37,57.89 121.78,60.29 126.84,60.29 127.31,60.76 128.11,60.76 129.13,59.73 130.17,59.73 130.63,59.28 131.89,59.28 132.2,59.58 135.19,59.58 136.18,60.57 138.29,60.57 138.85,60.01 140.88,60.01 142,58.89 143.7,58.89 144.01,59.2 144.01,59.35 144.54,59.89 v3(144.87,59.89) 146.01,59.89 146.6,60.47 147.13,60.47 148.52,59.07 153.01,59.07 153.7,58.38 156.14,58.38 158.77,55.75 160.52,55.75 162.02,57.24 163.11,57.24 165.22,55.13 168.28,55.13 168.49,55.35 168.49,55.59 168.8,55.89 169.3,55.89 170.53,54.66 170.53,53.06 169.43,51.96 169.43,50.49 v3(169.25,50.31)
  IN3 w0.061: v3(93.05,61.96) 92.67,61.57 92.67,60.88 92.75,60.81 v4(92.75,60.55)
MIPI60_PCH_JTAG_TCLK: length 31
  TOP w0.069: v3(129.05,56.94) 129.05,56.94 RC180.1 ; R193.2 105.62,62.51 105.62,60.69 109.23,57.07 v2(109.23,55.39) ; v2(119.72,55.75) 120.14,55.34 v6(120.26,55.34)
  IN1 w0.061: v2(109.23,55.39) 109.29,55.33 113.59,55.33 114,55.75 119.72,55.75 v2(119.72,55.75) 119.93,55.75 119.95,55.77 120.26,55.77 120.99,56.5 128.61,56.5 v3(129.05,56.94)
  IN3 w0.061: v4(129.38,57.06) 129.17,57.06 v3(129.05,56.94)
MIPI60_PCH_JTAG_TDI: length 53.2
  TOP w0.069: v6(118.25,63.24) 118.25,63.01 117.69,62.45 117.69,62.1 117.44,61.85 v3(117.44,61.33)
  IN1 w0.061: v3(92.93,64.33) 92.24,64.33 90.55,62.64 v2(90.51,62.64)
  IN3 w0.061: v4(126.95,61.06) 126.79,60.89 126.74,60.89 126.61,60.77 123.9,60.77 120.61,64.05 119.72,64.05 119.6,63.92 119.6,62.3 119.01,61.71 117.82,61.71 v3(117.44,61.33) 116.87,60.77 112.72,60.77 108.8,64.69 108.8,65.35 108.56,65.59 108.56,66.15 108.4,66.3 107.84,66.3 107.72,66.43 107.4,66.43 107.22,66.26 106.93,66.26 106.67,66.52 106.67,67.04 105.52,68.19 102.96,68.19 102.02,69.13 98.01,69.13 97.3,68.42 95.67,68.42 95.39,68.14 95.39,67.43 92.93,64.97 v3(92.93,64.33)
  BOTTOM w0.069: RC151.1 127.51,61.08 126.97,61.08 v4(126.95,61.06) 126.95,60.73 126.94,60.72 126.94,59.35 126.9,59.32 UC1.K1
MIPI60_PCH_JTAG_TDO: length 52.7
  TOP w0.069: v3(119.25,62.93) v6(120.15,62.93)
  IN1 w0.061: v2(89.42,74.4) 89.5,74.33 89.5,72.38 90.31,71.57 94.28,71.57 96.63,69.22 98.01,69.22 99.27,67.96 102.56,67.96 102.7,68.09 104.79,68.09 105.11,67.77 105.59,67.77 106.14,67.23 106.54,67.23 107.03,66.73 107.03,66.67 v3(107.01,66.65)
  IN3 w0.061: v4(126.38,61.06) 126.25,60.93 123.99,60.93 120.66,64.25 119.5,64.25 119.37,64.13 119.37,63.04 v3(119.25,62.93) 118.5,62.93 116.5,60.93 112.79,60.93 109.91,63.81 109.91,64.9 109.39,65.42 108.95,65.42 108.76,65.62 108.76,66.18 108.47,66.46 107.91,66.46 107.78,66.59 107.07,66.59 v3(107.01,66.65)
  BOTTOM w0.069: RC202.1 v4(126.38,61.06) 126.55,60.89 126.55,58.76 126.9,58.4 UC1.K2
MIPI60_PCH_JTAG_TMS: length 56.5
  TOP w0.069: v6(119.47,65.24) 119.94,64.78 v3(119.94,63.71)
  IN1 w0.061: v3(104.59,67.53) 104.36,67.77 102.99,67.77 102.86,67.63 99.13,67.63 97.87,68.89 96.5,68.89 94.14,71.25 90.17,71.25 88.25,73.17 v2(88.25,74.4)
  IN3 w0.061: v3(104.59,67.53) 104.88,67.82 105.18,67.82 106.24,66.76 106.24,66.43 107.51,65.16 107.87,65.16 112.59,60.44 118.3,60.44 119.94,62.08 v3(119.94,63.71) 119.98,63.75 120.61,63.75 123.92,60.44 126.82,60.44 127.17,60.09 128.52,60.09 v4(128.61,60.19)
  BOTTOM w0.069: UC1.N3 128.42,57.89 128.42,58.09 128.56,58.23 128.56,60.14 v4(128.61,60.19) 128.61,61.01 RC203.1
MIPI60_PCH_JTAG_TRST#: length 47.2
  TOP w0.069: v6(126.68,59.56) 126.68,59.43 127.37,58.74 127.37,57.96 127.81,57.52 v5(127.81,57.51) 128.22,57.09 RC201.1
  IN1 w0.061: v2(91.78,61.37) 92.38,61.97 92.52,61.97 93.1,62.55 94.92,62.55 95.36,63 v3(95.36,63)
  IN3 w0.061: v5(127.81,57.51) 127.62,57.69 127.62,57.79 126.68,58.74 124.93,58.74 124.42,59.26 112.07,59.26 111.82,59.5 110.17,59.5 108.42,61.26 108.42,62.14 104.85,65.71 104.36,65.71 104.32,65.75 98.06,65.75 97.85,65.55 97.85,64.89 97.75,64.79 97.09,64.79 96.64,64.33 95.57,64.33 95.36,64.13 v3(95.36,63)
  BOTTOM w0.069: UC1.N5 v5(127.81,57.51)
MIPI60_PCH_JTAGX: length 47
  TOP w0.069: CC737.1 128.19,58.6 v2(128.2,58.61)
  IN1 w0.061: v3(127.78,58.57) 127.9,58.69 128.13,58.69 v2(128.2,58.61) ; v2(89.24,62.64) 91.73,65.13 96.49,65.13 v3(97.02,65.65)
  IN3 w0.061: v4(128.25,58.37) 127.93,58.69 127.89,58.69 v3(127.78,58.57) 127.74,58.62 127.64,58.62 126.47,59.79 112.32,59.79 112.07,60.04 110.43,60.04 109.01,61.46 109.01,62.55 107.09,64.47 107.09,64.89 105.73,66.24 104.58,66.24 104.54,66.28 102.81,66.28 101.5,67.6 98.96,67.6 v3(97.02,65.65)
MIPI60_PRDY#: length 47.3
  TOP w0.069: v2(93.44,67.23) 93.38,67.18 JMIPI60.11
  IN1 w0.061: v2(93.44,67.23) 94.06,66.6 97.06,66.6 98.22,65.43 v3(98.22,65.27)
  IN3 w0.061: v4(127.93,56.86) 127.7,57.09 127.62,57.09 127.01,57.7 125.97,57.7 125.5,58.17 124.99,58.17 124.42,58.74 123.15,58.74 122.8,58.39 119.45,58.39 118.14,57.08 107.97,57.08 107.11,57.95 107.11,61.19 107.33,61.41 107.91,61.41 108.14,61.64 108.14,62.19 104.78,65.55 104.29,65.55 104.25,65.59 98.4,65.59 98.22,65.41 v3(98.22,65.27)
  BOTTOM w0.069: v4(127.93,56.86) 128.08,56.71 128.37,56.71 UC1.P6
MIPI60_PREQ#: length 52.6
  TOP w0.069: v2(93.03,67.23) 92.44,67.81 92.44,69.56 92.88,70 JMIPI60.10 92.88,72.5 91.57,73.82 R112.2
  IN1 w0.061: v3(98.73,65.25) 98.74,65.25 98.74,65.21 98.36,64.84 98.03,64.84 97.84,65.03 97.84,65.59 96.99,66.44 93.82,66.44 v2(93.03,67.23)
  IN3 w0.061: v3(98.73,65.25) 98.74,65.25 98.77,65.25 98.89,65.36 104.19,65.36 104.29,65.26 104.75,65.26 107.16,62.84 107.16,61.69 106.95,61.47 106.95,57.88 107.9,56.92 118.21,56.92 119.27,57.98 125.46,57.98 125.91,57.54 126.87,57.54 127.22,57.19 v4(127.22,56.86)
  BOTTOM w0.069: UC1.M6 127.72,56.71 127.37,56.71 v4(127.22,56.86)
MIPI60_PRESENT1#: length 3.8
  TOP w0.069: R188.2 93.07,63.87 93.78,63.87 94.38,64.48 JMIPI60.15
MIPI60_PRESENT2#: length 3.5
  TOP w0.069: R335.2 93.5,63.67 93.82,63.67 94.88,64.74 JMIPI60.17
MIPI60_SPI0_IO2: length 111.7
  TOP w0.069: v1(166.03,38.73) 165.67,38.73 v2(165.52,38.57) 165.31,38.57 RH634.1
  IN1 w0.061: v3(165.8,38.96) 165.52,38.68 v2(165.52,38.57) ; v2(92.42,62.64) 92.42,62.96 92.9,63.44 95.85,63.44 96.56,64.15 98.81,64.15 100.85,66.18 104.94,66.18 v3(105.55,65.58)
  IN2 w0.051: v3(105.55,65.58) 105.55,63.26 108.92,59.89 112.1,59.89 112.51,59.48 118.1,59.48 121.67,63.05 129.19,63.05 129.64,62.6 133.87,62.6 134,62.48 141.32,62.48 141.53,62.27 144.74,62.27 145.15,62.68 147.6,62.68 148.08,62.2 148.39,62.2 149.64,60.95 159.93,60.95 160.75,60.14 163.84,60.14 164.82,59.16 167.42,59.16 168.05,58.54 169.15,58.54 169.3,58.54 172.37,55.46 172.37,50.87 172.45,50.78 172.45,49.22 172.25,49.02 172.25,46.76 170.07,44.57 170.07,44.53 168.82,43.28 168.82,42.47 166.23,39.88 166.23,39.72 165.8,39.29 v3(165.8,38.96)
MIPI60_SPI0_MOSI: length 112.6
  TOP w0.069: R261.2 98.52,74.97 v3(98.52,74.4)
  IN1 w0.061: v2(163.15,37.36) 163.24,37.27 v3(163.58,37.27)
  IN2 w0.051: v3(98.52,74.4) 98.85,74.73 99.77,74.73 101.61,72.89 101.61,70.08 102.65,69.04 102.65,65.77 104.59,63.83 104.59,62.9 107.77,59.71 112.02,59.71 112.44,59.3 118.17,59.3 121.74,62.87 128.01,62.87 128.23,62.64 128.23,62.53 128.43,62.33 133.89,62.33 133.93,62.3 141.25,62.3 141.53,62.02 148.32,62.02 149.57,60.77 159.86,60.77 160.67,59.96 163.77,59.96 164.75,58.98 167.35,58.98 167.97,58.36 169.22,58.36 172.19,55.39 172.19,50.79 172.28,50.71 172.28,49.29 172.07,49.09 172.07,46.83 169.89,44.64 169.89,44.6 168.64,43.36 168.64,42.55 166.15,40.05 165.9,40.05 165.42,39.57 165.42,38.42 165.24,38.24 164.45,38.24 163.58,37.37 v3(163.58,37.27)
MIPI60_TCLK: length 4
  TOP w0.069: JMIPI60.3 91.38,64.44 90.82,63.87 90.53,63.87 R190.1 R244.1
MIPI60_TCLK1: length 4.1
  TOP w0.069: R193.1 105.19,63.79 104.44,63.79 103.77,64.46 103.54,64.46 103.38,64.62 JMIPI60.51
MIPI60_TDI: length 4.7
  TOP w0.069: R191.1 90.19,62.28 90.19,62.9 R312.1 91.88,64.6 JMIPI60.5
MIPI60_TDO: length 4.4
  TOP w0.069: JMIPI60.4 91.38,72.48 91.02,72.84 89.85,72.84 89.42,73.27 R156.1 R201.1
MIPI60_TMS: length 5.9
  TOP w0.069: JMIPI60.2 90.88,72.52 90.73,72.67 89.4,72.67 R247.1 R300.1 87.36,73.51 v5(87.36,72.76)
MIPI60_TRST#: length 4.5
  TOP w0.069: JMIPI60.9 92.88,64.74 91.78,63.64 R192.1 91.77,63.23 91.47,62.92 91.47,62.27 R213.1
MODE_1.1V_MEM: length 1.7
  BOTTOM w0.203: PR707.1 100.8,12.13 100.8,12.26 100.42,12.65 PU700.14
MONO_IN: length 2.1
  IN1 w0.254: v2(259.21,64.39) 258.78,64.39 v3(258.69,64.48)
  IN3 w0.254: v4(259.17,64.28) 258.89,64.28 v3(258.69,64.48)
  BOTTOM w0.069: v4(259.17,64.28) 259.17,65.02 v1(259.02,65.17)
MSCLK: length 71.1
  IN1 w0.061: v3(183.93,16.65) v2(183.93,16.99)
  IN3 w0.061: v4(240.83,12.58) 240.89,12.64 v4(242.11,12.64) 242.43,12.32 242.43,11.93 242.14,11.64 241.06,11.64 239.07,9.65 227.42,9.65 v3(226.81,9.03) 226.43,8.66 225.25,8.66 224.79,8.19 220.8,8.19 220.46,8.53 216.24,8.53 215.92,8.84 214.75,8.84 214.05,8.14 206.28,8.14 205.42,8.99 197.93,8.99 196.87,7.94 195.16,7.94 194.83,8.27 192.19,8.27 192.17,8.29 191.48,8.29 189.79,9.99 189.79,10.67 188.65,11.81 186.46,11.81 185.5,12.77 185.5,14.93 185.32,15.11 185,15.11 184.94,15.05 184.52,15.05 184.27,15.31 184.27,16.33 183.95,16.65 v3(183.93,16.65)
  BOTTOM w0.069: v4(240.83,12.58) 240.83,12.71 241.11,12.99 JDEG1.6
MSDATA: length 69.1
  IN1 w0.061: v2(183.13,17.79) v3(183.12,17.8)
  IN3 w0.061: v4(242.11,12.01) 240.91,12.01 238.91,10.01 225.86,10.01 224.82,8.97 216.31,8.97 216.07,9.21 214.6,9.21 213.9,8.5 206.72,8.5 205.86,9.36 v3(205.66,9.36) 197.78,9.36 197.07,8.65 191.63,8.65 190.15,10.14 190.15,10.83 188.81,12.17 186.61,12.17 185.86,12.92 185.86,15.08 184.63,16.32 184.63,16.48 184,17.11 183.81,17.11 v3(183.12,17.8)
  BOTTOM w0.069: v4(242.11,12.01) 241.79,12.33 241.66,12.33 RE205.1 241.61,12.77 JDEG1.7
MUX_L_ENA_R: length 1.7
  TOP w0.069: UM1.16 33.47,65.72 RM2.2
MUX_L_ENB_R: length 4.3
  TOP w0.069: UM1.10 29.11,65.72 28.79,65.4 28.79,63.62 RM1.2 28.73,63.41 28.21,63.92 v1(28.21,64.38)
MUX_L_FLIP#: length 45.8
  TOP w0.069: RM13.1 34.5,63.59 v1(33.8,62.88) 33.31,62.4 30.69,62.4 v2(30.27,62.82)
  IN1 w0.061: v2(30.27,62.82) 29.8,62.35 24.07,62.35 v3(23.64,62.78)
  IN3 w0.061: v3(23.64,62.78) 24.26,62.16 24.26,61.5 25.31,60.44 25.31,59.58 24.99,59.26 24.99,57.91 24.6,57.52 22.16,57.52 21.1,56.46 21.1,47.22 22.87,45.45 22.87,43.3 24.49,41.67 27.83,41.67 28.07,41.92 v4(30.3,41.92)
  BOTTOM w0.069: RPD129.1 RPD128.1 v4(30.3,41.92)
MUX_L_FLIP#_R: length 1.9
  BOTTOM w0.069: RPD127.2 30.3,41 30.29,41 30.29,40.88 30.21,40.79 UPD1.41
MUX_L_SAI: length 3.7
  TOP w0.069: RM13.2 33.61,63.7 32.45,63.7 32.14,64 v1(31.71,64) 31.69,64 31.31,64.38 UM1.14
MUX_L_SBI: length 1.8
  TOP w0.069: RM14.2 30.51,63.64 UM1.12
MUX_R_ENA_R: length 3.9
  BOTTOM w0.069: UM2.16 277.66,56.03 277.39,55.75 RM18.2 277.25,53.84 v1(276.42,54.67)
MUX_R_ENB_R: length 3.6
  BOTTOM w0.069: UM2.10 281.93,56.03 v1(281.98,55.97) 281.98,55.75 281.2,54.97 RM17.2
MUX_R_FLIP#: length 26.7
  TOP w0.069: RPD137.1 RPD136.1 v2(260.1,44.26)
  IN1 w0.061: v2(260.1,44.26) 260.46,44.26 v3(260.52,44.21)
  IN3 w0.061: v3(260.52,44.21) 261.61,44.21 262.56,45.16 268.74,45.16 269.41,45.82 270.95,45.82 271.66,46.53 271.66,47.42 272.7,48.46 272.7,48.9 275.31,51.5 v4(275.31,52.8)
  BOTTOM w0.069: RM16.1 279.5,52.82 279.1,52.82 RM15.1 278.12,52.72 275.39,52.72 v4(275.31,52.8)
MUX_R_FLIP#_R: length 1.9
  TOP w0.069: RPD135.2 260.2,43.59 UPD2.41
MUX_R_SAI: length 1.7
  BOTTOM w0.069: UM2.14 279.02,54.21 RM15.2
MUX_R_SBI: length 1.6
  BOTTOM w0.069: UM2.12 279.82,53.95 RM16.2
NB_LID#: length 60.6
  TOP w0.069: v3(194.43,7.56) 194.4,7.56 192.95,6.11 v6(192.95,5.05) 192.95,3.19 192.69,2.93 DE3.1 191.58,2.72 DE1.1 189.5,2.72 188.39,3.83 186.58,3.83 186.12,4.29 UE6.2 ; v5(212.92,2) 212.82,2 212.35,1.53 ULID1.3
  IN2 w0.051: v4(224.8,6.88) 224.8,7.08 224.68,7.21 223.27,7.21 222.89,6.82 198.57,6.82 198.37,6.62 197.87,6.62 196.73,7.76 194.63,7.76 v3(194.43,7.56)
  BOTTOM w0.069: v4(224.8,6.88) 224.8,4.79 223.94,3.93 214.72,3.93 214.42,3.62 214.42,3.57 212.92,2.08 v5(212.92,2)
NB_LID#_FPR: length 2.2
  BOTTOM w0.069: v1(255.64,38.88) R808.1 255.7,37.94 JFP1.3
NB_MUTE#: length 138
  TOP w0.069: v1(267.83,55.19) 267.45,54.81 v2(266.66,54.81)
  IN1 w0.061: v2(266.66,54.81) 266.51,54.65 v3(265.72,54.65)
  IN2 w0.051: v3(265.72,54.65) 265.7,54.63 263.21,54.63 261.96,53.38 256.27,53.38 255.08,52.19 255.08,49.48 258.19,46.37 259.88,46.37 261.1,45.15 261.1,43.49 260.49,42.88 v3(260.49,42.49)
  IN3 w0.061: v3(179.13,22.59) 179.54,23 180.58,23 181.09,22.5 185.76,22.5 188.12,20.14 188.12,17.86 188.52,17.45 188.52,16.37 193.04,11.86 193.29,11.86 193.54,12.11 193.81,12.11 193.89,12.04 194.99,12.04 195.35,11.68 212.74,11.68 213.72,12.66 220.03,12.66 220.77,13.4 228.73,13.4 230.29,14.96 238.73,14.96 244.31,20.54 245.26,20.54 245.46,20.73 246.42,20.73 247.36,21.67 247.66,21.67 249.7,23.71 251.46,23.71 253.05,25.3 253.58,25.3 254,25.72 256.42,25.72 256.73,26.03 258.05,26.03 259.9,27.87 259.9,29.55 260.77,30.42 260.77,32.43 260.25,32.95 260.25,35.99 259.47,36.77 259.47,41.64 260.31,42.49 v3(260.49,42.49)
NRB_BIT: length 15.2
  IN1 w0.061: v2(161.7,31.31) 161.32,31.69 159.78,31.69 159.09,32.38 v3(159.09,32.71)
  IN3 w0.061: v4(153.87,36.23) 154.02,36.08 154.28,36.08 154.69,35.67 155.5,35.67 155.77,35.4 156.95,35.4 158.11,34.23 158.11,33.69 v3(159.09,32.71)
  BOTTOM w0.069: v4(153.87,36.23) 154.1,36 UC1.CF48 154.1,35.66 153.15,34.71 153.15,34.71 152.06,33.62 151.37,33.62 RH621.1
OT_1.1V_MEM: length 3.4
  TOP w0.069: v1(99.99,14.42) 100.37,14.42 v5(100.65,14.7)
  TOP w0.203: v5(100.65,14.7) 100.65,14.57 100.93,14.29 100.93,13.33 PR702.2
  BOTTOM w0.203: PU700.11 100.53,14.15 100.65,14.27 v5(100.65,14.7)
P_DET#: length 39.1
  TOP w0.069: v4(163.47,62.09) 163.47,61.32 164.45,60.34 164.45,57.57 165.57,56.45 v1(165.57,54.22) 165.57,53.48 166.71,52.34 166.71,51.88 164.82,49.99 164.82,48.04 162.9,46.12 159.53,46.12 v2(158.48,47.16)
  IN1 w0.061: v3(155.63,37.45) 155.36,37.71 155.36,40.76 155.79,41.19 156.3,41.19 156.68,41.57 156.68,44.42 158.48,46.22 v2(158.48,47.16)
  IN3 w0.061: v3(155.63,37.45) 155.42,37.24 v4(155.34,37.24)
  BOTTOM w0.069: RC749.2 162.65,61.77 162.98,62.09 v4(163.47,62.09) 163.42,62.14 163.42,62.89 163.69,63.17 163.69,64 163.8,64.11 JUFC1.9
P_INT#: length 48.4
  TOP w0.069: v5(170.08,59.85) v1(170.44,59.48)
  IN2 w0.051: v3(172.8,44.09) 172.66,44.23 172.66,46.12 172.99,46.45 172.99,48.04 173.58,48.63 173.58,51.27 173.42,51.43 173.42,56.51 v5(170.08,59.85)
  IN3 w0.061: v4(182.33,44.21) 182.04,44.21 181.84,44.41 177.9,44.41 177.67,44.18 176.94,44.18 176.83,44.07 172.82,44.07 v3(172.8,44.09) 172.79,44.08 169.6,44.08 v4(169.41,44.27)
  BOTTOM w0.069: RC738.1 181.82,43.47 181.82,43.47 181.9,43.55 181.9,43.55 182.13,43.78 RC741.1 182.16,43.78 182.16,44.04 v4(182.33,44.21) ; v4(169.41,44.27) 169.41,44.04 169.15,43.78 169.15,43.17 169.25,43.07 170.24,43.07 170.49,42.83 UC1.DW34 ; v5(170.08,59.85) 170.08,60.84 167.96,62.96 167.96,65.27 168.14,65.45 168.14,65.8 167.88,66.06 166.79,66.06 166.46,65.73 165.27,65.73 164.28,64.74 163.21,64.74 163.1,64.63 JUFC1.13
P_SENSOR_PWR_SAVE#: length 19.1
  TOP w0.069: v2(165.37,50.16) 165.37,50.3 166.88,51.81 166.88,52.41 165.97,53.33 165.97,56.29 164.78,57.48 v1(164.78,58.77) 164.78,60.47 163.98,61.28 v4(163.98,62.04)
  IN1 w0.061: v3(165.32,49.57) 165.37,49.62 v2(165.37,50.16)
  IN3 w0.061: v3(165.32,49.57) 165.19,49.45 165.19,48.4 v4(165.43,48.16)
  BOTTOM w0.069: JUFC1.7 164.15,64.08 164.04,63.97 164.04,62.98 163.98,62.92 v4(163.98,62.04) 163.55,61.61 RC748.2
PANEL_BKEN_EC: length 41.4
  TOP w0.069: v2(183.48,16.55) 183.45,16.53 183.45,16.51 UE1.J9
  IN1 w0.061: v3(183.43,23.28) 182.97,22.83 182.97,20.9 183.29,20.58 183.29,19.96 183.48,19.76 v2(183.48,16.55)
  IN3 w0.061: v3(183.43,23.28) 183.43,23.65 183.83,24.05 186.6,24.05 187.93,25.38 188.77,25.38 189.92,26.53 190.18,26.53 190.89,27.24 191.57,27.24 192.81,28.48 v4(192.97,28.48)
  BOTTOM w0.069: v4(192.97,28.48) 193.46,28.97 193.46,29.25 194.58,30.37 196.61,30.37 197.92,29.06 198.89,29.06 200.62,27.33 200.62,23.19 201.52,22.29 202.53,22.29 202.86,21.96 202.86,19.86 203.37,19.35 204.4,19.35 D2.2 205.04,19.99 v1(205.04,20.29)
PANEL_BKLEN: length 59.2
  IN1 w0.061: v3(175.6,46.98) 175.48,46.86 174.84,46.86 173.83,47.86 172.39,47.86 170.93,49.32 168.72,49.32 168.21,49.83 167.55,49.83 167.4,49.98 166.87,49.98 v2(166.54,49.65) 166.26,49.93 v3(166.26,50.15)
  IN2 w0.051: v3(175.6,46.98) 175.43,46.8 175.43,44.28 178.75,40.96 179.74,40.96 179.74,40.96 180.35,40.96 184.32,37 184.32,36.02 184.81,35.53 185.54,35.53 186.94,34.13 190.93,34.13 191.97,33.09 194.52,33.09 196.34,31.27 196.34,30.36 199.81,26.89 199.81,23.91 204.88,18.84 v4(204.88,18.52)
  IN3 w0.061: v4(166.73,49.99) 166.37,49.99 166.26,50.11 v3(166.26,50.15)
  BOTTOM w0.069: D2.3 205.74,18.96 205.31,18.52 v4(204.88,18.52)
PANEL_MONITOR: length 173.5
  TOP w0.069: v4(113.17,70.96) 113.17,70.22 109.82,66.87 109.03,66.87 108.34,66.18 108.34,65.38 108.74,64.97 108.74,61.2 112.36,57.58 v3(112.36,55.67) 112.84,55.67 113.3,56.13 v1(115.69,56.13)
  IN1 w0.061: v3(182.33,14.95) v2(182.33,13.79)
  IN2 w0.051: v3(182.33,14.95) 181.93,14.95 181.65,15.23 181.65,17.51 180.88,18.28 175.11,18.28 174.66,18.73 171.43,18.73 169.86,20.3 169.86,23.68 166.66,26.88 161.23,26.88 160.4,27.7 115.48,27.7 114.08,26.31 110.84,26.31 110.46,25.93 107.59,25.93 107.16,25.49 101.92,25.49 101.11,26.31 96.52,26.31 89.73,33.1 89.73,48.89 94.48,53.64 94.48,55.71 95.53,56.76 97.16,56.76 97.61,56.3 109.49,56.3 109.86,55.94 109.86,55.47 110.29,55.03 111.78,55.03 112.36,55.61 v3(112.36,55.67)
PANEL_PWRGD:
  vias: v1(112.84,71.8)
PBAT_CHARGER_SMBCLK: length 191.1
  TOP w0.069: UE1.N2 177.66,12.86 177.66,12.35 176.96,11.64 176.96,11.03 176.96,11.03 176.96,10.96 v2(176.74,10.74) ; v4(36.97,23.56) 36.97,23.08 v1(36.16,22.27) 34.87,20.98 34.87,20.98 34.7,20.81 34.7,20.81 34.23,20.34 34.23,20.18 33.8,19.75 33.8,15 33.62,14.83 32.98,14.83 v2(32.81,15)
  IN1 w0.061: v2(32.81,15) 32.65,14.85 31.87,14.85 31.26,14.24 31.26,11.98 30.41,11.13 30.41,7.75 31.02,7.13 32.64,7.13 33,6.77 33,6.57 33.38,6.19 33.38,5.3 33.19,5.11 33.19,4.31 v2(33.13,4.26) 33.25,4.14 33.25,3.58 33.95,2.89 37.75,2.89 38.59,3.73 39.07,3.73 39.51,4.17 40.04,4.17 40.43,4.56 41.35,4.56 42.37,5.58 92.56,5.58 96.09,2.05 113.82,2.05 114.43,2.66 121.43,2.66 121.83,3.07 122.38,3.07 122.91,2.53 127.77,2.53 130.48,5.25 157.48,5.25 158.79,3.94 158.79,3.16 159.44,2.51 163.17,2.51 164.42,3.76 170.34,3.76 171.29,4.71 175.64,4.71 176.88,5.95 178.85,5.95 179.16,6.27 179.16,7.94 177.79,9.31 177.79,10.71 177.48,11.02 177.25,11.02 176.98,10.74 v2(176.74,10.74)
  BOTTOM w0.069: PR195.2 38.07,22.68 37.9,22.85 PD104.2 37.69,23.56 v4(36.97,23.56)
PBAT_CHARGER_SMBDAT: length 190
  TOP w0.069: UE1.M3 177.87,13.33 177.87,12.28 177.15,11.56 177.15,11.11 177.15,10.96 v2(177.37,10.74) ; v2(32.83,14.57) 32.89,14.63 33.7,14.63 33.99,14.92 33.99,19.67 v1(34.99,20.67) 37.34,23.02 37.34,23.12 v4(37.38,23.16)
  IN1 w0.061: v2(32.83,14.57) 32.74,14.66 31.94,14.66 31.44,14.16 31.44,11.9 30.6,11.05 30.6,7.83 31.1,7.32 32.71,7.32 33.19,6.85 33.19,6.65 33.57,6.26 33.57,5.22 33.37,5.03 33.37,4.66 33.65,4.39 33.78,4.39 v2(33.91,4.26) 33.8,4.26 33.44,3.9 33.44,3.66 34.03,3.08 37.67,3.08 38.51,3.92 38.99,3.92 39.43,4.36 39.97,4.36 40.35,4.75 41.27,4.75 42.29,5.77 92.63,5.77 96.16,2.24 113.74,2.24 114.36,2.85 121.35,2.85 121.75,3.25 122.46,3.25 122.99,2.72 127.69,2.72 130.4,5.44 157.56,5.44 158.98,4.02 158.98,3.23 159.52,2.69 163.09,2.69 164.34,3.94 170.26,3.94 171.21,4.9 175.56,4.9 176.81,6.14 178.77,6.14 178.97,6.34 178.97,7.86 177.6,9.24 177.6,10.52 v2(177.37,10.74)
  BOTTOM w0.069: v4(37.38,23.16) 37.19,22.97 PD104.3 37.82,22.65 37.93,22.54 PR196.2
PBAT_PRES#: length 64.6
  TOP w0.069: v4(212.08,4.03) 212.08,4.11 211.78,4.41 199.6,4.41 197.9,2.71 v1(194.48,2.71) 194.45,2.71 193.8,3.36 RE521.2 193.56,4.27 193.56,6.32 v2(194.3,7.05)
  IN1 w0.061: v2(183.13,18.59) 182.77,18.23 182.77,16.87 183.58,16.06 183.58,13.89 183.74,13.73 183.74,11.32 184.32,10.74 184.32,9.96 184.9,9.38 184.9,7.21 185.18,6.93 185.18,6.08 185.65,5.6 187.65,5.6 188.17,6.12 188.5,6.12 189.12,6.74 192.82,6.74 193.13,7.05 v2(194.3,7.05)
  BOTTOM w0.069: QE23.1 208.8,17.06 208.8,12.51 210.15,11.17 211.76,11.17 212.3,10.62 212.3,6.92 212.45,6.77 212.45,5.27 212.08,4.89 v4(212.08,4.03)
PCH_3.3V_TS_EN: length 91.7
  IN2 w0.051: v3(157.21,37.51) 157.21,37.74 156.99,37.97 156.99,38.87 157.96,39.84 158.5,39.84 160.29,41.64 160.29,42.66 161.39,43.76 163.11,43.76 163.24,43.89 163.24,44.57 164.56,45.89 164.56,46.83 164.69,46.97 164.69,50.76 163.01,52.44 162.38,52.44 160.3,54.53 156.11,54.53 155.53,55.11 152.44,55.11 151.65,55.9 v3(150.1,55.9)
  IN3 w0.061: v3(150.1,55.9) 150.25,56.05 150.25,57.3 150.71,57.76 150.71,58.68 147.87,61.53 147.87,62.55 147.62,62.8 147.04,62.8 145.93,61.69 141.7,61.69 141.14,62.25 137.34,62.25 137,61.91 133.7,61.91 133.55,62.06 129.23,62.06 129.08,61.9 126.43,61.9 126.34,61.99 125.69,61.99 125.54,61.84 123.41,61.84 119.85,65.4 116.43,65.4 114.81,66.06 114.18,66.69 110.86,66.69 110.49,67.06 108.71,67.06 108.44,66.79 108.06,66.79 107.36,67.48 v4(106.82,67.48) ; v4(155.97,36.91) 156.32,37.25 156.96,37.25 v3(157.21,37.51)
  BOTTOM w0.069: R672.1 105.54,68.76 v4(106.82,67.48)
PCH_BATLOW#: length 2.9
  BOTTOM w0.069: RH460.1 165.03,33.52 164.94,33.62 164.94,35.22 165.05,35.34 165.05,35.67 UC1.DH48
PCH_DMIC_CLK12: length 33.7
  TOP w0.069: R634.1 187.26,45 187.26,44.21 186.72,43.68 186.72,41.54 185.7,40.52 185.7,39.29 185.77,39.22 185.85,39.22 185.98,39.09 v3(186.01,39.09) ; v1(170.65,41.95) 170.52,42.08 169.7,42.08 v2(169.64,42.02) 168.99,42.02 RH705.2
  IN1 w0.061: v3(188.02,36.49) 187.69,36.83 187.28,36.83 187.03,37.08 184.29,37.08 183.32,38.05 182.25,38.05 180.43,39.87 173.19,39.87 173.04,40.02 170.83,40.02 170.05,40.8 170.05,41.08 169.41,41.73 169.41,41.79 v2(169.64,42.02)
  IN2 w0.051: v3(188.02,36.49) 187.8,36.72 187.8,37.02 186.01,38.8 v3(186.01,39.09)
PCH_DMIC_DATA12: length 31.4
  TOP w0.069: R655.1 187.06,45 187.06,44.29 186.53,43.76 v7(186.53,43.35) 186.53,41.62 185.51,40.6 v3(185.51,39.09)
  IN1 w0.061: v2(168.95,41.34) 169.17,41.57 169.3,41.57 169.86,41 169.86,40.72 170.75,39.83 172.96,39.83 173.11,39.68 180.35,39.68 182.18,37.86 183.24,37.86 184.21,36.89 186.96,36.89 187.21,36.64 187.36,36.64 v3(187.51,36.49)
  IN2 w0.051: v3(187.51,36.49) 187.62,36.6 187.62,36.94 185.51,39.06 v3(185.51,39.09)
PCH_DPWROK: length 22.9
  TOP w0.069: v6(180,29.53) 180.35,29.53 v2(180.58,29.3) ; RE248.1 184.28,28.78 v2(184.21,28.72)
  IN1 w0.061: v4(179.5,29.02) 179.79,29.3 v2(180.58,29.3) 180.61,29.3 180.71,29.41 183.07,29.41 183.3,29.18 183.3,28.78 183.48,28.6 184.1,28.6 v2(184.21,28.72)
  BOTTOM w0.069: UC1.DR48 168.4,36.17 168.87,36.64 168.87,36.92 169.13,37.18 169.61,37.18 169.89,36.9 170.45,36.9 170.65,36.7 172.95,36.7 174.2,35.45 174.2,34.29 175.55,32.94 175.55,32.81 176.63,31.73 177.23,31.73 177.77,31.2 177.77,31.05 CH48.1 178.02,30.68 RH575.1 178.8,29.91 179.5,29.22 v4(179.5,29.02)
PCH_DPWROK_EC: length 12.4
  TOP w0.069: UE1.F8 181.95,18.97 181.95,19.58 182.11,19.73 v2(182.82,19.73) ; RE248.2 v2(184.6,27.81)
  IN1 w0.061: v2(182.82,19.73) 182.84,19.73 183.12,20.01 183.12,20.51 182.72,20.92 182.72,23.28 183.58,24.15 183.58,25.27 184.36,26.05 184.77,26.05 184.98,26.26 184.98,26.59 185.19,26.79 185.19,27.22 v2(184.6,27.81)
PCH_IST_TP_0: length 2.8
  TOP w0.069: TP66.1 v5(162.2,44.72)
  BOTTOM w0.069: UC1.CW33 160.75,43.74 161.34,44.33 161.81,44.33 v5(162.2,44.72)
PCH_IST_TP_1: length 3
  TOP w0.069: v5(162.58,45.29) 162.58,45.3 162.16,45.72 TP65.1
  BOTTOM w0.069: v5(162.58,45.29) 162.58,44.57 162.15,44.15 161.57,44.15 UC1.CY32
PCH_OPI_RCOMP: length 8.2
  BOTTOM w0.089: 170.42,57.37 170.07,57.37 169.89,57.54 169.73,57.54
  BOTTOM w0.102: 170.42,57.37 170.65,57.6 170.99,57.6 171.4,57.19
  BOTTOM w0.127: 170.52,56.89 171.1,56.89 171.4,57.19 ; UC1.DU3 169.73,57.54
  BOTTOM w0.152: 170.52,56.89 170.45,56.96 170.1,56.96 169.95,56.81 169.58,56.81 169.36,57.04 169.36,57.56 UC1.DU3
  BOTTOM w0.305: 171.4,57.19 171.85,57.19 172.51,57.85 RH5.1
PCH_PCIE_WAKE#: length 30.4
  TOP w0.069: v2(171.92,33.22) v1(171.92,33.8) 171.92,34.06 173.8,35.93 173.8,37.84 v5(173.73,37.92) ; v2(174.28,14.52) 174.28,14.34 RE186.2 175.2,14.59 UE1.L1
  IN1 w0.061: v2(174.28,14.52) 174.03,14.78 174.03,16.78 174.69,17.45 174.69,19.62 175.14,20.07 175.14,22.88 174.85,23.17 174.85,26.32 174.65,26.52 174.65,28.64 173.74,29.55 173.74,31.37 171.92,33.19 v2(171.92,33.22)
  BOTTOM w0.069: RH207.2 173.39,38.47 RH653.1 173.45,38.2 v5(173.73,37.92)
PCH_PLTRST#: length 31.2
  TOP w0.069: UH1.2 179.39,27.81 179.52,27.93 179.52,28.39 179.45,28.46 UH1.1 177.97,28.46 v1(177.91,28.4) 177.52,28.4 177.23,28.11 v3(177.15,28.11)
  IN2 w0.051: v4(157.49,34.18) 157.52,34.18 157.67,34.03 157.67,32.56 158.64,31.59 158.76,31.59 163.35,31.59 164.06,30.88 164.68,30.88 164.94,31.13 169,31.13 171.27,28.86 174.14,28.86 174.78,28.22 176,28.22 176.42,27.81 176.85,27.81 v3(177.15,28.11)
  BOTTOM w0.069: UC1.CM49 157.21,35.63 157.21,35.02 157.51,34.73 157.51,34.19 v4(157.49,34.18) 157.19,33.87 157.19,31.97 RH690.2
PCH_PLTRST#_EC: length 549.4
  TOP w0.069: v2(11.04,40.1) 13.58,40.1 14.49,41.01 14.49,42.99 14.9,43.4 18.82,43.4 19.55,44.14 v1(20.41,44.14) 22.34,44.14 23.15,43.33 24.43,43.33 v3(25.24,44.14) 27.27,44.14 32.55,49.42 v2(34.02,49.42) ; RH46.1 181.75,27.16 UH1.4 180.52,27.16 180.02,27.65 v3(180.02,28.54) ; v3(148.65,6.57) 149.26,7.18 RE193.1 ; RT163.2 272.01,47.81 v2(271.92,47.9)
  IN1 w0.061: v3(180.02,28.54) 180.31,28.26 180.31,24.56 179.71,23.96 179.71,23.73 178.75,22.78 178.75,21.18 178.88,21.05 178.88,20.29 v4(178.42,19.83) ; v2(271.92,47.9) 271.92,47.95 v3(271.44,48.43) ; v3(105.53,67) 105.17,66.64 100.68,66.64 98.63,64.59 93.67,64.59 93.05,63.97 92.48,63.97 v2(91.15,62.64) ; v4(36.44,49.61) 36.25,49.42 v2(34.02,49.42) ; v2(11.04,40.1) 10.89,40.25 10.48,40.25 v4(10.36,40.13) ; v3(258.87,43.53) 258.92,43.48 258.92,42.69 257.81,41.58 257.81,41.1 257.34,40.63 257.34,38.29 256.49,37.45 256.49,36.44 258.82,34.1 258.82,29.14 258.28,28.59 256.96,28.59 256.44,28.07 255.28,28.07 v3(255.1,27.9)
  IN2 w0.051: v3(105.53,67) 105.53,68.52 104.46,69.59 104.46,71.92 105.04,72.51 108.41,72.51 109.22,71.7 114.29,71.7 115.2,70.78 115.2,69.31 116.23,68.28 117,67.94 146.08,67.94 146.72,67.3 148.64,67.3 149.14,67.81 169.05,67.81 173.56,63.3 173.56,61.66 177.35,57.87 180.06,57.87 183.55,54.37 183.55,53.05 185.03,51.58 185.03,43.27 187.16,41.14 188.94,41.14 189.65,40.43 189.65,38.91 189.24,38.5 v4(189.24,38.47) ; v3(252.39,21.3) 252.41,21.27 252.41,20.85 252.64,20.62 252.64,19.42 250.2,16.97 250.2,14.85 247.25,11.9 246.67,11.9 246.24,11.47 246.24,10.89 244.2,8.86 242.98,8.86 241.59,7.46 228.03,7.46 227.78,7.71 223.06,7.71 222.91,7.56 215.93,7.56 215.49,7.99 211.08,7.99 210.57,7.49 199.51,7.49 198.39,8.6 195.62,8.6 195.09,8.07 187.12,8.07 186.91,7.86 186.91,7.75 186.66,7.51 186.44,7.51 185.82,8.13 181.79,8.13 180.24,6.58 v4(178.47,6.58) 178.03,6.13 171.87,6.13 171.33,6.67 150.28,6.67 150.18,6.57 v3(148.65,6.57) 115.94,6.57 115.13,5.76 109.33,5.76 108.06,4.49 102.55,4.49 101.49,5.55 94.44,5.55 93.12,6.88 80.61,6.88 80.11,7.38 74.68,7.38 74.12,6.82 62.72,6.82 62.25,7.29 42.28,7.29 41.14,6.15 41.14,6.08 40.24,5.17 39.09,5.17 38.48,4.56 34.41,4.56 34.13,4.28 31.48,4.28 31.13,4.64 31.13,4.87 30.21,5.79 30.21,11.57 30.82,12.18 30.82,15.23 31.43,15.84 31.43,16.93 30.82,17.54 30.82,18.73 29.86,19.69 29.86,28.5 32.93,31.58 32.93,37.95 31.21,39.68 31.21,41.38 29.64,42.94 26.43,42.94 v3(25.24,44.14)
  IN3 w0.061: v4(252.21,21.84) 252.21,21.47 252.39,21.3 v3(252.39,21.3) ; v3(271.44,48.43) 270.93,47.92 265.75,47.92 263.85,46.02 260.84,46.02 259.17,44.35 259.17,43.83 v3(258.87,43.53) ; v3(255.1,27.9) 255.1,27.75 254.11,26.76 251.95,26.76 v4(251.42,26.23) ; v4(189.24,38.47) 189.24,38.2 189.03,37.99 189.03,37.25 190.02,36.27 190.02,32.57 187.79,30.34 185.73,30.34 185.32,29.93 184.51,29.93 184.38,30.07 182.57,30.07 181.37,28.88 180.36,28.88 v3(180.02,28.54)
  BOTTOM w0.069: v4(189.24,38.47) 189.32,38.55 U712.17 ; UWL1.31 253.46,21.42 253.05,21.84 v4(252.21,21.84) 251.63,22.42 LED2.1 251.63,22.95 250.99,23.59 250.99,25.8 v4(251.42,26.23) ; UCR1.1 10.36,40.3 v4(10.36,40.13) ; v4(178.47,6.58) 178.35,6.71 178.35,10.99 178.6,11.24 178.6,15.45 178.99,15.84 178.99,19.26 v4(178.42,19.83) 179.01,20.41 180.25,20.41 180.52,20.15 JNGFF1.50
